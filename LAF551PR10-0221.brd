# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LPC_FRAME#: length 108
  TOP w0.089: v1(217.09,22.13) 217.36,22.4 v2(217.58,22.4)
  TOP w0.114: v2(302.55,20.67) 302.5,20.72 302.5,21.95 304.34,23.78 UE5.4
  IN3 w0.127: v2(217.58,22.4) 217.74,22.56 218.39,22.56 218.51,22.69 218.51,22.91 218.64,23.04 220.99,23.04 221.26,23.31 223.4,23.31 223.83,22.87 225.01,22.87 225.51,23.37 225.51,23.43 226.2,24.12 227.7,24.12 v2(229.02,22.8)
  IN6 w0.081: v2(302.55,20.67) 301.46,21.77 300.35,21.77 299.25,22.87 293.28,22.87 292.16,21.76 276.78,21.76 276.39,22.15 274.01,22.15 271.33,24.84 269.66,24.84 268.54,23.71 264.9,23.71 264.36,23.17 261.82,23.17 260.77,24.21 260.77,27.13 259.91,27.99 257.18,27.99 255.95,29.22 249.52,29.22 247.01,26.71 247.01,26.36 244.63,23.98 243.82,23.98 240.68,20.84 237.67,20.84 235.35,23.15 229.38,23.15 v2(229.02,22.8)
  BOTTOM w0.122: v2(217.58,22.4) 217.51,22.33 216.66,22.33 216.24,22.75 215.84,22.75 215.49,23.1 UH1.BE38
LX_1.0VS_VGAP: length 6.7
  TOP w0.102: v2(242.52,45.27) v1(243.23,45.27)
  IN3 w0.254: v2(243.07,40.45) 243.02,40.5 243.02,44.76 v2(242.52,45.27)
  BOTTOM w0.254: PU800.6 242.72,40.96 243.07,40.61 v2(243.07,40.45)
LX_3V: length 24.7
  IN4 w1.016: 50.24,28.06 51.93,29.75 53.67,29.75 54.68,30.77 54.68,32.25 54.17,32.76 54.17,36.63 59.44,41.9 59.44,44.44 57.28,46.6
  vias: v1(50.49,28.06) v2(44.71,27.74) v2(44.78,26.6) v2(44.97,27.17) v2(45.41,27.74) v2(45.47,26.6) v2(45.67,27.17) v2(46.05,27.74) v2(46.11,26.6) v2(46.3,27.17) v2(46.74,27.74) v2(46.74,26.6) v2(47,27.17) v2(47.38,27.74) v2(47.38,26.6) v2(47.63,27.17) v2(48.01,27.74) v2(48.01,26.6) v2(48.27,27.17) v2(48.65,27.74) v2(48.71,26.6) v2(48.9,27.17) v2(49.28,27.74) v2(49.35,26.6) v2(49.54,27.17) v2(56.26,47.56) v2(56.9,47.55)
LX_5V: length 9.7
  IN4 w1.016: 43.92,40.16 43.92,40.71 50,46.8 50.55,46.8
  vias: v1(40.88,36.58) v2(40.52,39.36) v2(40.84,38.85) v2(40.86,37.71) v2(41.09,38.28) v2(41.22,39.36) v2(41.18,37.19) v2(41.54,38.85) v2(41.5,37.71) v2(41.73,38.28) v2(41.86,39.36) v2(42.13,37.71) v2(42.17,38.85) v2(42.36,38.28) v2(42.38,35.97) v2(42.49,39.36) v2(42.73,35.49) v2(42.81,38.85) v2(42.83,37.71) v2(43.06,38.28) v2(43.13,39.36) v2(43.44,38.85) v2(43.7,38.28) v2(50.78,47.58) v2(51.37,47.57)
LX_+1.8VGS: length 6.7
  TOP w0.508: v2(230.67,39.94) 230.67,40.81 231.02,41.17 v1(231.02,44.36) v2(231.02,45.69)
  BOTTOM w0.254: v2(230.67,39.94) 230.52,40.09 PU802.6
LX_CHG: length 4.6
  IN1 w1.016: 65.73,23.99 64.46,25.26 61.67,25.26
  vias: v1(60.59,24.87) v2(60.97,25.26) v2(61.41,25.64) v2(65.92,22.6) v2(65.9,21.96) v2(66.49,21.96) v2(67.19,22.6) v2(67.83,22.6) v2(68.28,25.96) v2(68.27,22.09) v2(68.42,22.66) v2(68.72,25.45) v2(68.72,24.82) v2(68.72,24.18) v2(68.72,23.55) v2(68.93,22.98) v2(68.91,22.09) v2(69.41,22.41)
LX_VCCIO: length 7.7
  TOP w0.508: v2(120.34,120.32) v1(120.34,117.99) 120.34,114.23 v2(120.91,113.66)
  BOTTOM w0.254: v2(120.34,120.32) 120.71,119.95 PU509.6
ME_EN: length 118.1
  TOP w0.114: v2(223.27,30.93) 223.15,30.81 223.15,28.48 222.61,27.94 222.61,26.89 222.63,26.87 222.63,25.82 222.11,25.3 222.11,24.92 222.81,24.22 222.81,23.74 222.09,23.01 222.09,21.8 222.45,21.44 223.86,21.44 224.18,21.76 224.38,21.76 224.38,21.76 224.53,21.76 225.47,20.82 v2(225.94,20.82) ; v2(300.02,18.41) 300.02,17.05 301.05,16.02 301.05,15.97 304.61,12.41 UE5.99
  IN6 w0.081: v2(225.94,20.82) 226.73,20.82 227.44,20.1 229.42,20.1 229.53,19.99 231.1,19.99 231.32,20.21 235.16,20.21 236.64,18.73 241.6,18.73 242.34,17.99 244.58,17.99 246.4,19.81 246.4,22.58 250.13,26.31 256.11,26.31 260.73,21.69 264.97,21.69 265.52,22.23 266.58,22.23 267.17,21.65 271.65,21.65 272.63,20.67 275.77,20.67 276.17,20.28 292.98,20.28 293.35,19.91 297.35,19.91 298.41,18.85 299.89,18.85 300.02,18.72 v2(300.02,18.41)
  BOTTOM w0.114: v2(223.27,30.93) 223.27,30.99 223.69,31.41 223.69,32.71 223.59,32.81 v1(223.59,34.01) 223.59,34.67 222.76,35.5 222.76,37.5 222.42,37.84 RH16.1
ME_SUS_PWR_ACK: length 7.2
  BOTTOM w0.089: UH1.BC37 214.44,23.42 214.86,23.42 215.02,23.58 215.87,23.58 215.9,23.61 215.92,23.61 216.05,23.74 ; v1(218.82,23.33) 219.18,23.33
  BOTTOM w0.102: 219.18,23.33 219.55,23.33 RH506.1
  BOTTOM w0.122: 216.05,23.74 216.31,24.01 216.76,24.01 216.77,24 217.08,24 217.09,24.01 218.15,24.01 218.39,24.25 218.96,24.25 218.96,24.25 219.14,24.25 219.15,24.25 219.24,24.25 219.46,24.02 219.46,24.01 219.83,23.64 RH506.1
MEM_VDD_CTL: length 122.1
  IN3 w0.102: v2(212.02,60.13) 211.34,59.44 211.34,55.2 209.86,53.72 209.86,49.78 210.99,48.65 214.28,48.65 216.79,46.15 222.02,46.15 224.35,43.82 227.62,43.82 229.95,46.15 232.36,46.15 235.14,43.37 v2(235.14,40.88)
  IN4 w0.102: v2(212.02,60.13) 212.64,60.75 212.64,61.94 212.21,62.37 212.21,66.81 212.53,67.13 212.53,107.37 214.11,108.94 215.63,108.94 216.06,109.38 219.31,109.38 220.93,110.99 223.72,110.99 224.1,111.37 224.1,112 222.96,113.15 222.96,114.29 222.1,115.15 v2(221.37,115.15)
  BOTTOM w0.1: UG9.BH4 v2(221.37,115.15)
  BOTTOM w0.102: v2(235.14,40.88) 235.14,40.19 236.36,38.97 v1(236.36,38.24) 236.36,35.43 237.11,34.68 237.11,32.4 237.73,31.78 237.73,30.93 PR8214.1
MEM_VREF: length 255.7
  TOP w0.102: v2(191.72,101.76) 191.55,101.76 191.11,102.2 RG24.1
  IN3 w0.102: v2(228.02,52.37) 228.52,52.87 230.42,52.87 231.01,52.29 233.69,52.29 234.07,51.91 245.14,51.91 245.49,52.26 261.81,52.26 262.68,53.13 274.35,53.13 275.52,51.96 287.93,51.96 288.25,51.64 288.75,51.64 288.95,51.44 293.2,51.44 295.68,53.91 295.68,66.88 295.03,67.53 295.03,69.14 294.14,70.03 286.68,70.03 v2(284.69,68.05)
  BOTTOM w0.1: 213.69,105.84 214.77,106.92 214.77,109.92 215.34,110.49 215.34,111.4 215.69,111.75 217.1,111.75 217.29,111.94 218.54,111.94 218.75,112.16 219.18,112.16 219.35,112.33 219.9,112.33 220.22,112.65 UG9.BD3
  BOTTOM w0.102: 213.69,105.84 212.74,104.89 v1(212.44,104.89) 210.64,104.89 210.51,105.03 198.38,105.03 198,104.65 193.34,104.65 191.72,103.02 v2(191.72,101.76) 191.07,101.11 191.07,88.33 QG8.2 191.07,88.3 191.07,80.9 192.1,79.87 192.1,75.17 191.84,74.92 191.84,70.47 193.55,68.76 205.36,68.76 205.79,69.19 209.77,69.19 210.88,68.09 210.88,61.46 211.7,60.63 212.4,60.63 213.75,59.29 213.75,53.97 214.28,53.44 220.99,53.44 222.77,51.67 227.32,51.67 v2(228.02,52.37) 228.45,52.8 QG4.2
  BOTTOM w0.254: QG2.2 284.71,101.25 286.65,99.3 286.65,72.32 285.12,70.8 285.12,68.91 284.69,68.48 v2(284.69,68.05) 284.75,68 QG3.2
MIC1-VREFO_L: length 23
  TOP w0.254: RA28.1 27.25,23.8 v1(26.45,23) 25.66,22.22 v2(25.66,21.96)
  IN6 w0.254: v2(25.66,21.96) 25.66,21.9 25.15,21.39 24.71,21.39 23.96,22.14 23.96,26.41 23,27.37 23,30.27 23.96,31.23 v2(23.96,33.58)
  BOTTOM w0.203: UA1.38 28.1,33.31 28.04,33.37 24.99,33.37 24.73,33.1 24.44,33.1 v2(23.96,33.58)
  BOTTOM w0.254: v2(25.66,21.96) 25.66,21.45 RA26.1
MIC_CLK: length 308.4
  TOP w0.114: JEDP.23 162.62,181.38 162.53,181.28 162.53,178.18 163.19,177.52 163.19,176.06 162.51,175.38 162.51,173.66 v2(162.63,173.54) ; v2(161.25,167.44) 160.95,167.44 160.7,167.18 160.7,166.14 160.94,165.9 160.94,165.4 161.28,165.06 161.28,164.97 161.46,164.79 161.87,164.62 162.13,164.62 162.19,164.56 RV13.1
  IN1 w0.081: v2(105.42,30.72) 105.55,30.6 105.83,30.6 105.91,30.68 105.91,34.81 106.98,35.89 108.95,35.89 111.09,38.03 111.09,41.93 108.9,44.12 108.9,47.85 108.92,47.88 108.92,68.55 113.79,73.43 113.79,161.57 115.03,162.8 129.51,162.8 132.07,160.24 137.43,160.24 138.81,161.63 139.6,161.63 141.2,163.22 144.28,163.22 145.25,164.2 145.25,165.47 144.53,166.19 144.53,167.07 145.25,167.79 145.25,169 148.85,172.6 151.31,172.6 152.83,174.12 154.08,174.12 155.03,175.08 158.65,175.08 159.35,174.38 162.31,174.38 162.52,174.18 162.52,173.65 v2(162.63,173.54)
  IN3 w0.127: v2(162.63,173.54) 162.63,173.5 162.22,173.09 162.09,173.09 161.58,172.58 161.58,168.32 161.25,167.99 v2(161.25,167.44)
  IN6 w0.081: v2(36.58,38.15) 36.65,38.22 36.65,40.25 39.83,43.43 39.83,46.97 40.55,47.69 46.79,47.69 50.12,44.36 52.09,44.36 52.36,44.08 53.95,44.08 54.23,44.36 56.21,44.36 57.45,45.6 87.66,45.6 90.73,42.54 97.94,42.54 99.92,40.55 99.92,39.56 100.99,38.49 100.99,34.2 104.59,30.6 105.29,30.6 v2(105.42,30.72)
  BOTTOM w0.114: LA6.1 CA34.1 36.76,38.33 v2(36.58,38.15)
MIC_DATA: length 296.8
  TOP w0.114: v2(162.05,173.51) 162.26,173.72 162.26,175.48 162.95,176.16 162.95,177.42 162.29,178.08 162.29,181.38 162.12,181.55 JEDP.22
  IN1 w0.081: v2(105.42,30.09) 105.42,30.18 105.63,30.39 105.92,30.39 106.12,30.59 106.12,34.73 107.07,35.68 109.04,35.68 111.3,37.94 111.3,42.01 109.1,44.21 109.1,47.77 109.13,47.79 109.13,68.47 114,73.34 114,161.48 115.12,162.6 129.42,162.6 131.98,160.04 137.51,160.04 138.9,161.42 139.69,161.42 141.28,163.02 144.36,163.02 145.46,164.11 145.46,165.55 144.74,166.27 144.74,166.98 145.46,167.7 145.46,168.92 148.93,172.39 151.39,172.39 152.91,173.91 154.16,173.91 155.12,174.87 158.57,174.87 159.27,174.17 162.23,174.17 162.31,174.09 162.31,173.77 v2(162.05,173.51)
  IN6 w0.081: v2(105.42,30.09) 105.12,30.39 104.51,30.39 100.78,34.11 100.78,38.4 99.71,39.48 99.71,40.47 97.85,42.33 90.64,42.33 87.58,45.39 57.54,45.39 56.3,44.15 54.31,44.15 54.04,43.87 52.28,43.87 52,44.15 50.03,44.15 46.7,47.48 40.64,47.48 40.04,46.88 40.04,43.35 36.86,40.17 36.86,38.52 v2(37.22,38.15)
  BOTTOM w0.114: v2(37.22,38.15) 36.76,37.7 CA35.1 RA19.1
N17_ID0: length 9.6
  TOP w0.089: RH28.1 RH27.1 216,34.33 v2(216.38,34.71) 216.38,34.88 v1(216.1,35.16)
  IN4 w0.089: v2(210.23,33.23) 210.57,33.57 211.77,33.57 213.11,34.91 213.54,34.91 213.86,35.23 215.87,35.23 v2(216.38,34.71)
  BOTTOM w0.089: UH1.AR18 v2(210.23,33.23)
N17_ID1: length 5.9
  BOTTOM w0.089: UH1.BF14 215.85,35.08 217.03,35.08 217.12,34.99 218.31,34.99 v1(218.5,34.8) 218.81,34.49 219.18,34.49
  BOTTOM w0.102: 219.18,34.49 219.95,34.49 220.18,34.27 RH26.1 RH25.1
NC_B4: length 5.2
  TOP w0.089: UT1.B4 177.3,171.22 177.52,171.44 177.52,171.99 177.52,171.99
  TOP w0.107: 177.52,171.99 177.43,172.08 177.43,172.96 v2(177.49,173.03)
  BOTTOM w0.102: RT86.2 177.08,171.8 v1(177.05,171.83)
  BOTTOM w0.107: RT45.1 177.87,173.41 v2(177.49,173.03) 177.49,172.66 177.89,172.27 RT86.2
NC_B5: length 3.1
  TOP w0.089: 178,171.94 177.99,171.47 177.76,171.23 UT1.B5
  TOP w0.127: RT46.1 178.95,173.56 178.6,173.21 v1(178.6,172.96) 178.6,172.55 178,171.94
NC_G2: length 4.7
  TOP w0.089: 175.72,168.63 175.75,168.65 176.09,168.65 176.1,168.64 176.14,168.64 UT1.G2
  TOP w0.102: RT47.1 174.16,165.69 174.46,166 174.46,166.17 174.72,166.42 174.72,167.3 174.63,167.39 174.63,167.86 174.97,168.2 175.35,168.2 175.61,168.47 175.61,168.52 175.72,168.63
Net_185: length 1.7
  BOTTOM w0.122: 214.67,22.73 214.4,22.73 214.21,22.92 213.64,22.92 213.32,23.24 213.32,23.37 v2(213.32,23.37)
Net_186: length 1
  TOP w0.102: 329.24,43.83 328.34,43.83 v2(328.29,43.88)
Net_1311: length 0.6
  BOTTOM w0.076: v2(170.65,115.84) 170.71,115.91 170.71,116.07 170.54,116.24 170.38,116.24
Net_1312: length 0.6
  BOTTOM w0.076: 171.03,116.24 171.07,116.24 171.44,115.88 171.44,115.85 v2(171.42,115.85)
Net_1313: length 0.5
  BOTTOM w0.089: v2(170.06,115.85) 170.06,115.78 170.38,115.45
Net_1314: length 0.6
  BOTTOM w0.089: 169.73,115.45 170.08,115.11 v2(170.08,115.04)
Net_1315: length 3.3
  BOTTOM w0.076: 172.98,116.24 172.87,116.24 172.79,116.16 172.79,116.02 172.87,115.94 173.25,115.94 173.3,116 173.91,116 174.3,116.39 174.68,116.39 174.89,116.18 174.89,115.95 v2(175.09,115.75)
Net_1316: length 2.7
  BOTTOM w0.076: 171.68,115.45 171.82,115.45 172.04,115.23 172.04,115.15 172.21,114.97 173.14,114.97 173.15,114.97
  BOTTOM w0.089: 173.15,114.97 173.52,114.97 173.68,114.81 v2(173.68,114.42)
Net_1333: length 3.3
  BOTTOM w0.076: v2(174.51,115.75) 174.55,115.75 174.73,115.93 174.73,116.11 174.64,116.2 174.38,116.2 174.02,115.83 173.41,115.83 173.33,115.75 172.83,115.75 172.52,116.05 172.52,116.05 172.33,116.24
Net_1334: length 2.7
  BOTTOM w0.076: v2(174.25,114.42) 173.85,114.82 173.85,114.88 173.59,115.14 172.28,115.14 172.21,115.22 172.21,115.38 172.28,115.45 172.33,115.45
Net_1356: length 3.5
  BOTTOM w0.076: 133.05,96.1 133.29,95.86 133.29,95.19 133,94.9 132.75,94.9 132.21,94.36 v2(131.15,94.36)
Net_1364: length 0.7
  BOTTOM w0.076: 132.36,95.96 132.24,95.96 v2(131.84,95.56)
Net_1365: length 1.6
  BOTTOM w0.076: v2(131.52,94.82) 131.67,94.97 132.2,94.97 132.61,95.39 132.92,95.39
Net_1386: length 1.6
  BOTTOM w0.102: 316.07,42.92 316.07,44.14 v2(316.34,44.41)
Net_1549: length 0.5
  BOTTOM w0.122: 208.33,34.29 v2(208.87,34.29)
Net_1602: length 0.5
  BOTTOM w0.107: v2(200.67,33.2) 200.67,32.66
Net_1604: length 0.5
  BOTTOM w0.107: v2(199.91,33.2) 199.91,32.66
Net_1726:
  vias: v2(190.36,119.23) v2(190.36,118.4) v2(190.36,117.58) v2(192.01,119.23) v2(192.01,118.4) v2(192.01,117.58)
Net_1811: length 0.9
  BOTTOM w0.089: 170.51,96.69 171.06,96.14 v2(171.06,96.01)
NRB_BIT: length 7.8
  BOTTOM w0.089: UH1.BE30 215.32,26.9 216.37,26.9 216.54,26.72 216.99,26.72 217.6,26.11 218.5,26.11 218.66,25.96 218.66,25.9 218.68,25.87 218.68,25.75 218.85,25.58 219.18,25.58
  BOTTOM w0.102: v1(221.8,25.02) 221.19,25.02 220.81,25.4 RH524.2 220.7,25.4 220.27,25.84 219.43,25.84 219.18,25.58
NTC_LA: length 29
  IN1 w0.203: v2(251.23,146.17) 251.23,146.81 251.43,147.01 256.68,147.01 257.62,147.95 264.03,147.95 267.06,144.91 267.06,141.22 267.87,140.41 268.57,139.71 268.57,138.93 268.15,138.51 v2(268.13,138.51)
  BOTTOM w0.102: v1(251.23,148.06) PH6000.1
  BOTTOM w0.203: PH6000.1 v2(251.23,146.17)
  BOTTOM w0.254: v2(268.13,138.51) PR6009.1 269.78,138.51 PR6008.2
NTC_LB: length 46.8
  IN1 w0.203: v2(250.31,146.17) 250.31,147.04 250.61,147.34 256.44,147.34 257.48,148.38 264.06,148.38 267.39,145.04 267.39,141.35 268.9,139.85 268.9,138.08 v2(267.53,136.71)
  BOTTOM w0.203: PH6000.2 v2(250.31,146.17)
  BOTTOM w0.254: PR6014.2 266.04,132.95 PC6003.2 267.85,132.95 268.11,133.2 268.11,134.85 ; 267.72,136.71 268.11,136.33 v1(268.11,135.58) 268.11,134.85 ; 267.72,136.71 v2(267.53,136.71) 266.95,136.71 PR6012.2 266.04,136.76 PR6011.2 ; 267.72,136.71 269.69,136.71 PC6008.1 269.78,136.79 PR6020.1 268.91,137.62 PR6009.2 268.29,137.6 267.29,138.6 PC6006.2 266.04,138.6 PR6010.2 ; PR6013.2 266.04,134.85 PC6004.2 268.11,134.85
NUM: length 94.1
  TOP w0.102: RE636.1 273.75,35.32 v1(275.37,33.71) 277.44,31.64 277.44,29.21 278.58,28.07 278.58,26.22 279.39,25.41 279.39,20.59 280.6,19.37 v2(280.6,18.9)
  IN4 w0.102: v2(233.96,20.61) 234.16,20.41 236.9,20.41 237.72,19.59 240.06,19.59 242.16,17.5 244.66,17.5 245.76,17.5 246.69,16.56 248.02,16.56 249.05,17.59 254.62,17.59 255.11,18.09 259.3,18.09 260.33,19.12 265.56,19.12 266.26,19.82 267.15,19.82 267.76,19.21 271.16,19.21 272.3,20.35 279.15,20.35 v2(280.6,18.9)
  BOTTOM w0.102: v2(233.96,20.61) 233.5,20.14 232.59,20.14 231.69,19.25 231.69,18.87 232.72,17.85 232.72,12.23 230.78,10.29 229.53,10.29 229.35,10.11 226.54,10.11 226.54,10.11 224.23,10.11 224.09,9.97 224.09,8.63 223.74,8.28 223.11,8.28 222.97,8.14 JKB.2
NUM_LED: length 34.7
  TOP w0.102: v2(277.32,33.52) 276.39,33.52 273.99,35.93 273.99,38.29 272.69,39.59 RE637.1 ; UE5.36 292.64,22.81 292.87,23.04 292.87,24.27 290.49,26.65 290.49,28.6 290.14,28.95 290.14,32.03 v2(288.59,33.58)
  IN3 w0.102: v2(288.59,33.58) 288.32,33.32 285.44,33.32 284.83,33.93 277.73,33.93 v2(277.32,33.52)
  BOTTOM w0.102: v1(277.75,33.86) 277.4,33.52 v2(277.32,33.52)
NVVDD1_EN: length 350.4
  TOP w0.102: v2(275.92,152.16) v1(275.92,152.72)
  TOP w0.254: v2(283.09,164.34) CG481.1 RG549.2 282.42,165.24 283.05,165.88 283.05,168.66 282.38,169.33 DG7.1 ; v2(275.92,152.16) PR6036.2 276.3,151.4 276.58,151.68 PQ8203.2
  IN1 w0.254: v2(317.76,62.51) 317.76,60.61 320.9,57.46 320.9,53.48 322.35,52.03 325.74,52.03 328.56,49.2 331.91,49.2 333.18,47.93 333.18,38.08 331.1,36 v2(330.65,36)
  IN3 w0.254: v2(283.09,164.34) 283.09,161.75 280.23,158.89 280.23,157.61 279,156.38 277.92,156.38 275.92,154.37 v2(275.92,152.16) 275.92,150.87 279.17,147.62 281.66,147.62 287.51,141.77 287.51,100 287.51,99.98 287.59,99.66 287.62,99.54 287.87,98.6 287.9,98.49 288.41,96.78 288.9,95.28 289.17,94.35 289.8,92.99 292.24,87.96 v2(292.24,82.41) 292.72,81.93 292.72,79.11 299.78,72.04 299.78,64.15 301.88,62.05 305.55,62.05 305.58,62.02 306.32,62.02 306.94,62.64 314.26,62.64 314.91,61.99 317.24,61.99 v2(317.76,62.51)
  IN4 w0.254: v2(188.6,59.15) 191.04,59.15 196.48,53.71 199.14,53.71 200.47,52.38 200.47,49.36 203.45,46.39 208.1,46.39 208.79,45.7 209.19,45.7 211.16,43.72 211.16,42.28 211.91,41.53 215.36,41.53 215.76,41.93 219.01,41.93 219.05,41.98 222.24,41.98 222.48,42.22 228.88,42.22 229.42,42.76 231.68,42.76 234.15,40.3 236.74,40.3 236.79,40.25 237.24,40.25 238.01,41.01 240.74,41.01 242.72,42.99 258.4,42.99 259.09,42.31 265.68,42.31 272.75,35.23 275.45,35.23 276.46,34.22 279.22,34.22 279.92,33.52 282.65,33.52 283.98,34.85 291.09,34.85 291.79,34.15 320.18,34.15 320.81,33.52 323.92,33.52 325.91,35.5 328.63,35.5 329.13,36 v2(330.65,36)
  BOTTOM w0.102: v2(188.6,59.15) 188.63,59.15 189.11,58.66 189.11,58.37 189.98,57.5 UG31.18
  BOTTOM w0.254: QG508.2 289.74,80.63 290.37,81.26 290.48,81.26 291.63,82.41 v2(292.24,82.41)
NVVDD1_ENP: length 11.7
  TOP w0.254: v2(275.75,144.15) 274.89,143.28 PR6034.1 ; v2(277.9,151.03) PQ8203.3
  BOTTOM w0.203: v2(275.75,144.15) 275.61,144.01 PU6000.36
  BOTTOM w0.254: v2(277.9,151.03) 277.65,151.03 v1(276.72,150.1) 275.75,149.13 v2(275.75,144.15)
NVVDD1_PGOOD: length 318.4
  TOP w0.102: PR6403.1 v2(308.81,57.52) 308.99,57.52 v1(309.36,57.89) ; v2(277.46,144.33) 277.77,144.64 UG29.2 ; DG4.1 212.79,161.08 v2(212.47,161.4)
  IN4 w0.102: v2(308.81,57.52) 308.77,57.48 302.48,57.48 301.49,56.49 301.49,53.57 300.53,52.61 300.53,49.08 298.34,46.89 292.72,46.89 289.46,50.16 271.57,50.16 270.91,50.82 259.99,50.82 259.66,51.15 250.8,51.15 250.51,51.44 240.71,51.44 240.42,51.15 237.97,51.15 236.21,49.39 234.15,49.39 233.84,49.7 233.84,50.38 232.43,51.79 230.86,51.79 230.29,52.37 230.29,52.66 229.96,52.99 227.01,52.99 225.41,51.39 216.66,51.39 216.15,51.9 214.86,51.9 213.45,53.31 213.45,56.56 211.08,58.93 211.08,61.35 211.51,61.78 211.51,113.25 212.42,114.15 212.87,114.15 215.12,116.4 215.12,119.85 208.29,126.67 208.29,128.26 207.12,129.43 207.12,132.83 208.9,134.61 208.9,142.35 205.61,145.64 205.61,154.46 207.17,156.02 207.17,158.32 209.52,160.67 211.74,160.67 v2(212.47,161.4) 212.82,161.75 217.05,161.75 217.51,162.21 217.83,162.21 219.25,163.63 220,163.63 220.14,163.77 220.54,163.77 221.01,164.24 222.07,164.24 222.3,164.01 222.7,164.01 223.57,163.15 226.13,163.15 226.6,162.68 228.81,162.68 229.59,163.46 229.72,163.59 231.52,165.39 236.47,165.39 237.59,164.27 237.59,161.03 239.21,159.4 239.21,155.67 240.31,154.57 240.31,153.45 241.34,152.43 263.04,152.43 269.72,145.75 276.53,145.75 277.46,144.82 v2(277.46,144.33)
  BOTTOM w0.102: PR6042.2 277.46,144.99 v2(277.46,144.33) 277.46,144.28 276.41,143.23 PU6000.38
NVVDD2_EN: length 448.1
  TOP w0.102: v2(281.59,161.02) UG28.4 281.59,162.64 v1(282.04,163.1) ; PU6400.3 306.37,55.45 v2(306.59,55.24) 306.98,54.85 PR6404.2 307.28,55.73 307.27,55.74 PR6403.2 PR6436.1
  IN2 w0.102: v2(192.86,68.32) 192.86,67.55 193.24,67.17 194.7,67.17 196.41,65.46 196.8,65.46 197.11,65.14 197.11,64.19 196.78,63.86 195.76,63.86 194.86,62.96 194.86,61.45 193.04,59.63 193.04,58.98 192.94,58.88 189.77,58.88 188.87,57.98 v2(188.62,57.98) ; v2(306.59,55.24) 306.66,55.31 306.66,57.39 304.85,59.2 299.38,59.2 297.3,61.28 297.3,64.54 297.65,64.89 297.65,69.57 292.99,74.23 292.99,82.35 290.18,85.15 v2(290.18,87.31)
  IN3 w0.102: v2(306.59,55.24) 307.16,54.66 307.16,49.33 306.84,49.01 305.44,49.01 304.24,47.81 304.24,41.3 302.11,39.17 300.81,39.17 v2(299.86,38.22)
  IN4 w0.102: v2(281.59,161.02) 281.02,161.59 279.37,161.59 276.83,164.13 276.83,167.1 276.35,167.58 270.47,167.58 270.12,167.22 270.12,166.96 268.39,165.23 268.39,160.8 265.55,157.97 242.59,157.97 241.56,158.99 241.56,163.14 239.62,165.08 239.62,167.98 238.28,169.32 235.64,169.32 235.37,169.05 233.09,169.05 230.58,171.57 227.97,171.57 227.56,171.98 222.56,171.98 221.5,173.04 216.1,173.04 214.37,171.31 209.75,171.31 206.7,168.27 206.7,167.38 204.54,165.22 204.54,164.36 204.11,163.92 203.71,163.92 203.33,163.55 203.33,162.85 202.85,162.36 200.76,162.36 199.19,160.8 196.34,160.8 194.98,159.44 194.98,158.12 194.73,157.86 194.1,157.86 193.69,158.27 193.29,158.27 193.01,157.99 193.01,157.59 193.24,157.36 193.24,154.61 193.85,154 193.85,151.68 196.8,148.74 196.8,148.38 196.9,148.28 197.03,148.15 197.03,128.24 196.4,127.61 196.4,126.82 195.92,126.34 195.92,125.63 195.59,125.31 193.15,122.87 193.15,117.82 189.52,114.19 189.52,111.86 189.24,111.58 189.24,111.58 187.95,110.29 187.95,108.75 187.22,108.02 187.22,107.23 187.78,106.67 187.78,100.2 190.2,97.78 190.2,82.34 189.31,81.45 189.31,79.38 189.98,78.7 189.98,71.25 192.86,68.38 v2(192.86,68.32) 194.02,68.32 195.1,67.24 198.45,67.24 201.08,64.61 201.08,62.34 202.15,61.26 202.15,55.46 203.15,54.47 207.82,54.47 209.13,53.16 209.13,49.11 210.38,47.85 210.38,47.16 211.61,45.94 213.58,45.94 214.38,45.14 225.49,45.14 225.85,44.78 228.59,44.78 228.81,44.57 233.49,44.57 234.08,45.15 235.58,45.15 235.78,44.95 v2(235.91,44.95) 235.97,45.01 239.79,45.01 240.4,44.4 259.15,44.4 259.72,43.83 265.99,43.83 273.06,36.76 277.71,36.76 278.54,35.93 281.32,35.93 282.38,36.99 291.51,36.99 292.15,36.35 297.99,36.35 v2(299.86,38.22)
  BOTTOM w0.102: UG31.17 189.05,56.88 188.79,57.14 188.79,57.81 188.62,57.98 v2(188.62,57.98) ; PR8217.1 236.04,39.86 235.78,40.11 235.78,44.25 235.85,44.31 235.85,44.89 v2(235.91,44.95) ; QG507.2 v2(290.18,87.31)
NVVDD2_PGOOD: length 324.4
  TOP w0.102: v2(213.98,161.04) 214.02,161.08 DG4.2 214.89,160.95 214.18,160.24 RG506.2 213.47,159.78 QG502.4 ; v2(234.56,158.23) 234.56,163.61 234.78,163.84 QV3.2 ; PU6400.13 300.71,55.45 v2(300.57,55.59) 299.79,55.59 PR6408.1
  TOP w0.254: v2(205.94,56) 205.94,56.05 206.34,56.45 206.74,56.45 212.78,50.41 219.08,50.41 219.27,50.6 224.35,50.6 225.31,51.55 231.97,51.55 232.93,50.6 234.9,50.6 v2(235.28,50.22) 235.28,49.67 235.34,49.61 235.34,48.95 234.2,47.81 234.2,44.12 235.72,42.6 v1(235.77,42.6) v2(236.42,42.6)
  IN4 w0.089: 216.21,122.36 216.21,121.16 215.38,120.32 215.38,116.22 215.02,115.87
  IN4 w0.102: v2(300.57,55.59) 299.92,54.94 299.92,49.01 298.42,47.51 292.64,47.51 289.62,50.54 272.05,50.54 271.17,51.43 260.24,51.43 259.91,51.76 251.05,51.76 250.76,52.05 240.45,52.05 240.24,51.83 237.79,51.83 236.11,50.16 235.34,50.16 v2(235.28,50.22) 235.17,50.32 235.17,50.45 234.15,51.47 234.15,51.78 233.26,52.67 233.26,53.05 232,54.31 231.08,54.31 230.52,53.75 226.53,53.75 225.26,52.47 222.25,52.47 221.98,52.74 214.45,52.74 213.75,53.44 213.75,56.69 211.39,59.05 211.39,61.33 211.76,61.7 211.76,67 211.82,67.06 211.82,113.12 212.54,113.85 213,113.85 215.02,115.87 ; 216.21,122.36 216.21,125.61 215.44,126.38 211.95,126.38 208.84,129.49 208.41,129.49 207.43,130.48 207.43,132.7 209.24,134.52 209.24,142.44 205.91,145.77 205.91,154.33 207.21,155.63 207.53,155.63 208.73,156.84 208.73,159.44 209.62,160.33 212.12,160.33 212.84,161.04 v2(213.98,161.04) 213.99,161.05 214.19,161.05 214.59,161.45 217.18,161.45 217.63,161.9 217.96,161.9 219.38,163.33 220.02,163.33 220.23,163.54 220.74,163.54 221.13,163.93 221.95,163.93 222.17,163.71 222.58,163.71 223.44,162.84 226.01,162.84 226.83,162.02 226.83,158.61 227.78,157.66 233.98,157.66 v2(234.56,158.23)
  BOTTOM w0.203: v2(205.94,56) 205.94,55.57 205.74,55.36 202.89,55.36 199.46,51.93 195.08,51.93 194.76,52.25 194.76,52.89 192.37,55.28 UG31.5
  BOTTOM w0.254: v2(236.42,42.6) 237.11,42.6 PR801.2
NVVDD2_PSI: length 9
  TOP w0.102: v1(306.78,55.88) 306.28,56.38 v2(306.02,56.38)
  TOP w0.203: v2(306.02,56.38) 305.48,55.85 PU6400.4
  TOP w0.254: PR6406.1 311.17,57.76 PR6413.2 310.52,56.24 310.52,56.24 310.26,55.98 PR6410.2 309.82,55.84 v2(309.65,56.02)
  IN1 w0.254: v2(306.02,56.38) 306.17,56.23 309.43,56.23 v2(309.65,56.02)
NVVDD_B+: length 2.9
  BOTTOM w0.508: v2(264.61,145.72) 265.25,145.09 266.37,145.09 PC6000.2 266.39,145.09 PR6006.1
  vias: v1(258.42,152.45) v2(207.72,147.88) v2(207.72,147.25) v2(207.72,146.61) v2(207.72,145.98) v2(208.3,147.88) v2(208.3,147.25) v2(208.3,146.61) v2(208.3,145.98) v2(208.89,147.88) v2(208.89,147.25) v2(208.89,146.61) v2(208.89,145.98) v2(217.24,151.18) v2(217.88,151.18) v2(218.51,151.18) v2(219.15,151.18) v2(219.78,151.18) v2(220.42,151.18) v2(221.05,151.18) v2(221.69,151.18) v2(222.32,151.18) v2(230.89,151.25) v2(231.53,151.25) v2(232.16,151.25) v2(232.8,151.25) v2(233.43,151.25) v2(234.07,151.25) v2(234.7,151.25) v2(235.34,151.25) v2(235.97,151.25) v2(244.61,151.31) v2(245.25,151.31) v2(245.88,151.31) v2(246.52,151.31) v2(247.15,151.31) v2(247.79,151.31) v2(248.42,151.31) v2(249.06,151.31) v2(249.69,151.31) v2(258.39,151.37) v2(259.03,151.37) v2(259.63,151.37) v2(260.23,151.37) v2(260.87,151.37) v2(261.5,151.37) v2(262.14,151.37) v2(262.77,151.37) v2(263.41,151.37)
NVVDD_ISUMN1: length 11.7
  BOTTOM w0.254: PL6100.3 257.25,138.61 257.5,138.87 264.85,138.87 PR6010.1
NVVDD_ISUMN2: length 40.9
  IN2 w0.254: v2(243.47,139.44) 243.57,139.34 243.57,130.45 244.3,129.72 261.47,129.72 262.18,130.43 262.18,134.82 264.14,136.77 v2(264.49,136.77)
  BOTTOM w0.254: PR6011.1 v2(264.49,136.77) ; PL6101.3 v2(243.47,139.44)
NVVDD_ISUMN3: length 55
  IN2 w0.254: v2(264.49,134.86) 264.14,134.86 262.95,133.67 262.95,130.02 261.24,128.32 230.9,128.32 230.07,129.15 230.07,139 v2(229.75,139.31)
  BOTTOM w0.254: PR6013.1 v2(264.49,134.86) ; PL6200.3 v2(229.75,139.31)
NVVDD_ISUMN4: length 69.7
  IN2 w0.254: v2(216.1,139.5) 216.1,127.94 216.91,127.13 261.22,127.13 263.82,129.74 263.82,132.66 264.12,132.96 v2(264.49,132.96)
  BOTTOM w0.254: PL6201.3 v2(216.1,139.5) ; PR6014.1 v2(264.49,132.96)
NVVDD_ISUMP1: length 14
  BOTTOM w0.102: PR6001.1 265.11,140.82 v1(265.46,141.18)
  BOTTOM w0.254: PL6100.2 257.25,139.5 257.5,139.25 264.85,139.25 PR6001.1
NVVDD_ISUMP2: length 40.1
  IN2 w0.254: v2(264.49,137.66) 261.8,134.98 261.8,130.59 261.38,130.17 244.48,130.17 243.95,130.7 243.95,139.65 243.53,140.07 v2(243.47,140.07)
  BOTTOM w0.254: PL6101.2 v2(243.47,140.07) ; PR6002.1 v2(264.49,137.66)
NVVDD_ISUMP3: length 54.4
  IN2 w0.254: v2(264.49,135.75) 262.57,133.83 262.57,130.28 261.06,128.77 230.99,128.77 230.45,129.31 230.45,139.38 229.88,139.94 v2(229.75,139.94)
  BOTTOM w0.254: PL6200.2 v2(229.75,139.94) ; PR6003.1 v2(264.49,135.75)
NVVDD_ISUMP4: length 68.7
  IN2 w0.254: v2(216.1,140.2) 216.59,139.7 216.59,128.15 217.23,127.51 261.06,127.51 263.44,129.89 263.44,132.82 263.7,133.08 v2(264.49,133.87)
  BOTTOM w0.254: PL6201.2 v2(216.1,140.2) ; PR6004.1 v2(264.49,133.87)
NVVDD_PSI: length 102.5
  TOP w0.089: v2(217.47,112.34) 217.47,112.69 217.56,112.78 219.55,112.78 RG565.1
  TOP w0.102: v2(276.34,146.69) 276.22,146.69 v1(275.7,147.21)
  IN4 w0.102: v2(217.47,112.34) 217.47,112.42 217.88,112.83 217.88,114.81 218.15,115.09 218.15,116.52 217.66,117.01 217.66,118.04 217.32,118.38 217.32,118.88 217.32,119.03 218.07,119.78 218.38,119.78 218.44,119.84 219.34,119.84 219.39,119.78 221.54,119.78 222.9,118.42 225.04,118.42 226.48,119.86 226.48,121.56 229.96,125.03 236.3,125.03 239.44,128.17 262.18,128.17 264.94,130.93 276.54,130.93 277.55,131.94 277.55,136.31 277.72,136.47 277.72,136.48 278.14,136.9 278.14,137.14 277.91,137.37 277.91,145.11 v2(276.34,146.69)
  BOTTOM w0.089: UG9.BD2 219.41,112.65 219.1,112.34 v2(217.47,112.34) 217.33,112.34 216.92,111.93 215.61,111.93 215.15,111.48 215.15,111.09 214.72,110.66 214.19,110.66 RG15.1
  BOTTOM w0.102: PR6039.2 276.42,146.6 v2(276.34,146.69)
NVVDD_VCC_SENSE: length 11.8
  TOP w0.102: v1(246.47,125.78) 246.47,124.34 247.07,123.73 PR6021.2
  TOP w0.254: v2(247.07,122.55) PR6021.2
  IN2 w0.254: v2(247.07,122.55) 248.55,122.55 250.58,120.51 250.58,117.66 v2(250.12,117.2)
  BOTTOM w0.203: UG9.BK45 249.77,116.85 v2(250.12,117.2)
NVVDD_VID: length 95.7
  IN4 w0.102: v2(222.77,112.35) 222.23,112.89 221.76,112.89 220.91,113.74 220.91,115.67 220.06,116.53 219.34,116.53 218.89,116.97 218.89,117.38 217.81,118.46 217.81,118.69 218.59,119.47 219.19,119.47 219.24,119.42 221.39,119.42 222.75,118.05 226.3,118.05 226.63,118.38 228.04,118.38 229.5,119.84 229.5,123.77 230.06,124.34 236.38,124.34 239.67,127.63 262.52,127.63 265.25,130.36 276.61,130.36 278.01,131.75 278.01,134.29 279.08,135.36 279.08,136.86 278.37,137.57 278.37,146.46 278.37,146.6 v2(278.3,146.66)
  BOTTOM w0.1: UG9.BD6 v2(222.77,112.35)
  BOTTOM w0.102: PR6044.1 278.3,146.15 v2(278.3,146.66) 278.3,147.25 v1(278.2,147.35)
NVVDD_VSS_SENSE: length 10.2
  TOP w0.254: PR6025.2 v2(245.83,122.23)
  IN2 w0.254: v2(250.14,117.92) 250.14,120.32 248.36,122.1 245.96,122.1 v2(245.83,122.23)
  BOTTOM w0.089: v2(245.83,122.23) v1(245.83,121.03)
  BOTTOM w0.203: v2(250.14,117.92) UG9.BL45
NVVDDS_B+:
  vias: v1(275.42,37.53) v2(275.05,40.18) v2(275.05,39.59) v2(275.05,39.01) v2(287.92,47.12) v2(287.92,46.54) v2(287.92,45.95) v2(287.92,45.34) v2(287.92,44.76) v2(287.92,44.12)
NVVDDS_BST1:
  vias: v1(306.16,54.02)
NVVDDS_BST2:
  vias: v2(300.55,54.16)
NVVDDS_COMP: length 3.5
  TOP w0.203: PC6427.2 299.08,56.65 299.31,56.41 PR6411.2 300.39,56.41 v1(300.69,56.11) 300.96,55.85 PU6400.12
NVVDDS_HG1: length 2.7
  TOP w0.203: PU6400.2 305.97,55.05 v2(306.07,54.95) 307.06,53.97 PR6429.1
NVVDDS_HG2: length 3.6
  TOP w0.203: PU6400.14 300.71,55.05 v2(300.57,54.91) 299.99,54.91 PR6431.1
  BOTTOM w0.102: v1(301.02,56) 301.02,55.37 v2(300.57,54.91)
NVVDDS_LG1: length 15.5
  TOP w0.102: v2(295.33,46.09) v1(296.12,46.09)
  IN1 w0.762: 303.79,52.12 302.94,51.27 302.94,50.92 302.14,50.12 301.79,50.12 297.76,46.09 296.24,46.09
  IN2 w0.762: 295.03,45.36 295.03,43.74 294.14,42.85 294.14,41.27
  vias: v2(294.1,40.31) v2(294.75,46.09) v2(294.68,40.31) v2(303.95,53.11) v2(304.43,52.76)
NVVDDS_LG2: length 24.4
  TOP w0.102: v2(281.39,51.28) v1(281.39,50.65)
  IN1 w0.762: 283.03,50.85 284.11,49.77 294.14,49.77 296.05,51.68 301.25,51.68 301.76,52.19
  IN2 w0.762: 281.38,50.16 281.38,46.54
  vias: v2(281.25,45.58) v2(281.83,45.58) v2(281.98,51.28) v2(302.46,52.76) v2(302.94,53.11)
NVVDDS_PSI: length 215.3
  TOP w0.089: v2(218.35,113.21) 218.7,113.57 v1(219.15,113.57) 220.18,113.57 220.54,113.2 RG565.2 220.98,112.75 221.34,112.75 221.76,113.17 RG564.2 RG503.1
  TOP w0.102: v2(312.28,55.55) 311.99,55.84 PR6410.1
  IN4 w0.089: v2(218.35,113.21) 218.35,113.51 218.06,113.8 218.06,114.74 218.34,115.01 218.34,115.22 218.49,115.38 218.79,115.38 219,115.59 219,115.89 218.79,116.1 218.49,116.1 218.34,116.25 218.34,116.44 218.34,116.59 217.84,117.09 217.84,118.12 217.5,118.46 217.5,118.96 218.14,119.6 218.46,119.6 218.52,119.66 219.26,119.66 219.32,119.6 221.46,119.6 222.83,118.23 225.11,118.23 226.67,119.79 226.67,121.48 227.31,122.13 227.37,122.13 227.6,122.36
  IN4 w0.102: v2(312.28,55.55) 311.41,56.42 311.41,58.04 310.8,58.65 310.8,58.97 310.77,59 310.77,59.34 310.8,59.37 310.8,61.75 309.99,62.56 307.32,62.56 306.05,61.29 305.93,61.29 305.37,60.73 301.18,60.73 299.65,62.26 299.65,62.81 299.78,62.93 299.78,71.66 297.14,74.3 295.84,74.3 295.28,74.86 295.28,76.94 295.16,77.23 295.05,77.77 295.05,78.33 295.16,78.87 295.28,79.16 295.28,80.12 295.28,80.12 295.26,81.52 295.23,83.77 294.01,85.27 289.56,93.72 288.2,98.31 288.2,99.04 288.02,99.76 288.02,144.12 287.44,144.71 282.18,144.71 281.24,145.65 281.24,146.41 281.1,146.55 281.1,146.87 280.21,147.76 278.57,147.76 277.78,146.97 277.78,145.56 278.14,145.21 278.14,137.46 278.37,137.23 278.37,136.76 277.78,136.17 277.78,131.85 276.63,130.7 265.03,130.7 262.19,127.85 239.58,127.85 236.53,124.81 230.05,124.81 227.6,122.36
NVVDDS_SNB1: length 3.7
  TOP w0.102: v1(286.58,55.22) 286.53,55.17 PC6428.1
  TOP w0.508: PR6409.2 286.56,52.58 PC6428.1
NVVDDS_SNB2: length 2.7
  TOP w0.102: v1(277.54,55.44) PR6424.2
  TOP w0.508: PC6440.1 277.54,53.21 PR6424.2
NVVDDS_SW1:
  vias: v1(305.22,52.8)
NVVDDS_SW2:
  vias: v1(301.74,52.67)
NVVDDS_VCC_SENSE: length 108.6
  TOP w0.102: PR6422.1 297.58,62.61 v1(296.83,61.87)
  TOP w0.254: PR6422.1 v2(297.86,63.22)
  IN4 w0.254: v2(297.86,63.22) 298.53,62.55 298.97,62.55 299.47,63.06 299.47,69.71 294.97,74.21 294.97,76.88 294.87,77.14 294.75,77.74 294.75,78.36 294.87,78.96 294.97,79.22 294.97,79.99 294.97,80.09 294.97,80.39 294.97,80.52 294.94,82.32 294.93,83.66 293.76,85.1 289.28,93.61 287.9,98.27 287.9,99 287.72,99.72 287.72,120.57 286.1,122.19 264.77,122.19 262.43,119.85 249.34,119.85 v2(249.18,120.01)
  BOTTOM w0.203: UG9.BM45 249.62,118.4 249.62,119.57 v2(249.18,120.01) 249.18,120.35 PR6425.2
NVVDDS_VID: length 219.3
  TOP w0.089: v2(217.5,113.47) 217.5,113.81 v1(217.71,114.02)
  TOP w0.102: v2(309.09,58.65) 308.47,59.27 PR6412.1
  IN6 w0.102: v2(217.5,113.47) 217.5,112.91 216.99,112.4 216.99,110.78 216.48,110.26 216.48,109.85 213.43,106.8 209.55,106.8 206.49,103.74 197.27,103.74 196.7,104.31 190.83,104.31 188.73,102.21 187.51,102.21 186.2,100.91 186.2,100.85 185.71,100.35 185.71,95.18 186.57,94.31 186.57,73.13 189.27,70.44 199.88,70.44 201.64,68.67 201.65,68.67 201.7,68.61 209.7,68.61 210.64,67.68 210.64,58.32 212.23,56.73 212.23,54.86 214.35,52.74 220.12,52.74 220.38,52.47 225.79,52.47 226.33,53.01 228.2,53.01 229.52,51.7 232.02,51.7 232.42,51.3 249.39,51.3 250.63,50.07 259.51,50.07 260.58,51.13 271.92,51.13 273.25,49.81 277.86,49.81 278.7,48.96 293.03,48.96 297.08,53.02 297.08,56.45 299.43,58.79 308.95,58.79 v2(309.09,58.65)
  BOTTOM w0.1: UG9.BE4 220.72,113 218.78,113 218.6,112.82 218.14,112.82 v2(217.5,113.47)
NVVDDS_VIDBUF:
  vias: v1(305.43,58.23)
NVVDDS_VREF: length 8.9
  TOP w0.102: PR6426.1 302.45,62.39 v1(301.77,63.07)
  TOP w0.203: v2(303.44,57.97) PU6400.8
  TOP w0.254: PR6426.1 302.43,62.07 v2(301.91,61.55) 301.91,61.39 PC6441.2 302.31,60.93 PR6419.1
  IN1 w0.254: v2(301.91,61.55) 303.44,60.01 v2(303.44,57.97)
NVVDDS_VSS_SENSE: length 114.5
  TOP w0.102: v2(298.73,63.25) 298.73,64.04 v1(298.82,64.14)
  TOP w0.254: v2(304.99,61.57) PC6439.2 304.98,60.93 PR6423.2 304.1,60.89 PC6437.2 ; v2(298.73,63.25) 298.73,62.7 PR6421.1
  IN4 w0.254: v2(298.73,63.25) 298.99,63.51 298.99,69.66 294.59,74.06 294.59,76.8 294.5,77.03 294.36,77.7 294.36,78.4 294.5,79.07 294.59,79.3 294.59,79.99 294.53,83.54 293.44,84.89 288.92,93.46 287.56,98.07 287.52,98.11 287.52,98.96 287.34,99.67 287.34,120.41 285.94,121.81 264.96,121.81 262.66,119.51 249.45,119.51 v2(249.18,119.24)
  IN6 w0.254: v2(304.99,61.57) 304.48,62.07 300.84,62.07 299.67,63.25 v2(298.73,63.25)
  BOTTOM w0.203: PR6427.2 248.76,120.77 248.76,120.29 248.76,120.06 248.76,119.66 v2(249.18,119.24) 249.18,118.36 UG9.BM44
OC_WARN#: length 96.1
  TOP w0.102: v2(186.61,97.85) 182.77,101.69 182.77,113.9 183.05,114.18 ; 183.05,114.18 184.62,114.18 186,115.56 186.98,115.56 187.21,115.33 188.69,115.33 190.53,117.17 192.54,117.17 192.62,117.25 193.38,117.25 193.66,117.53 194.49,117.53 v2(194.5,117.53) ; 183.05,114.18 182.77,114.46 182.77,115.12 185.13,117.48 186.17,117.48 v1(188.48,119.78) 189.3,120.6 193.93,120.6 v2(194.35,120.18)
  IN6 w0.102: v2(217.43,109.91) 217.43,109.83 213.72,106.11 209.83,106.11 207,103.28 197.08,103.28 196.74,103.62 191.11,103.62 189.01,101.51 187.84,101.51 186.61,100.28 v2(186.61,97.85)
  BOTTOM w0.089: UG9.BB4 220.68,110.86 218.39,110.86 v2(217.43,109.91)
  BOTTOM w0.102: UG11.8 193.53,117.43 193.76,117.66 194.37,117.66 v2(194.5,117.53) 194.16,117.19 193.97,117.19 192.97,116.19 192.97,116.07 192.29,115.38 192.29,114.62 191.97,114.3 RG529.2 ; RG522.1 194.4,121.29 194.13,121.02 194.13,120.41 v2(194.35,120.18)
ON/OFF#: length 283.1
  TOP w0.102: v1(306.32,43.87) 306.7,44.25 v2(306.78,44.25)
  TOP w0.107: UE5.114 308.14,18.41 v2(308.45,18.11) 308.62,18.11 CE27.1 309.99,16.73 RE63.1 ; v2(311.9,8.59) SW1.2
  IN3 w0.102: v2(308.45,18.11) 310.43,20.09 312.14,20.09 312.52,20.46 312.52,21.88 311.99,22.41 311.59,22.41 310.64,23.36 310.64,24.29 311.9,25.55 311.95,25.6 311.95,25.94 311.9,25.99 311.9,26.89 312.17,27.17 312.17,27.8 310.8,29.17 310.8,29.24 310.4,29.65 310.4,30.85 308.75,32.5 308.75,35.49 308.87,35.61 308.87,37.77 308.75,37.9 308.75,39.23 308.87,39.36 308.87,39.69 308.75,39.82 308.75,41.01 308.85,41.11 308.85,42.43 308.75,42.54 308.75,42.92 307.41,44.25 v2(306.78,44.25)
  IN4 w0.102: v2(306.78,44.25) 306,43.48 298.64,43.48 297.12,41.95 293.14,41.95 292.44,42.65 278.52,42.65 277.71,41.85 272.97,41.85 268.72,46.09 260.66,46.09 260.05,46.7 249.08,46.7 247.57,48.21 237.81,48.21 237.47,47.87 237.3,47.7 237.22,47.7 236.95,47.44 232.52,47.44 232.25,47.7 223.57,47.7 223.29,47.42 216.25,47.42 215.97,47.7 215.8,47.87 214.25,49.42 214.1,49.42 211.16,52.36 211.16,55.62 207.84,58.93 207.84,68.47 209.23,69.85 209.23,103.67 207.08,105.81 207.08,112.45 204.07,115.47 203.93,115.6 203.93,123.26 200.36,126.83 200.36,126.97 200.36,126.97 200.36,129.7 199.37,130.69 199.37,143.25 201.71,145.59 201.71,145.78 201.71,145.78 201.71,148.1 200.83,148.98 200.83,150.03 202.92,152.12 202.92,155.89 204.22,157.19 204.89,157.19 205.44,157.75 205.44,158.02 205.44,158.96 209.37,162.89 210.56,164.08 210.56,164.87 v2(212.32,166.63)
  BOTTOM w0.107: v2(311.9,8.59) 311.44,8.13 308.21,8.13 307.84,8.5 307.84,12.27 308.86,13.29 308.86,14.66 307.98,15.54 307.98,17.64 v2(308.45,18.11)
OSC24M_IN: length 4.1
  TOP w0.102: RE18.2 316.59,7.31 315.79,8.11 v1(315.79,9.26) UE1.5
OSC24M_IN_R: length 4.4
  TOP w0.102: RE18.1 317.01,6.72 RE3.1 317.46,7.17 318.66,7.17 CE2.1 319.47,6.82 YE1.1
OSC24M_OUT: length 3.4
  TOP w0.102: UE1.6 316.3,9.33 316.19,9.22 316.19,8.31 316.56,7.94 RE19.2
OSC24M_OUT_R: length 7.3
  TOP w0.102: RE19.1 316.99,8.53 RE3.2 318.03,7.48 318.66,7.48 CE5.1 319.62,7.67 321.95,7.67 YE1.3
OUT_A: length 0.8
  BOTTOM w0.102: v2(37.35,6.66) 37.33,6.66 v1(36.78,6.1)
  vias: v2(36.9,7.04)
OUT_B: length 1.7
  BOTTOM w0.102: v2(36.33,4.12) v1(36.33,3.51)
  BOTTOM w0.508: v2(36.33,4.12) 36.48,4.27 36.48,4.31 36.71,4.53 LA51.1
OUT_D: length 0.5
  BOTTOM w0.102: v2(27,8.44) v1(27.5,8.44)
  vias: v2(27,9.03) v2(31.63,5.58) v2(31.77,5.01)
OVERT#: length 393.4
  TOP w0.102: v2(184.12,114.92) 183.97,115.07 183.97,115.99 184.53,116.55 186,116.55 189.75,120.3 193,120.3 193.52,119.78 194.95,119.78 196.48,118.25 198.78,118.25 199.18,118.66 205.29,118.66 v2(206.13,119.5) ; v2(309.7,61.36) 309.16,60.82 UG23.5 ; v2(213.4,156.8) 213.43,156.76 213.43,155.93 213.45,155.92 213.45,155.64 213.43,155.63 213.43,155.58 213.29,155.44 212.63,155.44 212.29,155.78 v1(211.21,155.78) 209.72,155.78 209.38,155.44 206.89,155.44 206.45,155.88 v2(206.45,156.33)
  IN1 w0.102: v2(221.47,114.45) 221.4,114.45 220.89,114.96 218.14,114.96 217.54,115.55 216.86,115.55 215.48,116.93 213.96,116.93 213.72,117.17 213.72,117.3 213.35,117.68 212.94,117.68 212.55,117.29 212.55,117.2 211.14,115.79 210.03,115.79 209.38,116.43 205.17,116.43 204.44,117.16 204.44,117.81 v2(206.13,119.5) ; v2(213.4,156.8) 213.43,156.76 213.43,155.86 212.33,154.76 212.33,153.34 213.84,151.83 224.98,151.83 225.59,151.22 227.81,151.22 228.43,151.84 238.98,151.84 239.42,152.28 241.68,152.28 241.82,152.14 251.79,152.14 252.64,152.99 252.64,155.34 253.67,156.37 263.86,156.37 264.7,155.53 264.7,152.52 265.45,151.78 265.45,150.98 267.35,149.07 271.76,149.07 274.3,151.62 274.3,154.05 v2(275.29,155.04)
  IN3 w0.102: v2(309.7,61.36) 308.83,62.22 307.09,62.22 305.76,60.89 300.62,60.89 300.4,60.67 299.64,60.67 299.23,61.08 299.23,71.68 292.01,78.9 292.01,80.46 291.25,81.22 291.25,84.92 291.25,88.26 289.11,92.67 288.46,94.08 288.46,94.08 288.17,95.05 288.03,95.46 287.74,96.38 287.74,96.38 287.68,96.56 287.68,96.56 287.22,98.1 287.21,98.11 287.13,98.4 287.13,98.4 286.92,99.18 286.92,99.18 286.88,99.36 286.87,99.37 286.85,99.46 286.84,99.52 286.75,99.86 286.74,99.91 286.74,139.4 283.63,142.52 280.36,142.52 278.74,144.15 278.74,145.33 277.55,146.51 277.55,148.26 275.22,150.6 275.22,154.97 v2(275.29,155.04)
  IN4 w0.102: v2(206.13,119.5) 206.51,119.5 206.76,119.75 206.76,124.01 203.51,127.26 203.51,128.85 201.75,130.61 201.75,134.64 200.74,135.65 200.74,142.61 203.08,144.96 203.08,145.03 203.08,146.35 203.08,149.08 203.95,149.95 203.95,151.2 204.29,151.55 204.29,155.32 204.75,155.78 205.9,155.78 v2(206.45,156.33)
  BOTTOM w0.1: v2(221.47,114.45) UG9.BG5
  BOTTOM w0.102: RG9.1 188.22,125.34 183.08,120.2 183.08,115.96 v2(184.12,114.92) 184.68,114.36 184.68,108.15 181.29,104.75 181.29,101.51 181.42,101.37 182.35,100.45 182.89,100.45 187.89,95.45 187.89,85.51 187.46,85.08 187.46,67.33 187.26,67.13 187.13,66.99 187.13,65.64 187.13,65.64 187.13,65.54 188.23,64.44 188.81,64.44 191.05,62.2 193.59,62.2 193.92,61.87 193.92,60.49 193.57,60.14 193.57,59.94 193.05,59.42 193.05,58.99 192.84,58.78 192.84,57.46 192.38,57 192.38,56.47 192.48,56.37 192.52,56.37 RG572.1 192.49,55.91 191.99,55.91 191.82,56.08 UG31.3
P1: length 18.7
  TOP w0.254: PR701.2 64.52,33.63 64.94,34.04 65.11,34.04 v2(65.48,34.41) 65.48,34.85 66.75,36.12 ; PQ708.1 66.32,36.9 64.72,35.3 61.86,35.3 v3(61.44,34.88) 61.22,34.66 61.22,32.95 58.75,30.47 PC701.1 58.05,29.96 58.29,29.72 PR706.1
  BOTTOM w0.254: PQ700.3 65.05,33.98 v2(65.48,34.41)
  vias: v2(68.06,39.14) v2(68.06,37.87) v2(68.14,41.04) v2(68.13,40.43) v2(68.16,36.67) v2(68.47,39.91) v2(68.55,38.2) v2(68.5,37.24) v2(68.77,39.37) v2(68.77,38.76) v2(68.78,41.01) v2(68.79,40.41) v2(68.78,36.49) v2(68.88,37.71)
P2:
  vias: v2(60.84,42.66) v2(60.84,41.55) v2(61.03,42.1) v2(61.48,42.66) v2(61.48,41.55) v2(61.67,42.1) v2(62.11,42.66) v2(62.11,41.55) v2(62.3,42.1) v2(62.75,42.66) v2(62.75,41.55) v2(62.94,42.1) v2(63.38,42.66) v2(63.38,41.55) v3(59.6,42.08)
PA_USB2_RBIAS: length 2.6
  TOP w0.102: UT1.H19 184.57,168.2 184.57,168.19 v2(184.56,168.19)
  BOTTOM w0.102: RT43.1 185.59,168 v1(185.59,167)
  BOTTOM w0.127: v2(184.56,168.19) 184.57,168.19 184.57,168.2 184.58,168.2 184.58,168.18 184.61,168.21 185.03,168.21 185.04,168.2 RT43.1
PANELL_LED_B_DRV#: length 261.6
  TOP w0.102: v2(231.66,166.91) 231.92,167.17 JLOGO.11 ; v2(308.02,46.25) 308.12,46.15 v1(308.12,45.47) 308.12,44.42 310.7,41.84 310.7,39.54 309.94,38.78 UE8.14
  IN4 w0.102: v2(308.02,46.25) 308.02,46.07 307.12,45.17 303.57,45.17 302.57,44.16 297.33,44.16 297.18,44.01 292.07,44.01 287.32,48.76 274.01,48.76 272.03,46.78 260.94,46.78 259.18,48.54 251.16,48.54 249.48,50.22 241.21,50.22 240.92,49.93 238.47,49.93 236.67,48.12 232.81,48.12 231.79,49.14 224.04,49.14 223,48.1 216.54,48.1 214.53,50.11 214.38,50.11 211.84,52.65 211.84,55.9 208.53,59.21 208.53,63.41 209.14,64.02 209.14,65.24 208.76,65.62 208.76,68.41 209.91,69.57 209.91,103.95 207.77,106.1 207.77,112.74 204.62,115.89 204.62,124.96 202.82,126.76 202.82,128.57 201.06,130.33 201.06,134.36 200.05,135.37 200.05,142.97 202.4,145.31 202.4,145.88 202.4,146.07 202.4,148.39 202.32,148.46 202.32,150.55 203.61,151.83 203.61,155.61 204.51,156.51 205.24,156.51 206.13,157.4 206.13,158.3 206.13,158.68 210.16,162.71 215.91,162.71 217.7,164.49 217.7,164.58 219.2,166.08 219.88,166.08 220.01,165.95 220.19,165.76 221.89,165.76 221.94,165.81 223.22,165.81 224.11,164.92 225.22,164.92 226.01,164.14 228.1,164.14 229.5,165.54 230.26,165.54 231.64,166.91 v2(231.66,166.91)
PANELL_LED_G_DRV#: length 264.7
  TOP w0.102: v2(227.72,165.15) 227.89,164.99 v1(229.21,164.99) 230.54,164.99 230.92,165.37 JLOGO.10 ; v2(308.61,46.25) 308.61,44.26 310.93,41.93 310.93,39.32 310.14,38.54 310.14,37.52 309.9,37.28 UE8.11
  IN4 w0.102: v2(227.72,165.15) 227.5,165.37 227.4,165.37 226.74,166.03 226.2,166.03 225.54,165.37 223.99,165.37 223.31,166.04 221.85,166.04 221.8,165.99 220.29,165.99 219.97,166.31 219.11,166.31 217.47,164.68 217.47,164.59 215.82,162.93 210.06,162.93 209.83,162.7 205.9,158.77 205.9,158.21 205.9,157.49 205.14,156.73 204.41,156.73 203.38,155.7 203.38,151.93 201.29,149.84 201.29,149.17 201.9,148.56 202.17,148.29 202.17,145.97 202.17,145.78 202.17,145.4 199.82,143.06 199.82,131.24 202.59,128.47 202.59,126.67 204.39,124.87 204.39,115.79 207.54,112.64 207.54,106 209.69,103.86 209.69,69.66 208.52,68.49 208.52,65.54 208.91,65.15 208.91,64.12 208.3,63.51 208.3,59.12 211.62,55.8 211.62,52.55 214.29,49.88 214.44,49.88 216.44,47.88 223.1,47.88 224.11,48.89 231.72,48.89 232.71,47.9 236.76,47.9 237.55,48.68 240.82,48.68 241.53,49.39 249.98,49.39 251.06,48.31 259.08,48.31 260.85,46.55 268.91,46.55 269.15,46.31 271.89,46.31 274.11,48.53 287.22,48.53 291.97,43.78 297.27,43.78 297.43,43.93 303.67,43.93 304.67,44.94 307.29,44.94 v2(308.61,46.25)
PANELL_LED_R_DRV#: length 263.9
  TOP w0.102: JLOGO.9 229.92,167.04 229.75,166.87 228.8,166.87 v2(227.72,165.79) ; v2(309.19,46.25) 309.19,44 309.58,43.6 v1(310.52,43.6) 310.63,43.6 311.26,42.97 311.26,39.27 310.4,38.41 310.4,37.27 309.91,36.78 UE8.10
  IN4 w0.102: v2(227.72,165.79) 227.58,165.65 227.44,165.65 226.83,166.26 226.11,166.26 225.45,165.6 224.08,165.6 223.41,166.27 221.76,166.27 221.7,166.22 220.38,166.22 220.07,166.54 219.01,166.54 217.24,164.77 217.24,164.68 215.72,163.16 209.97,163.16 209.6,162.8 205.67,158.87 205.67,158.11 205.67,157.59 205.05,156.96 204.32,156.96 203.15,155.8 203.15,152.02 201.06,149.94 201.06,149.07 201.81,148.33 201.94,148.2 201.94,145.88 201.94,145.69 201.94,145.5 199.6,143.16 199.6,131.15 202.36,128.38 202.36,126.57 204.16,124.77 204.16,115.7 207.31,112.55 207.31,105.91 209.46,103.76 209.46,69.76 208.07,68.37 208.07,59.02 211.39,55.71 211.39,52.46 214.19,49.65 214.34,49.65 216.06,47.93 216.35,47.65 223.19,47.65 223.48,47.93 232.35,47.93 232.62,47.67 236.86,47.67 237.13,47.93 237.21,47.93 237.73,48.45 240.91,48.45 241.62,49.17 249.89,49.17 250.97,48.09 258.99,48.09 260.75,46.32 268.82,46.32 273.06,42.07 277.61,42.07 278.42,42.88 292.53,42.88 293.23,42.18 297.02,42.18 298.55,43.7 303.76,43.7 304.77,44.71 307.65,44.71 v2(309.19,46.25)
PANELR_LED_B_DRV#: length 263.7
  TOP w0.102: v2(306.4,47.84) 306.45,47.79 v1(306.45,46.25) 306.45,45.91 307.34,45.02 307.34,43.82 308.72,42.44 UE8.17 ; v2(233.31,166.25) 233.39,166.25 234.27,167.12 234.82,167.12 234.92,167.22 JLOGO.14
  IN4 w0.102: v2(233.31,166.25) 232.81,166.25 232.26,165.69 231.39,165.69 229.42,163.72 229.28,163.59 228.68,162.98 227.03,162.98 226.56,163.45 223.69,163.45 222.83,164.32 222.58,164.32 222.43,164.32 222.2,164.54 220.97,164.54 220.45,164.02 219.96,164.02 219.84,163.91 219.1,163.91 217.7,162.51 217.38,162.51 216.89,162.02 210.44,162.02 206.87,158.44 206.87,156.15 204.62,153.9 204.62,152.26 205.05,151.83 205.05,150.73 204.62,150.3 204.48,150.16 204.48,150.16 203.31,148.99 203.31,146.45 203.31,146.26 203.31,146.26 203.31,144.93 203.31,144.93 203.31,144.86 200.97,142.52 200.97,135.75 201.98,134.74 201.98,130.71 203.73,128.95 203.73,127.36 205.62,125.48 209.05,125.48 214.85,119.68 214.85,116.56 212.74,114.46 212.29,114.46 211.21,113.38 211.21,61.85 210.78,61.42 210.78,58.8 213.14,56.44 213.14,53.19 214.73,51.6 216.02,51.6 216.53,51.09 225.54,51.09 226.39,51.94 230.28,51.94 230.73,51.49 232.29,51.49 233.54,50.24 233.54,49.52 233.97,49.09 236.34,49.09 238.09,50.84 240.54,50.84 240.83,51.13 250.38,51.13 250.67,50.84 258.17,50.84 261.32,47.69 271.53,47.69 273.7,49.85 287.52,49.85 292.45,44.92 296.8,44.92 299.31,47.44 303.93,47.44 304.87,48.38 305.86,48.38 v2(306.4,47.84)
PANELR_LED_G_DRV#: length 260.4
  TOP w0.102: v2(307.03,47.81) 306.93,47.7 306.93,45.94 307.56,45.3 307.56,44.19 v1(308.1,43.65) 308.81,42.94 308.81,42.74 310.14,41.4 310.14,40.12 309.8,39.78 UE8.16 ; JLOGO.13 233.92,167.1 233.65,166.83 v2(233.29,166.83)
  IN4 w0.102: v2(307.03,47.81) 306.66,47.44 304.58,47.44 304.12,46.98 299.5,46.98 296.99,44.47 292.26,44.47 287.33,49.4 273.89,49.4 271.72,47.23 261.13,47.23 257.98,50.38 250.48,50.38 250.19,50.68 241.02,50.68 240.73,50.38 238.28,50.38 236.53,48.63 233.78,48.63 233.08,49.33 233.08,49.68 231.73,51.03 230.54,51.03 230.1,51.48 226.58,51.48 225.73,50.63 216.34,50.63 215.83,51.14 214.54,51.14 212.68,53 212.68,56.25 210.32,58.61 210.32,62.07 210.75,62.5 210.75,109.49 208.23,112.02 208.23,112.93 205.08,116.08 205.08,125.15 203.28,126.95 203.28,128.76 201.52,130.52 201.52,134.55 200.51,135.56 200.51,142.71 202.85,145.05 202.85,145.12 202.85,146.07 202.85,146.26 202.85,146.26 202.85,149.18 203.72,150.04 203.72,151.3 204.07,151.65 204.07,155.42 204.7,156.05 205.43,156.05 206.59,157.21 206.59,158.49 210.35,162.25 216.79,162.25 217.29,162.74 217.61,162.74 219.01,164.14 219.75,164.14 219.86,164.25 220.35,164.25 220.87,164.77 222.29,164.77 222.52,164.54 222.92,164.54 223.79,163.68 226.65,163.68 227.12,163.21 228.59,163.21 229.19,163.81 231.3,165.92 232.16,165.92 233.07,166.83 v2(233.29,166.83)
PANELR_LED_R_DRV#: length 263
  TOP w0.102: v2(231.66,166.33) 231.75,166.33 232.92,167.5 JLOGO.12 ; UE8.15 309.87,39.28 310.47,39.88 310.47,41.57 v1(310.13,41.91) 310.13,42.09 307.79,44.42 307.79,45.9 v2(307.44,46.25)
  IN4 w0.102: v2(307.44,46.25) 306.58,45.4 303.48,45.4 302.47,44.39 297.24,44.39 297.08,44.24 292.16,44.24 287.23,49.17 273.98,49.17 271.82,47.01 261.04,47.01 259.27,48.77 251.25,48.77 249.58,50.45 241.12,50.45 240.83,50.16 238.38,50.16 236.63,48.4 232.85,48.4 230,51.25 226.67,51.25 225.82,50.4 220.27,50.4 219.59,49.72 219.59,48.54 219.43,48.38 216.59,48.38 214.63,50.34 214.48,50.34 212.07,52.74 212.07,55.99 208.76,59.31 208.76,62.58 210.14,63.96 210.14,104.05 208,106.19 208,112.83 204.85,115.98 204.85,125.06 203.05,126.86 203.05,128.66 201.29,130.42 201.29,134.45 200.28,135.46 200.28,142.87 202.63,145.22 202.63,145.97 202.62,146.16 202.62,146.16 202.62,150.53 203.84,151.74 203.84,155.51 204.6,156.28 205.33,156.28 206.36,157.3 206.36,158.39 206.36,158.4 206.36,158.58 210.25,162.48 216.7,162.48 217.19,162.97 217.51,162.97 218.77,164.22 218.77,165.32 219.3,165.85 219.78,165.85 220.1,165.54 221.99,165.54 222.04,165.59 223.12,165.59 224.01,164.7 225.13,164.7 225.78,164.04 225.92,163.91 228.2,163.91 229.59,165.31 230.36,165.31 231.38,166.33 v2(231.66,166.33)
PB_USB2_RBIAS: length 5.4
  TOP w0.102: UT1.F19 183.92,169.49 v2(183.92,169.51)
  BOTTOM w0.102: v1(185.75,171.3) 185.75,169.84 RT44.1 185.48,170.03
  BOTTOM w0.127: 185.48,170.03 184.9,170.62 184.35,170.62 184.03,170.3 184.03,169.62 v2(183.92,169.51)
PBTN_OUT#: length 124.9
  TOP w0.089: CH174.1 216.02,20.69 217.23,19.49 RH2.2 ; CH174.1 215.96,21.63 v2(216.19,21.87) ; CH174.1 215.84,20.57 v2(215.84,19.47)
  TOP w0.114: UE5.106 303.62,15.21 302.74,16.09 302.68,16.09 302.53,16.25 v2(302.53,16.19)
  IN3 w0.127: v2(302.53,16.19) 302.53,16.76 303.12,17.35 303.12,20.76 302.24,21.65 302.24,24.12 300.85,25.52 293.44,25.52 288.85,30.11 281.23,30.11 280.53,30.81 269.65,30.81 268.43,32.03 259.74,32.03 259.24,32.53 249.03,32.53 247.06,30.56 243.15,30.56 238.24,25.64 235.74,25.64 235.38,25.28 235.38,25.28 235.13,25.04 234.57,24.48 233.33,24.48 232.35,25.45 231.01,25.45 228.04,28.42 228.04,31.87 227.91,31.99 226.29,31.99 v2(225.54,32.75)
  IN6 w0.081: v2(225.54,32.75) 225.23,32.44 223.37,32.44 221.37,30.44 221.37,27.09 220.97,26.7 220.97,26.36 221.05,26.28 221.05,25.71 220.42,25.07 220.42,24.66 219.24,23.48 219.18,23.48
  IN6 w0.089: v2(216.19,21.87) 216.19,22.82 216.75,23.37 218.87,23.37 218.99,23.48 219.18,23.48
  BOTTOM w0.122: UH1.BE46 v2(215.84,19.47)
