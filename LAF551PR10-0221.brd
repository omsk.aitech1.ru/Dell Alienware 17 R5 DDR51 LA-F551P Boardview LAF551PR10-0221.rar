# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D26: length 68.4
  IN1 w0.081: v2(142.43,100.27) 142.43,100.14 142.93,99.64 142.93,99.42 143.51,98.84 143.51,92.65 143.13,92.27 143.13,91.99 142.88,91.75 142.88,91.57 142.47,91.16 142.47,89.05 139.57,86.15 139.57,83.57 134.48,78.48 134.48,72.34 134.3,72.16 134.07,72.16 133.97,72.06 133.97,71.86 134.07,71.76 134.3,71.76 134.4,71.67 134.4,71.47 134.3,71.37 134.07,71.37 133.97,71.27 133.97,71.07 134.07,70.97 134.3,70.97 134.4,70.87 134.4,70.67 134.3,70.58 134.07,70.58 133.97,70.48 133.97,70.28 134.07,70.18 134.3,70.18 134.4,70.08 134.4,69.88 134.3,69.78 134.07,69.78 133.97,69.68 133.97,69.49 134.07,69.39 134.3,69.39 134.4,69.29 134.4,69.09 134.3,68.99 134.07,68.99 133.97,68.89 133.97,68.69 134.07,68.59 134.3,68.59 134.4,68.5 134.4,68.3 134.3,68.2 134.07,68.2 133.97,68.1 133.97,67.9 134.07,67.8 134.3,67.8 134.4,67.7 134.4,67.5 134.3,67.41 134.07,67.41 133.97,67.31 133.97,63.64 133.67,63.33 133.67,56.53 133.05,55.91 133.05,45.92 132.67,45.54 v2(132.17,45.54)
  BOTTOM w0.076: v2(142.43,100.27) UC1.BB8
  BOTTOM w0.114: JDIMM2.79 131.19,47.94 131.39,47.74 131.39,46.31 v2(132.17,45.54)
DDR_B_D27: length 67.7
  IN1 w0.081: v2(141.52,100.27) 141.52,100.13 141.16,99.77 141.16,99.47 141.72,98.91 141.87,98.91 142.3,98.48 142.3,93.25 141.8,92.75 141.8,92.12 141.55,91.88 141.55,91.75 141.41,91.61 141.41,89.71 137.63,85.94 137.63,84.21 132.11,78.68 132.11,67.02 130.77,65.68 130.77,62.17 130.75,62.14 130.75,48.67 130.06,47.98 130.06,45.2 129.99,45.13 129.99,44.01 129.91,43.93 129.57,43.93 129.49,44.01 129.49,44.11 129.32,44.27 v2(129.02,44.27)
  BOTTOM w0.076: v2(141.52,100.27) UC1.BC8
  BOTTOM w0.114: JDIMM2.66 127.94,43.19 v2(129.02,44.27)
DDR_B_D28: length 68.2
  IN1 w0.081: v2(141.52,101.57) 141.15,101.2 141.15,100.02 140.98,99.85 140.98,99.4 141.49,98.89 141.49,92.15 141.38,92.05 141.38,91.82 141.19,91.64 141.19,89.88 137.33,86.02 137.33,84.33 131.81,78.8 131.81,67.14 130.47,65.8 130.47,62.98 129.73,62.23 129.73,60.12 129.85,59.99 130.35,59.99 130.45,59.89 130.45,59.69 130.35,59.6 129.86,59.6 129.75,59.49 129.75,56.08 130.45,55.38 130.45,53.08 129.75,52.38 129.75,45.62 129.67,45.54 v2(129.02,45.54)
  BOTTOM w0.076: v2(141.52,101.57) UC1.BC10
  BOTTOM w0.114: JDIMM2.71 129.19,47.66 129.56,47.29 129.56,46.08 v2(129.02,45.54)
DDR_B_D29: length 69.8
  IN1 w0.081: v2(142.43,101.57) 142.8,101.2 142.8,100.06 143.75,99.11 143.75,92.36 143.14,91.75 143.14,91.49 142.69,91.04 142.69,88.95 139.87,86.13 139.87,83.45 134.78,78.35 134.78,67.03 134.7,66.95 134.39,66.95 134.31,66.87 134.31,66.71 134.39,66.63 134.7,66.63 134.78,66.55 134.78,66.38 134.7,66.3 134.39,66.3 134.31,66.22 134.31,66.06 134.39,65.98 134.7,65.98 134.78,65.9 134.78,65.48 134.56,65.26 134.56,63.79 133.97,63.2 133.97,62.77 134.07,62.67 134.4,62.67 134.5,62.57 134.5,62.37 134.4,62.27 134.07,62.27 133.97,62.18 133.97,56.4 133.35,55.78 133.35,44.61 133.01,44.27 v2(132.17,44.27)
  BOTTOM w0.076: v2(142.43,101.57) UC1.BB10
  BOTTOM w0.114: v2(132.17,44.27) 131.44,43.55 JDIMM2.80
DDR_B_D30: length 65.8
  IN1 w0.081: v2(129.02,43) 129.39,43 129.4,43 129.63,43 130.29,43.66 130.29,44.61 130.36,44.68 130.36,47.85 131.05,48.54 131.05,62.01 131.07,62.04 131.07,65.46 132.47,66.86 132.47,78.6 137.94,84.07 137.94,85.84 141.62,89.52 141.62,91.58 141.72,91.68 141.72,91.8 142.04,92.11 142.04,92.65 142.51,93.12 142.51,98.52 141.52,99.51 v2(141.52,99.62)
  BOTTOM w0.076: v2(141.52,99.62) UC1.BC7
  BOTTOM w0.114: JDIMM2.70 128.94,42.92 v2(129.02,43)
DDR_B_D31: length 67.2
  IN1 w0.081: v2(132.17,46.81) 132.49,46.81 132.75,47.07 132.75,48.62 132.6,48.77 132.6,49.06 132.75,49.21 132.75,49.41 132.65,49.51 132.35,49.51 132.25,49.61 132.25,49.81 132.35,49.9 132.65,49.9 132.75,50 132.75,53.23 132.65,53.33 132.44,53.33 132.34,53.42 132.34,53.63 132.44,53.72 132.65,53.72 132.75,53.82 132.75,54.02 132.65,54.12 132.38,54.12 132.28,54.22 132.28,54.42 132.38,54.52 132.65,54.52 132.75,54.62 132.75,54.81 132.65,54.91 132.38,54.91 132.28,55.01 132.28,55.17 132.42,55.31 132.65,55.31 132.75,55.41 132.75,56.03 133.36,56.65 133.36,64.13 133.68,64.44 133.68,72.9 133.86,73.08 134.08,73.08 134.18,73.18 134.18,73.38 134.08,73.47 133.86,73.47 133.76,73.57 133.76,73.77 133.86,73.87 134.08,73.87 134.18,73.97 134.18,74.17 134.08,74.27 133.86,74.27 133.76,74.37 133.76,74.56 133.86,74.66 134.08,74.66 134.18,74.76 134.18,74.96 134.08,75.06 133.86,75.06 133.76,75.16 133.76,75.36 133.86,75.46 134.08,75.46 134.18,75.55 134.18,75.75 134.08,75.85 133.86,75.85 133.76,75.95 133.76,76.15 133.86,76.25 134.08,76.25 134.18,76.35 134.18,76.55 134.08,76.64 133.86,76.64 133.76,76.74 133.76,76.94 133.86,77.04 134.08,77.04 134.18,77.14 134.18,77.34 134.08,77.44 133.86,77.44 133.76,77.54 133.76,78.19 139.27,83.7 139.27,86.22 142.26,89.22 142.26,91.28 142.66,91.67 142.66,91.8 142.82,91.96 142.82,92.42 143.23,92.83 143.23,98.72 142.76,99.19 142.76,99.3 v2(142.43,99.62)
  BOTTOM w0.076: v2(142.43,99.62) UC1.BB7
  BOTTOM w0.114: v2(132.17,46.81) 132.19,46.84 JDIMM2.83
DDR_B_D32: length 68.9
  IN1 w0.081: v2(158.89,102.22) 159.36,101.76 159.36,101.42 159.44,101.34 159.44,100.18 159.76,99.86 159.76,98.87 160.19,98.44 160.19,93.53 163.51,90.21 163.51,72.98 160.15,69.63 160.15,60.63 160.73,60.05 160.73,52.07 159.55,50.89 159.55,50.19 159.71,50.03 160.2,50.03 160.28,49.95 160.28,49.29 160.2,49.21 159.3,49.21 159.2,49.11 159.2,48.91 159.3,48.81 160.4,48.81 160.47,48.74 160.47,48.48 160.4,48.41 159.3,48.41 159.2,48.32 159.2,48.12 159.3,48.02 160.4,48.02 160.47,47.95 160.47,47.7 160.39,47.62 159.27,47.62 159.2,47.55 159.2,47.3 159.3,47.2 159.55,47.2 159.63,47.12 v2(159.63,46.87)
  BOTTOM w0.076: v2(158.89,102.22) UC1.AA11
  BOTTOM w0.114: v2(159.63,46.87) 160.2,47.43 JDIMM2.187
DDR_B_D33: length 68.6
  IN1 w0.081: v2(159.63,45.6) 159.63,45.57 159.12,45.06 158.98,45.06 158.9,45.14 158.9,45.76 158.98,45.84 159.12,45.84 159.2,45.93 159.2,46.09 159.12,46.17 158.98,46.17 158.9,46.25 158.9,46.41 158.98,46.49 159.12,46.49 159.2,46.58 159.2,46.74 159.12,46.82 158.98,46.82 158.9,46.9 158.9,49.23 159.25,49.59 159.25,51.01 159.92,51.68 159.92,52.59 160.02,52.68 160.18,52.68 160.28,52.78 160.28,52.98 160.18,53.08 159.99,53.08 159.89,53.18 159.89,53.38 159.99,53.48 160.2,53.48 160.3,53.58 160.3,53.77 160.2,53.87 159.99,53.87 159.89,53.97 159.89,54.17 159.99,54.27 160.32,54.27 160.42,54.37 160.42,54.57 160.32,54.67 159.99,54.67 159.89,54.76 159.89,55.03 159.97,55.11 160.32,55.11 160.4,55.19 160.4,59.96 159.85,60.51 159.85,69.75 163.17,73.07 163.17,87.99 163.05,88.12 163.05,90.38 159.98,93.45 159.98,98.4 159.59,98.79 159.59,99.75 159.26,100.07 159.26,101.2 v2(158.89,101.57)
  BOTTOM w0.076: v2(158.89,101.57) UC1.AA10
  BOTTOM w0.114: v2(159.63,45.6) 159.2,46.03 JDIMM2.183
DDR_B_D34: length 67.4
  IN1 w0.081: v2(157.98,102.22) 157.53,101.77 157.53,101.49 157.2,101.16 157.2,99.3 157.76,98.75 157.76,92.4 159.99,90.17 159.99,74.12 156.76,70.89 156.76,53.32 156.08,52.63 156.08,50.2 155.21,49.34 155.21,43.93 155.29,43.85 155.57,43.85 155.65,43.77 155.65,43.61 155.57,43.52 155.29,43.52 155.21,43.44 155.21,43.29 155.37,43.13 156.38,43.13 v2(156.46,43.04)
  BOTTOM w0.076: v2(157.98,102.22) UC1.AC11
  BOTTOM w0.114: JDIMM2.174 156.94,42.54 156.46,43.02 v2(156.46,43.04)
DDR_B_D35: length 66.2
  IN1 w0.081: v2(157.98,101.57) 157.41,101 157.41,99.39 157.99,98.81 157.99,92.55 160.29,90.25 160.29,83.05 160.39,82.95 160.52,82.95 160.62,82.86 160.62,82.66 160.52,82.56 160.39,82.56 160.29,82.46 160.29,82.26 160.39,82.16 160.52,82.16 160.62,82.06 160.62,81.86 160.52,81.77 160.39,81.77 160.29,81.67 160.29,73.99 157.06,70.77 157.06,53.19 156.38,52.51 156.38,50.08 155.51,49.21 155.51,45.26 v2(156.46,44.31)
  BOTTOM w0.076: UC1.AC10 157.65,101.25 v2(157.98,101.57)
  BOTTOM w0.114: JDIMM2.170 155.94,41.46 156.05,41.57 156.05,43.9 v2(156.46,44.31)
DDR_B_D36: length 66.2
  IN1 w0.081: v2(158.89,99.62) 158.89,99.49 158.96,99.42 158.96,93 162.57,89.4 162.57,84.26 162.57,84.26 162.57,73.32 159.25,70 159.25,67.13 159.15,67.03 158.97,67.03 158.87,66.93 158.87,66.74 158.97,66.64 159.15,66.64 159.25,66.55 159.25,66.35 159.15,66.26 158.97,66.26 158.87,66.16 158.87,65.97 158.97,65.87 159.15,65.87 159.25,65.78 159.25,65.58 159.15,65.49 158.97,65.49 158.87,65.39 158.87,65.2 158.97,65.1 159.15,65.1 159.25,65 159.25,64.81 159.15,64.71 158.97,64.71 158.87,64.62 158.87,64.42 158.97,64.33 159.15,64.33 159.25,64.23 159.25,59.95 159.23,59.93 159.23,54.85 159.29,54.79 159.29,51.9 158.65,51.26 158.65,49.84 158.29,49.48 158.29,43.51 158.75,43.06 v2(159.63,43.06)
  BOTTOM w0.076: v2(158.89,99.62) UC1.AA7
  BOTTOM w0.114: JDIMM2.182 158.94,41.9 159.34,42.3 159.34,42.77 v2(159.63,43.06)
DDR_B_D37: length 66.6
  IN1 w0.081: v2(159.63,44.33) 159.28,44.33 159.14,44.19 159.14,43.6 159.06,43.52 158.76,43.52 158.59,43.68 158.59,49.36 158.95,49.71 158.95,51.14 159.59,51.78 159.59,55.18 160.1,55.69 160.1,59.83 159.55,60.39 159.55,69.87 162.87,73.19 162.87,90.24 159.78,93.33 159.78,98.35 159.38,98.74 159.38,99.66 158.95,100.1 158.95,100.21 v2(158.89,100.27)
  BOTTOM w0.076: v2(158.89,100.27) UC1.AA8
  BOTTOM w0.114: v2(159.63,44.33) 160.09,43.87 160.09,42.64 159.95,42.5 159.95,40.8 JDIMM2.186
DDR_B_D38: length 65.3
  IN1 w0.081: v2(157.98,100.27) 157.61,99.9 157.61,99.43 158.2,98.84 158.2,92.65 160.92,89.94 160.92,85.43 160.82,85.33 160.69,85.33 160.59,85.23 160.59,85.03 160.69,84.93 160.82,84.93 160.92,84.83 160.92,84.63 160.82,84.54 160.69,84.54 160.59,84.44 160.59,84.24 160.69,84.14 160.82,84.14 160.92,84.04 160.92,83.84 160.82,83.74 160.69,83.74 160.59,83.64 160.59,83.45 160.69,83.35 160.82,83.35 160.92,83.25 160.92,81.74 160.59,81.41 160.59,73.59 157.36,70.37 157.36,53.06 156.68,52.38 156.68,49.95 155.82,49.09 155.82,48.39 155.92,48.29 156.03,48.29 156.13,48.19 156.13,47.99 156.03,47.89 155.92,47.89 155.82,47.79 155.82,45.92 156.16,45.58 v2(156.46,45.58)
  BOTTOM w0.076: v2(157.98,100.27) UC1.AC8
  BOTTOM w0.114: JDIMM2.169 155.69,47.94 155.46,47.71 155.46,45.96 155.84,45.58 v2(156.46,45.58)
DDR_B_D39: length 64.8
  IN1 w0.081: v2(156.46,46.85) 156.46,47.04 156.56,47.14 156.65,47.14 156.73,47.22 156.73,47.45 156.65,47.53 156.49,47.53 156.39,47.63 156.39,47.83 156.49,47.93 156.69,47.93 156.79,48.03 156.79,48.22 156.69,48.31 156.51,48.31 156.41,48.41 156.41,49.25 156.98,49.82 156.98,51.54 157.67,52.22 157.67,55.64 157.77,55.74 157.92,55.74 158.02,55.84 158.02,56.04 157.92,56.14 157.77,56.14 157.67,56.24 157.67,56.44 157.77,56.53 157.92,56.53 158.02,56.63 158.02,56.83 157.92,56.93 157.77,56.93 157.67,57.03 157.67,70.24 161.22,73.8 161.22,74.35 161.12,74.45 160.99,74.45 160.89,74.55 160.89,74.75 160.99,74.85 161.12,74.85 161.22,74.95 161.22,75.14 161.12,75.24 160.99,75.24 160.89,75.34 160.89,75.54 160.99,75.64 161.12,75.64 161.22,75.74 161.22,75.94 161.12,76.04 160.99,76.04 160.89,76.13 160.89,76.33 160.99,76.43 161.12,76.43 161.22,76.53 161.22,76.73 161.12,76.83 160.99,76.83 160.89,76.93 160.89,77.13 160.99,77.22 161.12,77.22 161.22,77.32 161.22,77.52 161.12,77.62 160.99,77.62 160.89,77.72 160.89,77.92 160.99,78.02 161.12,78.02 161.22,78.12 161.22,78.31 161.12,78.41 160.99,78.41 160.89,78.51 160.89,78.71 160.99,78.81 161.12,78.81 161.22,78.91 161.22,79.11 161.12,79.21 160.99,79.21 160.89,79.3 160.89,79.5 160.99,79.6 161.12,79.6 161.22,79.7 161.22,79.9 161.12,80 160.99,80 160.89,80.1 160.89,80.3 160.99,80.39 161.12,80.39 161.22,80.49 161.22,80.69 161.12,80.79 160.99,80.79 160.89,80.89 160.89,81.09 160.99,81.19 161.12,81.19 161.22,81.29 161.22,89.89 158.41,92.7 158.41,98.93 157.98,99.35 v2(157.98,99.71)
  BOTTOM w0.114: v2(156.46,46.85) 156.46,47.29 156.69,47.52 JDIMM2.173
  BOTTOM w0.127: v2(157.98,99.71) 157.56,99.3 UC1.AC7
DDR_B_D40: length 68
  IN1 w0.081: v2(160.72,99.73) 160.33,99.34 160.33,99.05 160.8,98.59 160.8,93.8 164.84,89.76 164.84,72.44 161.91,69.5 161.91,66.35 162.01,66.25 162.49,66.25 162.59,66.16 162.59,65.91 162.49,65.81 162.01,65.81 161.91,65.72 161.91,65.47 162.01,65.37 162.49,65.37 162.59,65.27 162.59,65.02 162.49,64.93 161.99,64.93 161.91,64.84 161.91,64.6 162.01,64.51 162.49,64.51 162.59,64.41 162.59,64.09 162.44,63.95 162.44,63.77 162.59,63.62 162.59,63.44 162.44,63.3 162.44,63.12 162.59,62.97 162.59,62.48 162.49,62.39 162.01,62.39 161.91,62.29 161.91,62.09 162.01,61.99 162.49,61.99 162.59,61.89 162.59,61.69 162.49,61.59 162.01,61.59 161.91,61.49 161.91,61.3 162.01,61.2 162.49,61.2 162.59,61.1 162.59,60.36 162.8,60.15 162.8,55.63 162.52,55.35 162.52,49.87 162.42,49.77 162.16,49.77 162.06,49.67 162.06,49.47 162.16,49.37 162.42,49.37 162.52,49.27 162.52,49.05 162.42,48.95 161.65,48.95 161.55,48.85 161.55,48.64 161.65,48.54 162.26,48.54 162.36,48.45 162.36,48.18 162.23,48.06 161.68,48.06 161.54,47.92 161.54,47.05 v2(161.66,46.93)
  BOTTOM w0.076: v2(160.72,99.73) 160.51,99.95 UC1.W8
  BOTTOM w0.114: v2(161.66,46.93) 161.49,46.76 161.16,46.76 161.04,46.87 161.04,47.55 161.2,47.7 JDIMM2.191
DDR_B_D41: length 67.4
  IN1 w0.081: v2(161.66,45.66) 161.66,45.59 162.1,45.16 162.21,45.16 162.29,45.24 162.29,45.49 162.21,45.58 162.21,45.58 162.12,45.66 162.12,45.82 162.21,45.9 162.21,45.9 162.29,45.98 162.29,46.14 162.21,46.23 162.21,46.23 162.12,46.31 162.12,46.47 162.21,46.55 162.21,46.55 162.29,46.63 162.29,46.89 162.51,47.1 162.51,47.22 162.42,47.3 162.14,47.3 162.06,47.38 162.06,47.55 162.14,47.63 162.42,47.63 162.51,47.71 162.51,47.9 162.82,48.22 162.82,55.22 163.1,55.5 163.1,60.29 162.89,60.51 162.89,66.46 162.79,66.55 162.31,66.55 162.21,66.65 162.21,66.85 162.31,66.95 162.79,66.95 162.89,67.05 162.89,67.25 162.79,67.35 162.31,67.35 162.21,67.45 162.21,67.64 162.31,67.74 162.79,67.74 162.89,67.84 162.89,68.04 162.79,68.14 162.31,68.14 162.21,68.24 162.21,68.44 162.31,68.54 162.79,68.54 162.89,68.63 162.89,68.83 162.79,68.93 162.4,68.93 162.31,69.03 162.31,69.23 162.4,69.33 162.79,69.33 162.89,69.43 162.89,69.9 165.14,72.16 165.14,89.71 160.98,93.88 160.98,98.92 v2(160.72,99.17)
  BOTTOM w0.076: UC1.W7 160.6,99.3 v2(160.72,99.17)
  BOTTOM w0.114: JDIMM2.195 162.2,46.19 v2(161.66,45.66)
DDR_B_D42: length 69.3
  IN1 w0.081: v2(165.34,45.6) 164.85,46.08 164.85,48.11 164.94,48.19 165.09,48.19 165.17,48.27 165.17,48.43 165.09,48.52 164.94,48.52 164.85,48.6 164.85,48.76 164.94,48.84 165.09,48.84 165.17,48.92 165.17,49.08 165.09,49.17 164.94,49.17 164.85,49.25 164.85,49.62 165.25,50.02 165.25,55.2 165.75,55.69 165.75,60.5 165.68,60.57 165.37,60.57 165.24,60.7 165.24,60.88 165.32,60.96 165.66,60.96 165.74,61.04 165.74,61.21 165.66,61.29 165.32,61.29 165.24,61.37 165.24,61.53 165.32,61.61 165.66,61.61 165.74,61.69 165.74,61.86 165.66,61.94 165.32,61.94 165.24,62.02 165.24,66.91 165.34,67 165.65,67 165.75,67.1 165.75,67.29 165.65,67.39 165.34,67.39 165.24,67.49 165.24,67.68 165.34,67.78 165.65,67.78 165.75,67.87 165.75,68.07 165.65,68.16 165.34,68.16 165.24,68.26 165.24,68.45 165.34,68.55 165.65,68.55 165.75,68.65 165.75,68.84 165.65,68.94 165.34,68.94 165.24,69.03 165.24,69.26 166.95,70.97 166.95,89.46 167.08,89.59 167.08,90.09 162.54,94.63 162.54,98.77 162.2,99.11 162.2,99.83 162,100.02 162,101.17 v2(161.6,101.57)
  BOTTOM w0.076: UC1.V10 161.18,101.27 v2(161.6,101.57)
  BOTTOM w0.114: JDIMM2.203 164.19,46.74 v2(165.34,45.6)
DDR_B_D43: length 70.5
  IN1 w0.081: v2(161.61,102.22) 162.18,101.65 162.18,100.18 162.49,99.88 162.49,99.07 162.72,98.84 162.72,94.71 167.33,90.09 167.33,89.78 167.71,89.4 167.71,87.42 167.32,87.03 167.32,70.91 166.05,69.64 166.05,69.51 166.13,69.43 166.17,69.43 166.25,69.35 166.25,69.19 166.17,69.11 166.13,69.11 166.05,69.03 166.05,68.86 166.13,68.78 166.17,68.78 166.25,68.7 166.25,68.54 166.17,68.46 166.13,68.46 166.05,68.38 166.05,68.21 166.13,68.13 166.17,68.13 166.25,68.05 166.25,67.89 166.17,67.81 166.13,67.81 166.05,67.72 166.05,67.56 166.13,67.48 166.17,67.48 166.25,67.4 166.25,67.24 166.17,67.16 166.13,67.16 166.05,67.07 166.05,66.7 165.95,66.61 165.64,66.61 165.54,66.51 165.54,66.32 165.7,66.16 166.21,66.16 166.29,66.07 166.29,65.86 166.21,65.77 165.62,65.77 165.54,65.69 165.54,65.55 165.7,65.39 166.21,65.39 166.29,65.3 166.29,65.06 166.21,64.97 165.62,64.97 165.54,64.89 165.54,64.74 165.7,64.58 166.21,64.58 166.29,64.5 166.29,64.29 166.21,64.2 165.62,64.2 165.54,64.12 165.54,63.97 165.7,63.81 166.21,63.81 166.29,63.72 166.29,63.51 166.21,63.43 165.62,63.43 165.54,63.34 165.54,63.2 165.7,63.04 166.21,63.04 166.29,62.95 166.29,62.71 166.21,62.62 165.62,62.62 165.54,62.54 165.54,62.4 165.64,62.3 165.95,62.3 166.05,62.2 166.05,61.59 166.19,61.45 166.19,61.26 166.05,61.12 166.05,60.94 166.19,60.8 166.19,60.61 166.05,60.47 166.05,60.29 166.19,60.15 166.19,59.96 166.05,59.82 166.05,59.64 166.19,59.5 166.19,59.31 166.05,59.17 166.05,58.99 166.19,58.85 166.19,58.66 166.05,58.52 166.05,58.34 166.19,58.2 166.19,58.01 166.05,57.87 166.05,57.69 166.19,57.55 166.19,57.36 166.05,57.22 166.05,57.04 166.19,56.9 166.19,56.71 166.05,56.57 166.05,55.56 165.55,55.07 165.55,49.84 165.49,49.77 165.49,47.02 v2(165.34,46.87)
  BOTTOM w0.076: v2(161.61,102.22) 161.18,101.92 UC1.V11
  BOTTOM w0.114: v2(165.34,46.87) 165.19,47.01 JDIMM2.207
DDR_B_D44: length 69.8
  IN1 w0.081: v2(161.66,44.39) 161.34,44.39 161.26,44.47 161.26,49.71 161.38,49.83 161.82,49.83 162.04,50.05 162.15,50.05 162.22,50.12 162.22,51.14 162.14,51.22 161.7,51.22 161.59,51.33 161.59,51.44 161.7,51.55 162.14,51.55 162.22,51.63 162.22,55.47 162.5,55.75 162.5,59.9 162.25,60.14 162.25,60.74 162.17,60.82 161.69,60.82 161.61,60.9 161.61,62.56 161.72,62.67 162.07,62.67 162.15,62.75 162.15,63.91 161.61,64.45 161.61,69.63 164.54,72.56 164.54,89.81 160.6,93.75 160.6,98.54 160.14,98.99 160.14,99.79 160.29,99.94 160.29,101.61 160.37,101.69 160.6,101.69 v2(160.72,101.57)
  BOTTOM w0.076: UC1.W11 160.4,102.03 160.51,102.03 160.6,101.94 160.63,101.94 160.72,101.85 v2(160.72,101.57)
  BOTTOM w0.114: JDIMM2.190 160.94,42.26 161.17,42.49 161.17,42.72 160.94,42.94 160.94,43.17 161.17,43.4 161.17,43.63 160.94,43.86 160.94,44.28 161.06,44.39 v2(161.66,44.39)
DDR_B_D45: length 69.8
  IN1 w0.081: v2(159.82,101.03) 159.96,100.89 159.96,98.92 160.39,98.49 160.39,93.7 164.24,89.86 164.24,72.68 161.31,69.75 161.31,60.66 162.19,59.77 162.19,55.88 161.92,55.6 161.92,55.36 161.84,55.28 161.32,55.28 161.24,55.2 161.24,55.03 161.32,54.95 161.84,54.95 161.92,54.87 161.92,54.71 161.84,54.63 161.32,54.63 161.24,54.55 161.24,54.38 161.32,54.3 161.84,54.3 161.92,54.22 161.92,54.06 161.84,53.98 161.32,53.98 161.24,53.9 161.24,53.73 161.32,53.65 161.84,53.65 161.92,53.57 161.92,53.41 161.84,53.33 161.32,53.33 161.24,53.25 161.24,53.08 161.32,53 161.84,53 161.92,52.92 161.92,52.19 161.21,51.49 161.21,50.07 160.96,49.82 160.96,43.83 v2(161.66,43.12)
  BOTTOM w0.076: UC1.W10 160.04,101.25 v2(159.82,101.03)
  BOTTOM w0.114: JDIMM2.194 161.94,42.84 v2(161.66,43.12)
DDR_B_D46: length 66.9
  IN1 w0.081: v2(165.34,43.06) 164.52,43.06 164.09,43.49 164.09,44.25 164.17,44.33 164.33,44.33 164.41,44.41 164.41,44.57 164.33,44.65 164.17,44.65 164.09,44.73 164.09,49.71 164.62,50.24 164.62,61.48 164.09,62.01 164.09,65.84 164.19,65.93 164.44,65.93 164.54,66.03 164.54,66.22 164.44,66.32 164.19,66.32 164.09,66.42 164.09,66.61 164.19,66.71 164.44,66.71 164.54,66.8 164.54,67 164.44,67.09 164.19,67.09 164.09,67.19 164.09,67.38 164.19,67.48 164.44,67.48 164.54,67.58 164.54,67.77 164.44,67.86 164.19,67.86 164.09,67.96 164.09,68.15 164.19,68.25 164.44,68.25 164.54,68.35 164.54,68.54 164.44,68.64 164.19,68.64 164.09,68.73 164.09,68.96 166.35,71.22 166.35,89.47 161.55,94.27 161.55,99.53 v2(161.64,99.62)
  BOTTOM w0.076: v2(161.64,99.62) UC1.V7
  BOTTOM w0.114: JDIMM2.208 165.44,42.95 v2(165.34,43.06)
DDR_B_D47: length 67.8
  IN1 w0.081: v2(165.34,44.33) 165.15,44.14 164.78,44.14 164.69,44.22 164.69,44.69 164.47,44.91 164.47,45.13 164.56,45.21 164.84,45.21 164.92,45.29 164.92,45.45 164.84,45.53 164.56,45.53 164.47,45.61 164.47,49.67 164.92,50.11 164.92,62.13 164.82,62.22 164.51,62.22 164.41,62.32 164.41,62.51 164.51,62.61 164.85,62.61 164.94,62.71 164.94,64.38 164.85,64.48 164.49,64.48 164.39,64.58 164.39,64.77 164.49,64.87 164.85,64.87 164.94,64.96 164.94,65.16 164.85,65.25 164.49,65.25 164.39,65.35 164.39,65.54 164.49,65.64 164.85,65.64 164.94,65.73 164.94,69.38 166.65,71.09 166.65,89.41 166.89,89.65 166.89,90.03 162.35,94.57 162.35,98.7 162.02,99.02 162.02,99.76 161.64,100.14 v2(161.64,100.27)
  BOTTOM w0.076: v2(161.64,100.27) UC1.V8
  BOTTOM w0.114: JDIMM2.204 164.44,43.43 v2(165.34,44.33)
DDR_B_D48: length 69.4
  IN1 w0.081: v2(167.18,43.12) 166.25,44.05 166.25,49.59 166.72,50.06 166.72,54.68 166.78,54.75 166.78,65.3 166.86,65.38 167.25,65.38 167.33,65.46 167.33,65.62 167.25,65.71 166.86,65.71 166.78,65.79 166.78,65.95 166.86,66.03 167.25,66.03 167.33,66.11 167.33,66.28 167.25,66.36 166.86,66.36 166.78,66.44 166.78,66.6 166.86,66.68 167.25,66.68 167.33,66.76 167.33,66.93 167.25,67.01 166.86,67.01 166.78,67.09 166.78,67.25 166.86,67.33 167.25,67.33 167.33,67.41 167.33,67.58 167.25,67.66 166.86,67.66 166.78,67.74 166.78,68.09 168.05,69.35 168.05,89.63 163.1,94.58 163.1,98.93 162.74,99.28 162.74,99.92 162.92,100.1 162.92,101.28 163.07,101.43 163.07,101.83 v2(163.47,102.22)
  BOTTOM w0.076: v2(163.47,102.22) UC1.R11
  BOTTOM w0.114: v2(167.18,43.12) 167.44,42.86 JDIMM2.216
DDR_B_D49: length 68.9
  IN1 w0.081: v2(164.38,102.22) 164.93,101.68 164.93,100.62 165.1,100.44 165.1,98.41 165.66,97.85 165.66,95.2 170.63,90.22 170.63,90.08 171.12,89.6 171.12,86.72 171.86,85.98 171.86,68.46 171.78,68.38 171.48,68.38 171.4,68.3 171.4,68.14 171.48,68.05 171.78,68.05 171.86,67.97 171.86,67.81 171.78,67.73 171.48,67.73 171.4,67.65 171.4,67.49 171.48,67.4 171.78,67.4 171.86,67.32 171.86,67.16 171.78,67.08 171.48,67.08 171.4,67 171.4,66.84 171.48,66.75 171.78,66.75 171.86,66.67 171.86,66.51 171.78,66.43 171.48,66.43 171.4,66.35 171.4,66.18 171.48,66.1 171.78,66.1 171.86,66.02 171.86,61.03 171.81,60.99 171.81,55.42 171.17,54.77 171.17,48.49 171.51,48.15 171.51,43.76 v2(170.8,43.06)
  BOTTOM w0.076: v2(164.38,102.22) UC1.P11
  BOTTOM w0.114: v2(170.8,43.06) 170.44,42.7 JDIMM2.228
DDR_B_D50: length 65
  IN1 w0.081: v2(164.38,99.62) 164.38,98.38 165.01,97.74 165.01,95.09 169.87,90.23 169.87,89.79 170.26,89.4 170.26,69.9 170.4,69.76 170.4,56.52 169.68,55.81 169.68,54.08 170.26,53.5 170.26,52.62 169.89,52.25 169.89,51.7 169.79,51.6 169.65,51.6 169.55,51.5 169.55,51.3 169.65,51.2 169.79,51.2 169.89,51.1 169.89,50.26 169.55,49.92 169.55,48.57 170.06,48.06 170.06,47 169.68,46.62 169.68,44.97 169.76,44.89 170.17,44.89 170.25,44.97 170.25,45.46 170.39,45.6 v2(170.8,45.6)
  BOTTOM w0.076: v2(164.38,99.62) UC1.P7
  BOTTOM w0.114: v2(170.8,45.6) 169.69,46.7 JDIMM2.225
DDR_B_D51: length 65.4
  IN1 w0.081: v2(167.18,46.93) 166.89,47.23 166.89,48.02 167.05,48.19 167.87,48.19 167.97,48.29 167.97,48.5 167.87,48.6 167.27,48.6 167.17,48.7 167.17,48.89 167.27,48.99 167.87,48.99 167.97,49.09 167.97,49.29 167.87,49.39 167.52,49.39 167.42,49.49 167.42,49.69 167.52,49.78 167.87,49.78 167.97,49.88 167.97,50.63 167.87,50.73 167.52,50.73 167.42,50.83 167.42,51.03 167.52,51.13 167.71,51.13 167.97,51.39 167.97,59.36 168.09,59.48 168.09,64.46 168.19,64.56 168.36,64.56 168.46,64.65 168.46,64.84 168.36,64.94 168.19,64.94 168.09,65.04 168.09,65.23 168.19,65.33 168.36,65.33 168.46,65.42 168.46,65.62 168.36,65.71 168.19,65.71 168.09,65.81 168.09,66.04 168.19,66.14 168.35,66.14 168.45,66.23 168.45,66.42 168.35,66.52 168.19,66.52 168.09,66.62 168.09,66.81 168.19,66.91 168.35,66.91 168.45,67 168.45,67.2 168.35,67.29 168.19,67.29 168.09,67.39 168.09,67.58 168.19,67.68 168.35,67.68 168.45,67.78 168.45,67.97 168.35,68.07 168.19,68.07 168.09,68.16 168.09,68.36 168.19,68.45 168.35,68.45 168.45,68.55 168.45,68.91 168.76,69.21 168.76,89.42 163.45,94.72 163.45,99.07 163.1,99.43 163.1,99.77 163.47,100.14 v2(163.47,100.27)
  BOTTOM w0.076: v2(163.47,100.27) UC1.R8
  BOTTOM w0.114: v2(167.18,46.93) 167.19,47.87 JDIMM2.215
DDR_B_D52: length 66.9
  IN1 w0.081: v2(167.18,45.66) 166.63,45.66 166.55,45.74 166.55,48.78 166.63,48.86 166.81,48.86 166.89,48.94 166.89,49.1 166.81,49.19 166.63,49.19 166.55,49.27 166.55,49.47 167.12,50.04 167.12,52.62 167.22,52.72 167.6,52.72 167.67,52.8 167.67,53.05 167.57,53.15 167.11,53.15 167.02,53.25 167.02,53.44 167.11,53.54 167.57,53.54 167.67,53.64 167.67,53.84 167.57,53.94 167.11,53.94 167.02,54.04 167.02,54.24 167.11,54.34 167.57,54.34 167.67,54.43 167.67,59.7 167.79,59.82 167.79,68.67 168.35,69.23 168.35,72.12 168.35,72.12 168.35,89.58 163.28,94.65 163.28,99 162.92,99.36 162.92,99.85 163.1,100.03 163.1,101.2 v2(163.47,101.57)
  BOTTOM w0.076: v2(163.47,101.57) UC1.R10
  BOTTOM w0.114: JDIMM2.211 166.19,46.65 v2(167.18,45.66)
DDR_B_D53: length 68
  IN1 w0.081: v2(164.38,101.57) 164.75,101.2 164.75,100.55 164.93,100.37 164.93,98.33 165.42,97.84 165.42,95.18 170.25,90.35 170.25,90.06 170.83,89.48 170.83,86.6 171.51,85.93 171.51,69.64 171,69.13 171,65.77 171.09,65.69 171.38,65.69 171.46,65.61 171.46,65.44 171.38,65.36 171.09,65.36 171,65.28 171,65.12 171.09,65.04 171.38,65.04 171.46,64.96 171.46,64.79 171.38,64.71 171.09,64.71 171,64.63 171,64.47 171.09,64.39 171.38,64.39 171.46,64.31 171.46,64.14 171.38,64.06 171.09,64.06 171,63.98 171,60.77 171.51,60.27 171.51,55.54 170.87,54.9 170.87,48.36 171.21,48.02 171.21,44.73 v2(170.8,44.33)
  BOTTOM w0.076: v2(164.38,101.57) UC1.P10
  BOTTOM w0.114: v2(170.8,44.33) 169.44,42.97 JDIMM2.224
DDR_B_D54: length 63.6
  IN1 w0.081: v2(167.18,44.39) 167.6,44.39 167.71,44.5 167.71,47.21 168.27,47.77 168.27,59.23 168.39,59.35 168.39,63.29 168.49,63.39 168.66,63.39 168.76,63.49 168.76,63.68 168.66,63.78 168.49,63.78 168.39,63.87 168.39,64.07 168.49,64.16 168.66,64.16 168.76,64.26 168.76,68.79 169.06,69.09 169.06,89.37 163.63,94.8 163.63,99.46 v2(163.47,99.62)
  BOTTOM w0.076: v2(163.47,99.62) UC1.R7
  BOTTOM w0.114: v2(167.18,44.39) 166.44,43.65 JDIMM2.212
DDR_B_D55: length 65.4
  IN1 w0.081: v2(170.8,46.87) 170.56,46.87 170.44,46.98 170.44,47.26 170.54,47.36 170.81,47.36 170.91,47.46 170.91,47.65 170.81,47.75 170.67,47.75 170.51,47.91 170.51,48.47 170.33,48.65 169.95,48.65 169.85,48.75 169.85,48.95 169.95,49.05 170.47,49.05 170.56,49.15 170.56,49.34 170.47,49.44 169.95,49.44 169.85,49.54 169.85,49.74 169.95,49.84 170.47,49.84 170.56,49.94 170.56,50.23 170.47,50.33 170.29,50.33 170.19,50.42 170.19,50.62 170.29,50.72 170.47,50.72 170.56,50.82 170.56,51.02 170.47,51.12 170.29,51.12 170.19,51.22 170.19,51.42 170.29,51.51 170.47,51.51 170.56,51.61 170.56,53.96 170.44,54.09 170.16,54.09 170.06,54.19 170.06,54.44 170.16,54.54 170.47,54.54 170.56,54.64 170.56,54.9 170.47,55 170.09,55 170,55.09 170,55.36 170.09,55.45 170.97,55.45 171.21,55.69 171.21,60.12 170.7,60.63 170.7,69.88 170.55,70.03 170.55,89.36 170.05,89.86 170.05,90.3 165.22,95.14 165.22,97.79 164.75,98.26 164.75,99.9 v2(164.38,100.27)
  BOTTOM w0.076: v2(164.38,100.27) UC1.P8
  BOTTOM w0.114: JDIMM2.229 170.69,46.97 v2(170.8,46.87)
DDR_B_D56: length 70.8
  IN1 w0.081: v2(167.09,102.22) 167.56,101.75 167.56,101.43 167.69,101.3 167.69,100.54 168.47,99.76 168.47,99.5 169.41,98.56 169.41,97.14 169.97,96.58 169.97,95.9 169.74,95.67 169.74,94.85 170.56,94.03 172.41,94.03 174.61,91.84 174.61,88.6 175.93,87.27 175.93,71.98 176.35,71.56 176.35,66.09 177.9,64.54 177.9,61.8 177.48,61.38 177.48,61.01 177.56,60.93 177.79,60.93 177.87,60.85 177.87,60.69 177.79,60.61 177.56,60.61 177.48,60.52 177.48,60.36 177.56,60.28 177.79,60.28 177.87,60.2 177.87,60.04 177.79,59.96 177.56,59.96 177.48,59.87 177.48,59.71 177.56,59.63 177.79,59.63 177.87,59.55 177.87,59.39 177.79,59.31 177.56,59.31 177.48,59.22 177.48,59.06 177.56,58.98 177.79,58.98 177.87,58.9 177.87,58.74 177.79,58.66 177.56,58.66 177.48,58.57 177.48,58.41 177.56,58.33 177.79,58.33 177.87,58.25 177.87,58.09 177.79,58.01 177.56,58.01 177.48,57.92 177.48,55.13 177.55,55.06 177.55,55.04 177.66,54.94 177.66,46.42 v2(176.83,45.6)
  BOTTOM w0.076: v2(167.09,102.22) UC1.L11
  BOTTOM w0.114: JDIMM2.245 174.69,47.74 v2(176.83,45.6)
DDR_B_D57: length 71.3
  IN1 w0.081: v2(173.15,43.06) 172.67,43.54 172.67,45.39 172.4,45.66 172.4,48.25 172.16,48.49 172.16,54.72 172.75,55.31 172.75,56.16 172.67,56.24 172.43,56.24 172.35,56.32 172.35,56.49 172.43,56.57 172.67,56.57 172.75,56.65 172.75,56.81 172.67,56.89 172.43,56.89 172.35,56.97 172.35,57.14 172.43,57.22 172.67,57.22 172.75,57.3 172.75,57.46 172.67,57.54 172.43,57.54 172.35,57.62 172.35,57.79 172.43,57.87 172.67,57.87 172.75,57.95 172.75,58.11 172.67,58.19 172.43,58.19 172.35,58.27 172.35,58.44 172.43,58.52 172.67,58.52 172.75,58.6 172.75,58.76 172.67,58.84 172.43,58.84 172.35,58.92 172.35,59.09 172.43,59.17 172.67,59.17 172.75,59.25 172.75,59.41 172.67,59.49 172.43,59.49 172.35,59.57 172.35,59.74 172.43,59.82 172.67,59.82 172.75,59.9 172.75,60.4 172.75,60.4 172.75,61.42 172.85,61.52 173.11,61.52 173.21,61.61 173.21,61.81 173.11,61.9 172.85,61.9 172.75,62 172.75,62.19 172.85,62.29 173.11,62.29 173.21,62.39 173.21,62.58 173.11,62.68 172.85,62.68 172.59,62.93 172.59,85.94 171.61,86.92 171.61,89.81 169.6,91.81 169.44,91.81 166.01,95.25 166.01,97.85 165.55,98.31 165.55,100.59 165.66,100.7 165.66,101.67 v2(166.21,102.22)
  BOTTOM w0.076: v2(166.21,102.22) UC1.M11
  BOTTOM w0.114: JDIMM2.236 172.44,42.35 v2(173.15,43.06)
DDR_B_D58: length 67.1
  IN1 w0.081: v2(176.83,43.06) 175.97,43.92 175.97,51.3 175.87,51.4 175.49,51.4 175.4,51.5 175.4,51.7 175.49,51.8 175.87,51.8 175.96,51.9 175.96,52.61 175.87,52.71 175.55,52.71 175.45,52.81 175.45,53.01 175.55,53.11 175.87,53.11 175.96,53.2 175.96,53.4 175.97,53.41 175.97,61.52 176.49,62.04 176.49,64.75 175.49,65.75 175.49,71.22 175.08,71.63 175.08,86.92 173.76,88.24 173.76,91.37 171.63,93.5 170.33,93.5 168.16,95.67 168.16,98.38 167.08,99.47 v2(167.08,99.71)
  BOTTOM w0.076: UC1.L7 166.59,99.35 v2(167.08,99.71)
  BOTTOM w0.114: JDIMM2.250 175.95,40.8 175.95,42.49 176.51,43.06 v2(176.83,43.06)
DDR_B_D59: length 67.6
  IN1 w0.081: v2(166.14,99.59) 166.14,99.47 166.93,98.67 167.11,98.67 167.55,98.23 167.55,95.53 170.38,92.7 170.81,92.7 172.55,90.96 172.55,87.22 173.95,85.83 173.95,65.67 174.7,64.91 174.7,63.23 174.6,63.14 174.4,63.14 174.3,63.04 174.3,62.85 174.4,62.75 174.6,62.75 174.7,62.65 174.7,62.43 174.6,62.33 174.4,62.33 174.3,62.24 174.3,62.05 174.4,61.95 174.6,61.95 174.7,61.85 174.7,61.66 174.6,61.56 174.4,61.56 174.3,61.47 174.3,61.27 174.4,61.18 174.6,61.18 174.7,61.08 174.7,60.89 174.6,60.79 174.4,60.79 174.3,60.69 174.3,60.5 174.4,60.4 174.6,60.4 174.7,60.31 174.7,60.11 174.6,60.02 174.4,60.02 174.3,59.92 174.3,59.73 174.4,59.63 174.6,59.63 174.7,59.54 174.7,59.34 174.6,59.25 174.4,59.25 174.32,59.17 174.32,54.85 173.87,54.41 173.87,46.23 173.56,45.92 173.56,44.73 v2(173.15,44.33)
  BOTTOM w0.076: UC1.M8 165.75,99.98 v2(166.14,99.59)
  BOTTOM w0.114: v2(173.15,44.33) 171.44,42.62 JDIMM2.232
DDR_B_D60: length 69.6
  IN1 w0.081: v2(167.09,101.57) 167.45,101.22 167.45,100.53 168.29,99.69 168.29,99.43 169.23,98.49 169.23,97.07 169.79,96.51 169.79,95.98 169.56,95.75 169.56,94.78 170.48,93.86 172.16,93.86 174.32,91.69 174.32,88.48 175.65,87.16 175.65,71.86 176.07,71.44 176.07,65.97 177.6,64.44 177.6,61.93 177.19,61.52 177.19,54.98 177.36,54.81 177.36,53.8 177.26,53.7 176.67,53.7 176.57,53.6 176.57,53.4 176.67,53.3 177.26,53.3 177.36,53.2 177.36,53.01 177.26,52.91 176.67,52.91 176.57,52.81 176.57,51.81 176.67,51.71 177.2,51.71 177.3,51.61 177.3,51.41 177.2,51.32 176.67,51.32 176.57,51.22 176.57,51.02 176.67,50.92 177.14,50.92 177.24,50.82 177.24,49.85 177.16,49.77 176.94,49.77 176.86,49.68 176.86,49.52 176.94,49.44 177.16,49.44 177.24,49.36 177.24,49.2 177.16,49.12 176.94,49.12 176.86,49.03 176.86,48.87 176.94,48.79 177.16,48.79 177.24,48.71 177.24,48.55 177.16,48.47 176.94,48.47 176.86,48.38 176.86,48.22 176.94,48.14 177.16,48.14 177.24,48.06 177.24,47.27 v2(176.83,46.87)
  BOTTOM w0.076: v2(167.09,101.57) UC1.L10
  BOTTOM w0.114: v2(176.83,46.87) 176.32,46.87 175.69,47.49 JDIMM2.249
DDR_B_D61: length 69.2
  IN1 w0.081: v2(166.21,101.57) 165.83,101.2 165.83,100.62 165.75,100.54 165.75,98.47 166.24,97.98 166.24,95.26 168.19,93.31 168.25,93.31 168.73,92.83 168.99,92.83 171.89,89.92 171.89,87.06 172.89,86.06 172.89,66.65 172.99,66.56 173.2,66.56 173.3,66.46 173.3,66.27 173.2,66.17 172.99,66.17 172.89,66.07 172.89,65.88 172.99,65.78 173.2,65.78 173.3,65.69 173.3,65.49 173.2,65.4 172.99,65.4 172.89,65.3 172.89,65.08 172.99,64.98 173.52,64.98 173.62,64.89 173.62,64.69 173.52,64.6 172.99,64.6 172.89,64.5 172.89,64.01 173.01,63.89 173.53,63.89 173.7,63.73 173.7,61.17 173.62,61.09 173.13,61.09 173.05,61 173.05,60.84 173.13,60.76 173.62,60.76 173.7,60.68 173.7,55.38 172.49,54.17 172.49,48.59 172.7,48.38 172.7,45.76 172.86,45.6 v2(173.15,45.6)
  BOTTOM w0.076: v2(166.21,101.57) UC1.M10
  BOTTOM w0.114: v2(173.15,45.6) 171.46,47.29 171.46,47.85 171.69,48.09 JDIMM2.233
DDR_B_D62: length 65.9
  IN1 w0.081: v2(166.15,98.95) 166.15,98.33 166.51,97.96 166.51,96.85 166.6,96.76 167.12,96.76 167.37,96.51 167.37,95.46 170.25,92.58 170.25,91.96 172.17,90.04 172.17,87.18 173.65,85.71 173.65,73.79 173.55,73.69 173.29,73.69 173.19,73.59 173.19,73.39 173.29,73.29 173.55,73.29 173.65,73.19 173.65,73 173.55,72.9 173.29,72.9 173.19,72.8 173.19,72.6 173.29,72.5 173.55,72.5 173.65,72.4 173.65,72.2 173.55,72.1 173.29,72.1 173.19,72 173.19,71.81 173.29,71.71 173.55,71.71 173.65,71.61 173.65,71.41 173.55,71.31 173.29,71.31 173.19,71.21 173.19,71.01 173.29,70.92 173.55,70.92 173.65,70.82 173.65,70.62 173.55,70.52 173.29,70.52 173.19,70.42 173.19,70.22 173.29,70.12 173.55,70.12 173.65,70.02 173.65,69.83 173.55,69.73 173.29,69.73 173.19,69.63 173.19,69.43 173.29,69.33 173.55,69.33 173.65,69.23 173.65,69.03 173.55,68.93 173.29,68.93 173.19,68.83 173.19,68.64 173.29,68.54 173.55,68.54 173.65,68.44 173.65,68.24 173.55,68.14 173.29,68.14 173.19,68.04 173.19,67.84 173.29,67.75 173.55,67.75 173.65,67.65 173.65,65.54 174,65.19 174,55.17 172.86,54.03 172.86,53.8 172.95,53.7 173.27,53.7 173.36,53.61 173.36,53.41 173.27,53.32 172.95,53.32 172.86,53.22 172.86,49.2 173.05,49.01 173.05,48.1 173.51,47.64 173.51,47.23 v2(173.15,46.87)
  BOTTOM w0.076: UC1.M7 165.79,99.3 v2(166.15,98.95)
  BOTTOM w0.114: JDIMM2.237 172.69,47.88 172.54,47.72 172.54,47.15 172.82,46.87 v2(173.15,46.87)
DDR_B_D63: length 67.6
  IN1 w0.081: v2(167.09,100.27) 167.44,99.93 167.44,99.36 168.07,98.73 168.74,98.73 169.02,98.44 169.02,95.06 170.41,93.68 171.43,93.68 171.44,93.67 171.56,93.67 171.56,93.67 171.86,93.67 174.04,91.49 174.04,88.36 175.36,87.04 175.36,71.75 175.77,71.34 175.77,65.87 176.79,64.85 176.79,61.71 176.27,61.19 176.27,50.67 176.37,50.57 176.84,50.57 176.94,50.47 176.94,50.28 176.84,50.18 176.37,50.18 176.27,50.09 176.27,49.09 176.43,48.93 176.43,44.73 v2(176.83,44.33)
  BOTTOM w0.076: v2(167.09,100.27) UC1.L8
  BOTTOM w0.114: JDIMM2.246 174.95,40.8 174.95,41.96 176.18,43.2 176.18,43.68 v2(176.83,44.33)
DDR_B_DQS0: length 73.4
  IN1 w0.081: v2(114.01,45.22) 113.49,45.22 113.32,45.39 113.32,48.21 113.58,48.47 114.14,48.47 114.25,48.58 114.25,49 114.08,49.17 113.76,49.17 113.56,49.36 113.56,49.66 114.2,50.29 114.2,51.28 113.96,51.52 113.96,52.66 114.58,53.28 114.58,64.82 119.93,70.18 119.93,83.13 128.61,91.8 128.61,97.66 129.36,98.4 129.36,99.18 129.43,99.25 129.43,99.27 129.61,99.45 129.61,99.58 130.71,100.68 130.73,100.68 130.73,101.02 130.72,101.03 130.72,101.17 131.06,101.51 132.36,101.51 132.87,101 133.36,101 133.49,101.13 133.49,101.35 v2(133.38,101.46)
  BOTTOM w0.089: v2(133.38,101.46) 133.66,101.18 UC1.BP9
  BOTTOM w0.114: JDIMM2.13 114.69,47.92 114.75,47.87 114.75,45.59 114.49,45.33 114.12,45.33 v2(114.01,45.22)
DDR_B_DQS1: length 71.4
  IN1 w0.081: v2(136.1,100.92) 135.99,100.92 135.86,100.79 135.86,98.97 134.71,97.82 134.71,96.8 135.75,95.77 135.75,94.27 133.04,91.56 133.04,89.91 125.43,82.3 125.43,81.64 124.77,80.98 124.77,69.02 120.72,64.96 120.72,60.43 120.07,59.78 120.07,55.63 120.28,55.42 120.28,48.66 119.31,47.69 119.31,46.23 118.4,45.33 118.4,44.36 118.48,44.28 118.74,44.28 v2(119.04,44.59)
  BOTTOM w0.076: UC1.BJ9 136.34,100.45 136.09,100.45 135.91,100.63 135.91,100.73 v2(136.1,100.92)
  BOTTOM w0.107: JDIMM2.34 119.94,41.83
  BOTTOM w0.114: 119.94,41.83 119.83,41.94 119.83,43.08 119.95,43.2 119.95,44.06 119.67,44.34 119.28,44.34 v2(119.04,44.59)
DDR_B_DQS2: length 68.6
  IN1 w0.081: v2(139.67,100.92) 139.64,100.92 139.31,100.59 139.31,98.48 139.94,97.84 139.94,93.33 138.85,92.24 138.85,90.1 134.89,86.14 134.89,85.34 129.34,79.8 129.34,68.27 125.91,64.83 125.91,47.45 125.4,46.95 125.4,46.55 125.91,46.04 125.91,45.57 125.58,45.24 125.02,45.24 124.92,45.34 124.75,45.34 v2(124.63,45.22)
  BOTTOM w0.076: v2(139.67,100.92) UC1.BF9
  BOTTOM w0.114: v2(124.63,45.22) 124.74,45.33 124.78,45.37 125.05,45.37 125.48,45.8 125.48,46.94 125.05,47.37 125.05,47.88 125.19,48.02 JDIMM2.55
DDR_B_DQS3: length 68.2
  IN1 w0.081: v2(142.43,100.92) 142.07,100.56 142.07,99.47 142.9,98.64 142.9,92.84 142.5,92.44 142.5,91.98 142.33,91.81 142.33,91.67 142.03,91.37 142.03,89.3 138.77,86.04 138.77,85.65 138.76,85.64 138.76,83.95 133.15,78.35 133.15,65.98 132.18,65.01 132.18,60.28 131.71,59.82 131.71,47.15 131.5,46.94 131.22,46.94 131.1,46.82 131.1,46.45 131.25,46.31 131.55,46.31 131.73,46.12 131.73,44.52 131.46,44.25 131.02,44.25 130.8,44.02 v2(130.8,43.95)
  BOTTOM w0.076: v2(142.43,100.92) UC1.BB9
  BOTTOM w0.114: JDIMM2.76 130.45,41.7 130.24,41.91 130.24,44.01 130.43,44.19 130.55,44.19 v2(130.8,43.95)
DDR_B_DQS4: length 66
  IN1 w0.081: v2(157.84,45.9) 157.58,45.65 157.35,45.65 157.2,45.8 157.2,46.55 157.77,47.13 157.77,48.48 157.6,48.66 157.32,48.66 157.2,48.78 157.2,49.05 157.32,49.17 157.51,49.17 157.72,49.38 157.72,50.48 158.09,50.84 158.09,51.52 158.69,52.12 158.69,59.99 158.35,60.33 158.35,69.96 161.96,73.58 161.96,89.72 158.79,92.9 158.79,99.13 158.53,99.39 158.53,100.49 158.44,100.58 158.44,101.08 158.56,101.2 158.77,101.2 158.89,101.08 v2(158.89,100.92)
  BOTTOM w0.076: v2(158.89,100.92) UC1.AA9
  BOTTOM w0.114: v2(157.84,45.9) 157.65,45.71 157.49,45.71 157.23,45.96 157.23,46.59 158.06,47.41 158.06,47.87 158.2,48 JDIMM2.179
DDR_B_DQS5: length 66.4
  IN1 w0.081: v2(163.51,44.07) 163.51,44.15 163.18,44.47 162.95,44.47 162.78,44.65 162.78,46.69 163.37,47.27 163.37,53.42 163.56,53.61 163.73,53.61 163.88,53.76 163.88,54.07 163.76,54.2 163.62,54.2 163.41,54.4 163.41,54.88 163.94,55.41 163.94,61.22 163.43,61.73 163.43,69.26 165.69,71.52 165.69,89.48 161.22,93.96 161.22,99.16 161.12,99.26 161.12,100.27 161,100.38 160.8,100.38 v2(160.71,100.29)
  BOTTOM w0.076: v2(160.71,100.29) 160.76,100.24 161.16,100.24 161.23,100.31 161.23,100.55 UC1.V9
  BOTTOM w0.107: 163.35,41.9 163.44,41.8 JDIMM2.200
  BOTTOM w0.114: 163.35,41.9 163.32,41.92 163.32,42.48 162.89,42.92 162.89,44.1 163.04,44.26 163.32,44.26 v2(163.51,44.07)
DDR_B_DQS6: length 66
  IN1 w0.081: v2(169.02,45.98) 168.79,45.74 168.56,45.74 168.44,45.86 168.44,46.89 168.63,47.08 169.24,47.08 169.53,47.37 169.53,47.79 169.35,47.98 169.13,47.98 168.94,48.17 168.94,52.57 169.03,52.65 169.41,52.65 169.61,52.84 169.61,53.31 169.42,53.5 169.26,53.5 169.08,53.69 169.08,56.12 169.85,56.9 169.85,61.83 169.41,62.27 169.41,68.51 169.73,68.83 169.73,89.22 164.01,94.94 164.01,100.49 163.93,100.57 163.93,101.08 164.03,101.18 164.22,101.18 164.38,101.01 v2(164.38,100.92)
  BOTTOM w0.076: v2(164.38,100.92) UC1.P9
  BOTTOM w0.114: v2(169.02,45.98) 168.81,45.76 168.72,45.76 168.71,45.76 168.55,45.92 168.55,47.94 168.69,48.09 JDIMM2.221
DDR_B_DQS7: length 68
  IN1 w0.081: v2(166.16,100.21) 166.45,100.21 166.54,100.13 166.54,99.41 167.09,98.86 167.19,98.86 167.8,98.25 167.8,95.54 170.38,92.97 171.25,92.97 173.11,91.1 173.11,87.49 174.43,86.17 174.43,65.87 175.22,65.08 175.22,54.65 174.41,53.84 174.41,46.93 174.6,46.74 175.06,46.74 175.22,46.58 175.22,46.29 174.81,45.88 174.35,45.88 174.15,45.68 174.15,44.55 174.28,44.41 174.41,44.41 174.74,44.08 v2(174.74,44.01)
  BOTTOM w0.076: v2(166.16,100.21) 166.16,100.36 166.4,100.6 UC1.L9
  BOTTOM w0.114: JDIMM2.242 173.94,41.64 173.69,41.89 173.69,42.41 174.12,42.83 174.12,44.28 174.23,44.4 174.35,44.4 v2(174.74,44.01)
DDR_B_DQS#0: length 73.3
  IN1 w0.081: v2(133.98,101.44) 133.87,101.44 133.74,101.32 133.74,101.31 133.66,101.22 133.66,101.06 133.43,100.83 132.8,100.83 132.29,101.34 131.13,101.34 130.89,101.1 130.9,101.09 130.9,100.61 130.8,100.51 130.78,100.51 129.78,99.51 129.78,99.38 129.52,99.11 129.52,98.33 128.77,97.59 128.77,91.74 120.09,83.06 120.09,70.11 114.74,64.76 114.74,53.21 114.12,52.6 114.12,51.58 114.35,51.35 114.35,50.23 113.72,49.59 113.72,49.45 113.84,49.33 114.14,49.33 114.4,49.07 114.4,48.51 114.21,48.31 113.64,48.31 113.48,48.15 113.48,45.46 113.56,45.38 113.61,45.38 113.66,45.43 113.85,45.62 113.9,45.62 114.01,45.73 v2(114.01,45.86)
  BOTTOM w0.089: UC1.BN9 134.31,101.12 v2(133.98,101.44)
  BOTTOM w0.107: 114.14,45.73 v2(114.01,45.86) ; JDIMM2.11 114.19,48.08
  BOTTOM w0.114: 114.19,48.08 114.5,47.77 114.5,45.69 114.39,45.58 114.3,45.58 114.14,45.73 114.14,45.73
DDR_B_DQS#1: length 71.4
  IN1 w0.081: v2(119.04,43.95) 118.87,44.12 118.42,44.12 118.25,44.3 118.25,45.39 119.15,46.3 119.15,47.76 120.12,48.73 120.12,55.36 119.91,55.57 119.91,59.84 120.56,60.49 120.56,65.02 124.62,69.08 124.62,81.04 125.28,81.7 125.28,82.36 132.88,89.97 132.88,91.63 135.59,94.34 135.59,95.7 134.56,96.74 134.56,97.88 135.71,99.03 135.71,101.04 136.06,101.39 v2(136.06,101.57)
  BOTTOM w0.076: v2(136.06,101.57) UC1.BL9
  BOTTOM w0.107: JDIMM2.32 119.45,41.83
  BOTTOM w0.114: v2(119.04,43.95) 119.19,44.1 119.56,44.1 119.71,43.95 119.71,43.3 119.59,43.18 119.59,41.97 119.45,41.83
DDR_B_DQS#2: length 68.5
  IN1 w0.081: v2(138.78,100.92) 138.93,101.07 139.08,101.07 139.2,100.96 139.2,100.71 139.15,100.66 139.15,98.41 139.78,97.77 139.78,93.4 138.69,92.31 138.69,90.16 134.73,86.2 134.73,85.41 129.19,79.86 129.19,68.33 125.75,64.9 125.75,47.52 125.24,47.02 125.24,46.49 125.76,45.97 125.76,45.64 125.51,45.4 125.09,45.4 v2(124.63,45.86)
  BOTTOM w0.076: v2(138.78,100.92) UC1.BG9
  BOTTOM w0.114: v2(124.63,45.86) 124.86,45.62 124.95,45.62 125.23,45.9 125.23,46.84 124.8,47.27 124.8,47.92 124.69,48.02 JDIMM2.53
DDR_B_DQS#3: length 68.1
  IN1 w0.081: v2(141.52,100.92) 141.9,100.54 141.9,99.4 142.73,98.57 142.73,92.91 142.33,92.51 142.33,92.05 142.15,91.88 142.15,91.74 141.86,91.45 141.86,89.37 138.6,86.11 138.6,84.02 132.99,78.41 132.99,66.04 132.02,65.07 132.02,60.35 131.83,60.16 131.55,59.88 131.55,47.21 131.44,47.09 131.15,47.09 130.95,46.89 130.95,46.36 131.16,46.15 131.48,46.15 131.57,46.06 131.57,44.59 131.39,44.41 130.97,44.41 v2(130.8,44.59)
  BOTTOM w0.076: v2(141.52,100.92) UC1.BC9
  BOTTOM w0.114: JDIMM2.74 129.94,41.81 129.99,41.86 129.99,44.11 130.32,44.44 130.65,44.44 v2(130.8,44.59)
DDR_B_DQS#4: length 66.1
  IN1 w0.081: v2(157.98,100.92) 158.16,100.92 158.28,100.8 158.28,100.51 158.37,100.42 158.37,99.32 158.63,99.07 158.63,92.84 161.81,89.66 161.81,73.64 158.19,70.03 158.19,60.27 158.53,59.93 158.53,52.18 157.93,51.59 157.93,50.91 157.57,50.54 157.57,49.45 157.45,49.33 157.25,49.33 157.04,49.12 157.04,48.72 157.25,48.5 157.53,48.5 157.62,48.42 157.62,47.19 157.04,46.62 157.04,45.73 157.28,45.49 157.61,45.49 v2(157.84,45.26)
  BOTTOM w0.076: v2(157.98,100.92) UC1.AC9
  BOTTOM w0.107: JDIMM2.177 157.69,48
  BOTTOM w0.114: 157.69,48 157.81,47.88 157.81,47.52 156.99,46.69 156.99,45.86 157.39,45.47 157.63,45.47 v2(157.84,45.26)
DDR_B_DQS#5: length 66.5
  IN1 w0.081: v2(163.51,44.71) 163.43,44.63 163.02,44.63 162.94,44.71 162.94,46.62 163.52,47.21 163.52,53.35 163.62,53.45 163.79,53.45 164.03,53.69 164.03,54.14 163.82,54.35 163.69,54.35 163.57,54.47 163.57,54.82 164.1,55.34 164.1,61.29 163.58,61.8 163.58,69.19 165.85,71.45 165.85,89.55 161.37,94.02 161.37,99.23 161.27,99.33 161.27,100.33 160.71,100.9 v2(160.71,100.93)
  BOTTOM w0.076: UC1.W9 160.38,100.6 v2(160.71,100.93)
  BOTTOM w0.107: JDIMM2.198 162.94,41.76
  BOTTOM w0.114: v2(163.51,44.71) 163.3,44.5 162.94,44.5 162.64,44.2 162.64,42.81 163.08,42.38 163.08,41.9 162.94,41.76
DDR_B_DQS#6: length 66
  IN1 w0.081: v2(163.47,100.92) 163.78,100.61 163.78,100.5 163.85,100.43 163.85,94.87 169.58,89.15 169.58,68.89 169.26,68.57 169.26,62.2 169.7,61.76 169.7,56.97 168.92,56.19 168.92,53.62 169.2,53.34 169.35,53.34 169.45,53.25 169.45,52.91 169.35,52.8 168.96,52.8 168.79,52.63 168.79,48.1 169.07,47.82 169.28,47.82 169.38,47.73 169.38,47.44 169.17,47.23 168.56,47.23 168.28,46.96 168.28,45.8 168.5,45.58 168.94,45.58 169.02,45.5 v2(169.02,45.34)
  BOTTOM w0.076: v2(163.47,100.92) UC1.R9
  BOTTOM w0.107: 168.85,45.52 v2(169.02,45.34)
  BOTTOM w0.114: 168.85,45.52 168.72,45.52 168.71,45.52 168.61,45.52 168.3,45.82 168.3,47.92 168.19,48.02 JDIMM2.219
DDR_B_DQS#7: length 68.1
  IN1 w0.081: v2(174.74,44.64) 174.66,44.57 174.38,44.57 174.3,44.65 174.3,45.61 174.41,45.72 174.88,45.72 175.38,46.23 175.38,46.65 175.13,46.9 174.66,46.9 174.57,46.99 174.57,53.78 175.38,54.58 175.38,65.15 174.59,65.93 174.59,86.24 173.27,87.56 173.27,91.17 171.31,93.12 170.44,93.12 167.96,95.61 167.96,98.31 167.26,99.02 167.16,99.02 166.7,99.48 166.7,100.19 166.46,100.43 166.46,100.46 166.2,100.72 v2(166.2,100.89)
  BOTTOM w0.076: UC1.M9 165.91,100.6 v2(166.2,100.89)
  BOTTOM w0.114: v2(174.74,44.64) 174.13,44.64 173.87,44.39 173.87,42.94 173.44,42.51 JDIMM2.240
DDR_B_MA0: length 66.5
  IN1 w0.089: v2(152.49,100.92) 152.02,100.45 152.02,99.31 152.95,98.38 152.95,95.62 153.2,95.37 153.2,85.65
  IN1 w0.13: v2(148.47,44.45) 147.44,45.48 147.44,45.89 147.19,46.14 147.19,47.87 146.75,48.31 146.75,51.79 147.06,52.1 147.06,53.34 147.79,54.06 147.79,60.05 147.59,60.25 147.59,73.27 149.06,74.74 151,74.74 151.27,75 151.27,77.17 153.2,79.11 153.2,85.65
  BOTTOM w0.076: v2(152.49,100.92) 152.17,100.6 UC1.AJ9
  BOTTOM w0.185: v2(148.47,44.45) 147.44,43.42 JDIMM2.144
DDR_B_MA1: length 66.3
  IN1 w0.089: v2(151.03,98.33) 151.03,97.54 150.34,96.85 150.34,87.28 150.35,87.27 150.35,85.65
  IN1 w0.13: 150.35,85.65 150.35,84.81 150.01,84.47 150.01,84.16 150.17,84 150.38,84 150.53,83.85 150.53,83.54 150.38,83.38 149.56,83.38 149.4,83.23 149.4,82.92 149.56,82.76 150.38,82.76 150.53,82.61 150.53,82.29 150.34,82.1 150,82.1 149.81,81.91 149.81,79.71 149.59,79.49 148.98,79.49 148.5,79.02 148.5,78.8 148.85,78.45 148.85,78.23 148.64,78.02 148.42,78.02 148.07,78.37 147.86,78.37 147.67,78.18 147.67,77.96 148.02,77.61 148.02,77.4 147.82,77.2 147.6,77.2 147.32,77.49 147.1,77.49 146.92,77.3 146.92,77.02 147.17,76.77 147.17,76.55 145.13,74.51 145.13,66.55 144.97,66.39 144.65,66.39 144.5,66.24 144.5,65.93 144.65,65.77 145.02,65.77 145.17,65.62 145.17,65.31 145.02,65.15 144.65,65.15 144.5,65 144.5,64.69 144.65,64.53 144.95,64.53 145.11,64.38 145.11,63.22 144.85,62.96 144.85,62.65 145.13,62.37 145.13,62.03 144.97,61.88 144.65,61.88 144.5,61.72 144.5,61.41 144.65,61.26 144.97,61.26 145.13,61.1 145.13,60.82 144.94,60.63 144.85,60.63 144.48,60.26 144.48,54.61 144,54.12 144,46.88 v2(143.98,46.87)
  BOTTOM w0.076: v2(151.03,98.33) 151.09,98.27 151.31,98.27 151.45,98.27 151.55,98.37 151.55,98.56 UC1.AK6
  BOTTOM w0.185: JDIMM2.133 144.69,47.8 143.98,47.08 v2(143.98,46.87)
DDR_B_MA2: length 67.9
  IN1 w0.089: 150.99,85.65 150.99,87.43 150.68,87.74 150.68,96.53 v2(151.8,97.65)
  IN1 w0.13: 150.99,85.65 150.99,82.01 150.26,81.28 150.26,79 145.63,74.36 145.63,60.54 145.19,60.1 145.19,54.55 144.45,53.82 144.45,45.54 144.64,45.35 145.01,45.35 145.17,45.2 145.17,44.89 145.01,44.73 144.63,44.73 144.41,44.51 144.41,42.38 144.48,42.31 144.48,42.01 144.56,41.93 144.89,41.93 145.04,42.09 145.04,44.05 145.32,44.33 v2(145.62,44.33)
  BOTTOM w0.076: UC1.AK5 151.75,97.65 v2(151.8,97.65)
  BOTTOM w0.185: JDIMM2.132 144.44,41.75 144.63,41.93 144.63,43.35 145.61,44.33 v2(145.62,44.33)
DDR_B_MA3: length 66.5
  IN1 w0.089: 149.89,85.65 149.89,87.96 150.16,88.23 150.16,97.58 v2(150.24,97.66)
  IN1 w0.13: v2(143.98,45.6) 143.54,46.04 143.54,59.89 144.04,60.39 144.04,66.7 144.19,66.85 144.51,66.85 144.67,67.01 144.67,67.32 144.51,67.47 144.19,67.47 144.04,67.63 144.04,67.94 144.19,68.09 144.51,68.09 144.67,68.25 144.67,68.56 144.51,68.71 144.19,68.71 144.04,68.87 144.04,69.18 144.19,69.33 144.51,69.33 144.67,69.49 144.67,69.8 144.51,69.95 144.19,69.95 144.04,70.11 144.04,70.42 144.19,70.57 144.51,70.57 144.67,70.73 144.67,71.04 144.51,71.19 144.19,71.19 144.04,71.35 144.04,71.74 144.19,71.9 144.51,71.9 144.67,72.05 144.67,72.36 144.51,72.52 144.19,72.52 144.04,72.67 144.04,72.98 144.19,73.14 144.46,73.14 144.61,73.29 144.61,75.57 144.76,75.72 144.95,75.72 145.2,75.46 145.43,75.46 145.69,75.71 145.69,75.93 145.34,76.28 145.34,76.49 145.54,76.7 145.75,76.7 146.09,76.36 146.33,76.36 146.53,76.56 146.53,76.78 146.18,77.13 146.18,77.34 148.94,80.1 148.94,83.42 149.55,84.03 149.55,84.66 149.89,85 149.89,85.65
  BOTTOM w0.076: v2(150.24,97.66) 150.57,97.99 UC1.AL5
  BOTTOM w0.185: JDIMM2.131 144.19,48.02 143.45,47.28 143.45,46.13 v2(143.98,45.6)
DDR_B_MA4: length 67
  IN1 w0.089: v2(150.24,98.31) 149.88,98.67 149.25,98.67 148.99,98.41 148.99,86.81 148.63,86.45 148.63,85.65
  IN1 w0.13: 148.63,85.65 148.63,84.41 148.02,83.8 148.02,81.24 143.12,76.34 143.12,60.77 142.62,60.28 142.62,44.78 142.49,44.65 142.19,44.65 142.06,44.52 142.06,44.26 142.19,44.13 142.49,44.13 142.62,44 142.62,43.24 142.82,43.04 142.82,41.91 142.98,41.75 143.36,41.75 143.52,41.91 143.52,42.98 143.65,43.11 v2(143.98,43.11)
  BOTTOM w0.076: UC1.AL6 150.57,98.64 v2(150.24,98.31)
  BOTTOM w0.185: JDIMM2.128 143.44,42.28 143.98,42.82 v2(143.98,43.11)
DDR_B_MA5: length 66.1
  IN1 w0.089: 149.43,85.65 149.43,96.2 149.77,96.53 149.77,97.95 v2(149.4,98.31)
  IN1 w0.13: v2(143.98,44.33) 143.74,44.08 143.37,44.08 143.08,44.37 143.08,60.08 143.58,60.58 143.58,73.44 143.73,73.6 144,73.6 144.15,73.75 144.15,74.06 144,74.22 143.73,74.22 143.58,74.37 143.58,74.74 143.73,74.89 144,74.89 144.15,75.05 144.15,75.35 144,75.5 143.73,75.5 143.58,75.66 143.58,76.15 146.8,79.37 146.98,79.37 147.16,79.19 147.35,79.19 147.53,79.38 147.53,79.56 147.35,79.74 147.35,79.92 147.53,80.1 147.72,80.1 147.9,79.93 148.08,79.93 148.26,80.11 148.26,80.29 148.08,80.47 148.08,80.65 148.48,81.05 148.48,83.61 149.09,84.22 149.09,84.85 149.43,85.19 149.43,85.65
  BOTTOM w0.076: UC1.AM6 149.8,98.39 149.72,98.31 v2(149.4,98.31)
  BOTTOM w0.185: JDIMM2.126 142.94,43.99 143.28,44.33 v2(143.98,44.33)
