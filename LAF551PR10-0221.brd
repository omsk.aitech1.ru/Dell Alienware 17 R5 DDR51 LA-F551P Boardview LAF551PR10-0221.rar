# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_FLASH: length 58.6
  TOP w0.381: v2(193.68,166.58) 193.68,167.21 195.13,168.66 196.24,168.66 196.33,168.75 197.09,168.75 RT124.1 ; RT67.1 RT66.1 198.89,161.67 197.97,160.75 197.39,160.75 196.88,161.26 196.88,162.06
  TOP w0.508: v2(188.06,156.96) 189.3,156.96 192.41,160.07 192.87,160.07 194.44,161.65 195.08,161.65
  IN1 w0.381: v2(193.68,166.58) 193.68,166.36 v2(195.27,164.77)
  IN2 w0.508: v2(207.87,164.3) 208.24,163.94 208.24,161.75 206.88,160.39 205.3,160.39 205.05,160.14 202.08,160.14 200.88,161.33 198.64,161.33 197.9,162.08 v2(197.61,162.08)
  BOTTOM w0.203: CT103.1 196.6,165 196.68,164.93 197.64,164.93 197.7,164.87 UT4.G1
  BOTTOM w0.254: UT4.B1 197.89,162.37 v2(197.61,162.08)
  BOTTOM w0.381: RT74.1 207.92,164.4 207.87,164.35 v2(207.87,164.3)
  BOTTOM w0.508: UT2.8 190.18,152.25 190.28,152.15 190.28,152.14 190.64,151.78 190.65,151.78 190.81,151.62 RT51.1 ; UT2.8 190.05,154.18 189.54,154.18 189.26,153.9 CT45.1 ; UT2.8 190.18,155.98 189.62,156.54 RT50.1 188.48,156.54 v2(188.06,156.96) 187.97,157.05 187.97,157.84 188.54,158.41 188.54,159.49 187.51,160.52 RT49.1 187.51,161.6 187.59,161.67 187.59,162.84 188.15,163.4 189.14,163.4 RT48.1 ; v2(195.27,164.77) 195.5,165 CT103.1
  vias: v3(195.17,163.85)
+3.3V_LC: length 24.9
  TOP w0.127: v3(171.82,156.83) v2(171.82,157.47)
  TOP w0.203: UT1.R6 v2(178.71,164.95)
  IN3 w0.508: v2(171.82,157.47) 172.15,157.8 172.15,159.88 173.3,161.03 173.3,163.76 173.74,164.2 173.74,164.94 174.04,165.23 175.13,165.23 v2(175.37,164.99) 175.56,164.99 176.44,164.11 176.44,162.44 176.98,161.89 178.45,161.89 179.31,162.74 179.31,163.72 178.71,164.31 v2(178.71,164.95)
  BOTTOM w0.381: CT46.1 178.75,164.91 v2(178.71,164.95) ; RT8.1 RT7.1 175.65,164.71 v2(175.37,164.99) ; v2(171.82,157.47) 171.84,157.47 172.25,157.06 RT9.1 172.56,157.06 172.93,157.43 RT6.1
+3.3V_TBT_SX: length 52.3
  TOP w0.254: v2(178.71,169.49) 178.72,169.49 179.02,169.18 UT1.F8 ; v2(170.51,168.46) 170.58,168.46 171.15,169.03 RT30.1 ; RT31.1 171.78,164.45 v2(172.83,164.45) 172.87,164.49 173.51,164.49 RT26.1 RT27.1 ; v2(173.98,163.25) 173.94,163.3 RT29.1 RT28.1 ; RT33.1 171.15,167.43 RT36.1 170.81,166.84 170.62,166.65 v2(170.49,166.65) 170.02,166.65 RT32.1
  TOP w0.381: v2(196.75,171.33) 196.75,169.99 RT61.2
  IN3 w0.508: v2(178.71,169.49) 178.71,170.38 179.6,171.27 186.01,171.27 186.71,171.96 187.66,171.96 188.27,171.35 188.28,171.35 188.37,171.27 190.92,171.27 191.3,170.88 193.01,170.88 193.48,171.35 196.72,171.35 v2(196.75,171.33)
  IN4 w0.508: v2(179.89,176.14) 179.65,176.14 179.08,176.71 175.75,176.71 175.27,176.23 172.25,176.23 171.18,175.16 171.18,169.13 v2(170.51,168.46)
  IN6 w0.508: 171.2,168.9 171.11,168.81 171.14,168.77
  BOTTOM w0.254: v2(170.49,166.65) 170.16,166.65 169.91,166.4 v1(169.91,166.07) RT94.1
  BOTTOM w0.381: RT86.1 177.89,170.65 178.11,170.42 CT47.1 178.7,169.48 v2(178.71,169.49) ; RT70.1 197.39,170.68 v2(196.75,171.33)
  BOTTOM w0.508: v2(179.89,176.14) 179.76,176.27 RT97.2
+3.3V_TBT_SX_R: length 8.7
  TOP w0.381: v2(194.71,169.17) 195.77,169.17 195.92,169.32 CT102.1 RT61.1
  IN1 w0.508: v2(194.71,169.17) 194.98,169.17 195.48,168.66 195.48,167.19 195.84,166.83 196.35,166.83 v2(196.38,166.86)
  BOTTOM w0.076: UT4.H2 198.41,165.62 198.05,165.62 198.05,165.62 197.96,165.62
  BOTTOM w0.152: 197.96,165.62 197.89,165.62 197.69,165.83 197.29,165.83 196.38,166.74 v2(196.38,166.86)
+3V3_SYS: length 320.6
  TOP w0.254: v2(240.34,40.25) PR821.2 240.34,41.32 240.86,41.84 244.31,41.84 v3(245.79,43.32) 247.42,44.95 v2(247.42,48.62) ; PR6436.2 308.55,58.4 v2(308.84,58.11) ; v2(298.2,55.55) PR6408.2
  TOP w0.508: RG514.1 195,107.76 198.03,107.76 v2(198.21,107.94)
  IN1 w0.254: v2(308.84,58.11) 305.61,58.11 304.67,57.17 299.83,57.17 v2(298.2,55.55)
  IN2 w0.508: v2(191.99,121.82) 192.53,121.29 194.84,121.29 195.28,120.84 195.28,120.15 v2(196.76,118.67) ; v2(198.21,107.94) 198.73,107.42 201.14,107.42 201.49,107.06 201.61,107.06 201.88,106.8 206.26,106.8 207.02,106.04 212.04,106.04 212.11,105.96 217.95,105.96 v2(218.19,105.72)
  IN3 w0.254: v2(298.2,55.55) 298.2,54.2 293.37,49.36 273.97,49.36 272.31,47.7 260.9,47.7 258.5,50.1 248.61,50.1 247.42,48.92 v2(247.42,48.62) ; v2(212.02,59.49) 212.02,55.45 210.17,53.6 210.17,49.9 211.12,48.95 214.41,48.95 216.91,46.45 222.15,46.45 224.48,44.12 227.49,44.12 229.82,46.45 232.49,46.45 233.32,45.62 238.41,45.62 238.83,45.2 239.34,45.2 240.34,44.2 v2(240.34,40.25)
  IN4 w0.254: v2(218.19,105.72) 218.19,104.19 219.02,103.37 219.02,98.72 213.31,93.01 213.31,67.47 212.52,66.68 212.52,62.5 212.95,62.07 212.95,60.3 212.14,59.49 v2(212.02,59.49)
  IN4 w0.508: 199.01,118.35 199.01,115.35 197.66,114.01 197.66,113.66 196.16,112.17 196.16,110.86 195.25,109.95 195.25,108.82 196.12,107.94 v2(198.21,107.94) ; v2(225.54,166.31) 225.29,166.06 224.57,166.06 222.43,168.2 209.53,168.2 207.76,166.42 207.76,165.48 208.61,164.63 209.44,164.63 v2(209.71,164.36) 209.71,164 207.63,161.92 206.6,161.92 205.2,160.52 204.67,160.52 202.19,158.04 200.14,158.04 200.11,158.07 197.32,158.07 195.41,156.16 195.41,152.06 197.93,149.55 198.43,149.55 200.41,147.56 200.41,146.13 198.34,144.06 198.34,127.18 198.42,127.11 198.42,123.8 199.75,122.47 199.75,121.29 200,121.05 200,120.12 199.01,119.13 198.69,119.13
  BOTTOM w0.457: UG11.4 192.16,120.96 192.99,121.78 CG61.1 ; v2(209.71,164.36) 209.5,164.15 RV655.1 ; CG323.1 195.82,108.55 195.56,108.81 UG14.6
  BOTTOM w0.508: v2(225.54,166.31) 225.15,165.93 RX1.1 223.2,165.93 QX1.2 ; v2(191.99,121.82) 192.45,122.28 CG61.1 ; CG323.1 CG385.1 197.61,108.55 198.21,107.96 v2(198.21,107.94)
+3V_PCH: length 317.6
  TOP w0.381: RH95.1 209.6,28.42 v2(209.37,28.19) ; RH515.2 RH453.2 220.68,18.9 RH545.2 221.04,20.09 RH594.1 ; RH130.1 216.26,28.18 216.28,28.18 216.61,28.51 216.61,28.51 v2(216.8,28.7) ; RH21.2 RH27.2 216.61,34.22 216.99,34.6 216.99,34.98 215.4,36.57 215.4,37.19 214.41,38.18 CH182.1 214.17,38.1 213.68,38.1 v2(213.51,37.93) ; v2(209.37,30.53) 209.36,30.53 v2(209.36,31.96)
  TOP w0.457: RH453.2 221.41,18.88 v2(221.46,18.82)
  TOP w0.508: v2(204.73,8.98) 204.73,9.81 205.3,10.38 206.07,10.38 207.96,12.27 207.96,14.21 ; RH7.2 216.73,16.55 v2(216.73,17.07) 216.71,17.1 CH186.1 ; R367.2 229.66,43.63 230.39,42.9 230.39,41.43 229.14,40.19 229.14,38.8 228.46,38.12 225.24,38.12 224.57,38.79 ; RC9.1 127.47,162.14 v2(128,161.6) ; RH75.1 221.01,24.6 221.51,24.1 v2(221.51,24.07) 221.15,23.71 RH78.1
  IN1 w0.508: v2(212.16,46.41) 212.16,45.68 213.31,44.54 213.31,43.32 213.05,43.07 213.05,43.06 212.72,42.73 212.71,42.73 212.61,42.62 212.61,40.63 213.36,39.87 213.36,39.15 212.84,38.63 212.84,37.57 v2(213.19,37.22)
  IN2 w0.457: v2(206.7,15.23) 206.7,15.63 206.18,16.15 204,16.15 203.08,15.23 202.32,15.23 202,14.91 v2(201.56,14.91)
  IN4 w0.381: v2(206.19,24.6) v2(203.94,24.6)
  IN4 w0.508: v2(209.37,28.19) 208.74,28.82 208.74,30.53 ; v2(128,161.6) 128,160.34 127.64,159.98 127.64,155.93 128.33,155.24 130.93,155.24 131.98,154.19 142.23,154.19 143.16,153.27 145.01,153.27 145.65,153.91 147.82,153.91 151.83,157.92 160.46,157.92 167.18,151.19 172.33,151.19 172.97,150.55 184.77,150.55 187.41,147.91 187.41,147.55 187.41,145.37 188.08,144.7 188.08,137.6 188.45,137.23 188.54,137.14 188.54,130.56 180.87,122.89 180.87,121.92 180.87,121.92 180.87,121.39 180.87,121.39 180.87,119.62 178.9,117.66 178.9,114.42 178.26,113.77 178.26,108.38 178.91,107.73 178.91,97.06 176.04,94.19 176.04,76.05 178,74.1 180.04,74.1 180.11,74.03 180.12,74.03 180.67,73.49 180.67,71.99 179.4,70.72 179.4,59.43 180.54,58.28 180.54,57.2 180.07,56.73 180.07,55.15 179.08,54.16 179.08,53.44 179.97,52.56 179.97,51.73 181.12,50.58 182.46,50.58 183.02,50.03 183.02,47.42 183.92,46.51 183.92,45.73 183.93,45.72 183.93,45.29 187.6,41.61 187.6,41.58 188,41.18 v2(188,41.09) 188,40.82 187.49,40.3 187.49,37.68 189.43,35.74 191.13,35.74 191.59,36.2 192.91,36.2 196.29,32.82 198.57,32.82 198.83,32.57 201.7,32.57 201.98,32.84 204.81,32.84 204.96,32.69 206.65,32.69 207.21,32.14 207.21,31.87 207.75,31.33 207.93,31.33 208.74,30.53 ; 208.74,30.53 v2(209.37,30.53)
  IN6 w0.381: v2(202.36,29.79) 202.23,29.79 200.96,28.51 200.96,26.59 201.47,26.08 202.52,26.08 203.07,25.53 203.07,25.52 203.94,24.64 v2(203.94,24.6)
  BOTTOM w0.254: UH1.BB7 v2(213.51,37.93) UH1.AY8 ; UH1.AT44 210.67,20.16 v2(210.18,20.16) ; UH1.AP26 v2(210.13,28.16) ; UH1.AE35 v2(206.19,24.6) ; UH1.AN21 209.36,31.96 v2(209.36,31.96) ; UH1.AE36 v2(206.19,23.84) ; UH1.AW9 v2(213.19,37.22) ; UH1.AN26 v2(209.37,28.19) ; UH1.AC36 v2(203.94,23.84) ; UH1.AN24 v2(209.37,30.53) ; UH1.AN32 v2(209.46,25.6) ; UH1.AC35 v2(203.94,24.6) ; v2(209.43,20.69) 209.43,20.24 UH1.AN44 ; v2(213.7,34.54) 213.86,34.7 UH1.BB14 ; UH1.V23 v2(202.36,29.79)
  BOTTOM w0.381: v2(221.51,24.07) 221.1,24.49 RH524.1 ; RH524.1 RH63.1 219.58,24.82 RH558.2 ; RH524.1 220.75,24.44 RH506.2 ; RG555.1 187.68,37.07 RG556.1 187.5,37.82 187.5,39.97 188.03,40.5 188.03,41.06 v2(188,41.09) ; RH533.2 204.48,9.24 v2(204.73,8.98) ; RH460.1 RH461.1 221.13,29.44 222.04,28.53 v2(222.26,28.53) ; v2(221.45,34.52) RH25.2 RH29.2
  BOTTOM w0.457: RH99.2 200.92,13.72 RH100.1 201.1,14.46 v2(201.56,14.91)
  BOTTOM w0.508: v2(222.78,39.58) 222.67,39.69 222.67,40.79 223.15,41.28 PR817.1 ; RH493.1 224.37,22.99 224.3,23.06 v2(224.3,23.56) ; v2(212.16,46.41) 212.16,45.9 RH571.2
  vias: v2(228.72,16.94) v2(229.31,16.94) v3(212.19,25.52)
+3VALW: length 561.5
  TOP w0.203: v2(20.31,49.25) 19.97,49.6 UU2.47
  TOP w0.254: CE56.1 327.68,43.67 328.02,43.33 UE6.24 ; v2(326.59,15.42) 326.32,15.16 JIO.8
  TOP w0.381: RA13.1 20.85,27.19 20.19,27.85 v2(19.91,27.85) 19.91,29.65 20.34,30.08 RA84.2 ; RE300.2 157.64,164.4 v2(158.2,163.84) ; RU26.1 297.58,65.14 v2(297.16,65.56) ; v2(311.92,51.25) PR3.2 312.71,51.4 PR24.2 ; v2(218.73,19.62) 218.45,19.35 RH2.1 218.14,18.72 RH6.2
  TOP w0.457: v2(244.09,23.02) 244.09,23.02 244.09,23.05 244.56,23.52 PR301.1
  TOP w0.508: v2(286.84,14.15) 286.9,14.21 RE102.2 ; v2(190.81,159.72) 190.9,159.81 191,159.81 191.93,160.73 192.63,160.73 194.09,162.2 194.09,164.7 194.69,165.29 RT53.1 ; PR16.2 80.7,10.71 80.11,10.11 78.48,10.11 78.05,10.54 78.05,11.62 76.19,13.49 76.19,15.47 74.15,17.5 v3(69.4,17.5) v2(68.32,17.5) ; v2(199.72,11.36) 199.72,9.77 198.95,9.01 RT111.1 ; v2(328.03,36.27) 328.06,36.27 328.06,36.27 328.02,36.27 326.4,37.9 R325.1 ; v2(320.11,39.07) 320.53,38.65 R307.1 ; v2(298.58,29.25) 298.27,28.94 RE643.1 RE642.1 ; v2(330.91,39.54) 330.91,39.55 330.75,39.7 330.75,39.7 330.46,40 RE91.1 ; v2(54.94,18.74) 55.04,18.84 55.63,18.84 56.14,19.35 PR718.2 ; RE70.1 310.57,18.64 v2(310.65,18.72) ; v2(207.73,117.5) 207.06,116.83 204.92,116.83 203.53,118.23 199.36,118.23 198.93,117.8 196.26,117.8 194.71,119.35 193.34,119.35 192.82,119.87 189.93,119.87 188.06,118 v2(188.06,115.77) ; v2(66.75,18.18) 65.86,18.18 65.32,18.71 PR710.1 ; v2(125.22,115.92) 123.88,114.58 v2(123.39,114.58) 123.4,114.57 123.4,113.57 124.21,112.75 124.21,104.7 122.94,103.43 122.94,100.38 127.52,95.81 127.52,89.4 125.04,86.92 119.77,86.92 119.3,86.46 119.3,84.8 121.14,82.97 PR32.1 ; PR812.2 237.17,44 237.68,44.5 238.49,44.5 v2(239.06,43.93) ; RE672.2 295.09,7.14 v2(294.8,6.85) ; v2(33.18,49.34) 33.18,49.34 33.18,49.34 34.13,49.34 34.27,49.2 34.59,49.2 35.51,48.28 36.43,48.28 37.54,49.39 37.54,50.11 RU31.1 ; RE79.1 308.81,10.82 v2(308.38,10.39) ; v2(327.16,44.69) 327.68,44.17 CE56.1 ; RE652.1 144.5,166.45 v2(146.31,166.45) ; v2(317.71,55.39) 318.16,55.83 RE530.1 ; RE64.2 v2(288.06,8.58) ; v2(59.26,17.02) 59.26,19.28 59.25,19.29 PR709.2 ; v2(280.74,150.36) PR6069.1 ; v2(190.76,14.41) 190.76,14.09 189.71,13.04 189.71,11.43 189.35,11.07 188.63,11.07 187.69,10.13 RT88.1
  TOP w1.016: 52.4,10.85 52.4,11.99 50.68,13.71 50.68,21.2 48.78,23.1
  IN1 w0.508: v2(59.26,17.02) 59.26,18.32 60.78,19.84 64.09,19.84 64.3,19.64 ; v2(151.57,175.06) 152.39,175.89 159.08,175.89 v2(159.77,175.19) ; v2(311.92,51.25) 313.18,52.51 315.17,52.51 317.71,55.05 v2(317.71,55.39)
  IN2 w0.508: v2(28.71,49.97) 28.84,49.97 29.47,49.33 31.11,49.33 31.67,48.77 31.69,48.77 31.7,48.76 32.6,48.76 33.18,49.34 v2(33.18,49.34)
  IN3 w0.508: 147.02,164.3 146.45,164.87 146.45,164.97 146.31,165.1 v2(146.31,166.45) ; 147.02,164.3 148.36,165.64 148.36,166.09 149.59,167.33 149.59,168.82 149.28,169.13 149.28,171.65 149.96,172.32 149.96,173.88 151.14,175.06 v2(151.57,175.06) ; 147.02,164.3 146.72,164 146.72,162.84 149.23,160.32 149.23,156.75 146.31,153.83 142.57,153.83 140.98,155.41 140.98,157.64 140.6,158.02 139.76,158.02 138.88,157.14 138.88,156.2 137.49,154.81 127.8,154.81 125.48,152.49 125.48,151.71 124.95,151.18 124.95,149.2 123.99,148.24 118.98,148.24 116.9,146.15 115.63,146.15 114.26,144.78 114.26,136.88 118.42,132.72 118.55,132.72 122.23,129.04 122.23,125.25 124.53,122.95 124.53,120.32 123.39,119.18 123.39,117.77 122.75,117.13 122.75,115.11 123.28,114.58 v2(123.39,114.58) ; v2(59.26,17.02) 59.26,16.52 58.64,15.9 56.63,15.9 54.94,17.59 v2(54.94,18.74) ; v2(98.24,51.68) 96.72,50.16 96.72,43.97 97.41,43.28 v2(97.47,43.28) ; v2(43.96,25.43) 43.96,32.74 39.48,37.23 39.48,39.88 35.35,44.01 35.35,45.55 33.18,47.72 v2(33.18,49.34) ; v2(288.06,8.58) 288.06,10.56 287.45,11.17 287.45,13.54 v2(286.84,14.15)
  IN4 w0.508: v2(188.25,170.66) 188.25,166.32 189.94,164.63 189.94,162.68 190.81,161.8 v2(190.81,159.72) 190.81,154.56 192.2,153.18 192.2,151.08 194.63,148.65 195.68,147.59 195.68,128.8 195.06,128.17 195.06,127.38 194.45,126.77 194.45,126.17 188.85,120.57 188.85,116.56 188.46,116.17 v2(188.06,115.77) ; v2(288.06,8.58) 288.87,7.76 293.89,7.76 v2(294.8,6.85) 295.36,6.85 295.97,7.46 296.69,7.46 v2(297.31,6.83) 297.78,6.37 303.77,6.37 v2(305.99,8.59) 307.79,10.39 v2(308.38,10.39) ; v2(192.54,16.5) 192.54,16.06 192.67,15.93 192.67,14.41 191.98,13.72 191.26,13.72 191.16,13.82 191.12,13.82 190.76,14.18 v2(190.76,14.41) ; v2(98.93,26.03) 98.93,28.73 100.07,29.88 102.1,29.88 102.71,30.49 v2(102.71,30.92) 102,31.63 102,35.9 101.05,36.85 101.05,41.87 99.27,43.65 98.4,43.65 98.03,43.28 v2(97.47,43.28)
  IN6 w0.381: v2(15.22,57.69) 15.58,57.69 16.03,58.13 18.18,58.13 18.91,57.41 18.91,56.29 20.48,54.71 20.48,52.64 v2(22.02,51.11)
  IN6 w0.508: v2(28.71,49.97) 28.46,50.22 26.11,50.22 25.73,50.6 25,50.6 24.94,50.66 ; v2(158.2,163.84) 158.2,165.33 159.95,167.08 v2(159.95,167.58) ; v2(192.54,16.5) 192.54,16.06 192.67,15.93 192.67,14.67 194.79,12.55 199.36,12.55 199.72,12.19 v2(199.72,11.36) ; v2(20.31,49.25) 20.31,48.83 18.28,46.8 18.28,45.09 20.07,43.3 20.07,37.81 19.27,37.01 19.27,28.36 v2(19.91,27.85) ; v2(316.94,46.22) 317,46.16 317,44 316.18,43.17 316.18,41.53 316.77,40.94 316.94,40.94 318.8,39.07 v2(320.11,39.07)
  BOTTOM w0.254: PU509.15 123.46,117.2 124.08,116.59 124.08,116.26 124.53,115.8 PC5003.1 ; PU800.15 239.24,43.75 v2(239.06,43.93)
  BOTTOM w0.381: RM41.1 150.71,171.81 149.79,172.72 CM70.1 149.61,172.73 UM7.5 ; v2(15.22,57.69) 15.15,57.76 RU27.1
  BOTTOM w0.508: PR210.1 97.17,43.59 v2(97.47,43.28) ; v2(98.24,51.68) 98.08,51.51 PR1300.1 ; v2(238.91,35.11) 239.66,35.86 PR8220.1 ; PC817.1 239.06,46.03 v2(239.06,43.93) ; RT97.1 178.37,176.41 178.02,176.75 177,176.75 RT95.1 ; v2(151.57,175.06) 152.14,174.49 152.14,172.66 151.3,171.81 RM41.1 ; PC821.1 225.36,43.35 PR814.2 ; v2(102.71,30.92) UE9.5 103.2,32.43 103.67,31.97 CE22.1 ; v2(327.15,19.23) 326.45,19.23 325.64,18.42 325.64,16.37 v2(326.59,15.42) ; PR5033.2 125.22,116.36 125.22,115.93 v2(125.22,115.92) ; v2(123.39,114.58) 123.94,114.58 124.53,115.17 PC5003.1 ; RE644.2 v2(207.73,117.5)
  vias: v2(31.76,14.29) v2(32.39,14.29) v2(44.59,23.68) v2(44.78,24.25) v2(45.16,24.82) v2(45.22,23.68) v2(45.41,24.25) v2(45.47,25.39) v2(45.86,24.82) v2(45.86,23.68) v2(46.11,25.39) v2(46.11,24.25) v2(46.49,24.82) v2(46.49,23.68) v2(46.74,25.39) v2(46.74,24.25) v2(47.13,24.82) v2(47.13,23.68) v2(47.38,25.39) v2(47.38,24.25) v2(47.76,24.82) v2(47.82,23.68) v2(48.01,24.25) v2(48.08,25.39) v2(48.4,24.82) v2(48.71,25.39) v2(52.27,9.34) v2(52.9,9.34) v2(66.13,18.82) v2(66.18,17.57) v2(66.75,19.38) v2(66.75,18.8) v2(66.77,17.54) v2(66.77,16.96) v2(67.41,16.93) v2(68.04,16.93) v2(68.32,19.41) v2(68.32,18.77) v2(68.32,18.14) v2(174.74,175) v2(175.35,175) v2(225.65,45.65) v2(226.02,45.19) v2(226.6,45.2) v2(229.04,35.27) v2(229.05,31.87) v2(229.12,28.76) v2(229.32,25.54) v2(230.81,36.15) v2(234.95,35.23) v2(234.95,31.99) v2(234.95,28.76) v2(234.96,25.45) v2(243.43,22.3) v2(244,22.44) v2(266.85,24.11) v2(267.53,24.15) v2(267.8,25.09) v2(268.07,24.39) v2(268.27,25.58) v2(268.36,24.9) v2(268.8,25.9) v2(268.83,25.3) v2(268.96,24.69) v2(269.41,25.87) v2(270.01,25.89) v2(270.6,25.89) v2(271.03,171.96) v2(271.03,171.38) v2(280.07,169.46) v2(280.3,170.03) v2(289.25,25.7) v2(289.69,25.26) v2(290.2,24.76) v2(297.04,26.98) v2(302.51,26.87) v2(310.9,25.77) v2(311.54,25.77) v2(313.7,56.76) v2(313.7,56.18) v3(43.15,25.7) v3(223.03,47.18)
+3VALW_PD: length 3.5
  TOP w0.203: CT88.1 195.6,167.2 v3(195.17,167.63)
  BOTTOM w0.152: v2(196.29,165.85) 196.82,165.85 197.1,165.57 197.59,165.57 197.75,165.41 197.76,165.41 197.8,165.37 198.15,165.37 UT4.H1
+3VALWP: length 55.7
  IN1 w0.508: v2(42.35,27.04) 41.55,27.85 41.55,35.57 39.66,37.46 39.66,37.49 39.49,37.66 39.49,38.55 38.97,39.07 38.97,42.48 39.56,43.07 39.56,46.8 40.88,48.12 47,48.12 48.45,49.57 58.66,49.57 60.24,47.99 v2(60.24,46.17)
  BOTTOM w0.254: v2(42.35,27.04) 41.86,26.55 PC117.1
  BOTTOM w0.508: PR101.1 57.14,51.3 59.38,51.3 60.24,50.43 v2(60.24,46.17)
  vias: v1(42.67,19.83) v2(43.95,21.52) v2(44.14,20.95) v2(44.52,20.44) v2(44.59,21.52) v2(44.84,20.98) v2(44.78,19.87) v2(45.16,20.44) v2(45.22,21.52) v2(45.22,19.29) v2(45.41,19.87) v2(45.54,21.01) v2(45.86,21.52) v2(45.86,20.44) v2(45.86,19.29) v2(46.11,19.87) v2(46.17,21.01) v2(46.49,21.52) v2(46.49,20.44) v2(46.49,19.29) v2(46.74,19.87) v2(46.87,21.01) v2(47.13,20.44) v2(47.13,19.29) v2(47.19,21.52)
+3VLP: length 400.1
  TOP w0.508: RU4.1 29.33,45.37 28.83,44.86 28.83,44.43 v2(28.14,43.74) 27.28,43.74 26.83,43.3 26.83,43.26 26.81,43.23 RU1.1 26.5,43.42 RU7.1 ; v2(34.75,47.17) 34.68,47.17 34.68,47.58 34.17,48.09 DU8.1 ; UU5.5 18.46,35.57 CU26.1 v2(18.3,34.66) ; RA85.2 20.6,28.26 v2(20.82,28.03) ; RU5.1 v2(33.93,43.63) ; v2(295.92,42.59) 296.44,42.59 296.95,43.09 PR11.2 297.24,43.3 297.75,42.79 v3(297.75,42.03) 297.75,40.01 296.52,38.78 v2(296.52,38.22) ; PR25.2 v2(313.64,51.68)
  IN1 w0.508: 22.21,32.92 22.21,32.44 20.82,31.05 v2(20.82,28.03) ; 22.21,32.92 25.64,36.35 27.14,36.35 28.56,37.77 32.43,37.77 33.32,38.66 33.32,43.02 v2(33.93,43.63) 33.98,43.68 33.98,46.35 34.68,47.04 34.68,47.17 ; 22.21,32.92 20.47,34.66 v2(18.3,34.66) ; 34.68,47.17 v2(34.75,47.17) ; 34.68,47.17 34.68,47.82 33.88,48.62 33.88,48.77 33.86,48.79 33.86,50.2 33.88,50.22 33.88,50.37 34.3,50.79 38.25,50.79 39.96,49.08 46.3,49.08 48.27,51.04 51.85,51.04 v2(52.69,51.89) 53.14,51.89 53.81,51.22 66.7,51.22 66.93,50.99 84.71,50.99 v2(85.42,50.28) ; v2(295.92,42.59) 297.99,42.59 298.62,43.21 301.8,43.21 303.73,45.14 308.44,45.14 308.94,45.64 310.69,45.64 312.56,47.51 312.56,50.47 313.64,51.55 v2(313.64,51.68)
  IN2 w0.508: v2(271.51,42.09) 271.32,41.9 270.33,41.9 266.78,45.45 245.4,45.45 243.15,47.7 225.31,47.7 224.88,48.14 216.45,48.14 215.06,49.53 210.98,49.53 210.84,49.67 210.83,49.67 210.47,50.03 210.47,51.25 207.05,54.67 202.76,54.67 199.5,51.41 192.87,51.41 190.84,49.39 185.48,49.39 182.82,46.72 180.42,46.72 180.24,46.54 178.63,46.54 176.6,48.57 174.67,48.57 174.2,49.03 172.77,49.03 172.67,49.14 154.99,49.14 154.39,49.74 144.81,49.74 144.21,49.14 125.74,49.14 125.24,49.64 106.24,49.64 105.99,49.89 97.04,49.89 96.93,49.78 95.71,49.78 95.09,50.4 92.06,50.4 91.25,49.58 86.12,49.58 v2(85.42,50.28) ; v2(28.14,43.74) 28.45,43.74 29.59,44.89 32.67,44.89 v2(33.93,43.63)
  IN3 w0.508: v2(308.41,17.15) 307.92,17.15 306.54,18.53 306.54,22.1 304.72,23.92 304.72,25.15 303.55,26.32 303.55,27.3 302.63,28.21 301.66,28.21 300.95,28.92 299.94,28.92 299,29.86 296.85,29.86 296.41,30.3 296.41,30.79 295.54,31.66 295.5,31.66 294.84,32.31 294.84,34.22 296.52,35.89 v2(296.52,38.22)
  IN6 w0.508: v2(271.51,42.09) 273.3,42.09 274.32,41.07 277.15,41.07 278.74,39.49 280.11,39.49 282.01,41.39 290.01,41.39 291.21,42.59 v2(295.92,42.59)
  BOTTOM w0.203: PU100.3 53.86,49.77 53.95,49.86 PC101.1
  BOTTOM w0.508: PC101.1 53.55,50.36 52.69,51.22 v2(52.69,51.89)
+3VS: length 730.3
  TOP w0.203: v2(18.79,24.68) 18.97,24.5 UA3.B2
  TOP w0.254: JEDP.24 v2(163.12,182.97) ; CG474.1 197.72,113.08 UG16.12 ; v2(324.37,14.85) 325.06,14.16 JIO.6 ; v2(166.89,182.96) 167.12,182.72 JEDP.32 ; UG16.9 197.32,111.58 v2(197.39,111.51)
  TOP w0.305: CS2.1 184.45,64.25 184.74,64.55 184.74,65.05 184.24,65.56 US1.1 ; US1.14 182.66,67.93 CS7.1
  TOP w0.356: v2(312.3,56.25) 312.38,56.18 RG561.1 ; RG567.1 v2(214.37,111.05)
  TOP w0.381: RG534.1 309.15,59.55 309.72,58.98 v2(309.72,58.65) ; v2(188.3,103.27) 188.48,103.09 RG536.1 ; RH607.1 RH606.1 217.85,38.18 218.25,38.57 219.18,38.57 ; v2(210.28,30.61) 210.28,30.6 210.29,30.6 210.87,31.18 RH537.2 ; RH602.1 209.76,24.44 209.09,24.44 208.8,24.15 v2(208.68,24.15) ; v2(221.65,38.87) 221.67,38.84 221.67,36.74 220.94,36.01 RH516.1 ; RG506.1 214.17,159.21 213.52,159.21 v2(213.31,158.99) ; RG566.1 v2(216.59,114.48) ; v2(187.46,99.28) 187.94,99.28 188.18,99.04 RG535.1 188.32,97.88 188.71,97.5 ; 216.24,27.32 216.26,27.3 216.42,27.3 216.64,27.08 217.39,27.08 217.61,26.86 v2(217.69,26.86) ; v2(156.98,39.55) 156.98,40.18 RD6.1
  TOP w0.457: QS3.2 189.19,69.29 v2(189.28,69.2)
  TOP w0.508: RD1.1 178.25,54.46 RD2.1 178.82,55.03 179,55.03 v2(179.46,55.49) ; RE84.1 310.3,13.81 v2(310.84,14.35) ; v2(125.13,135.56) 125.13,136.25 PR516.1 ; v2(202.26,11.23) 202.26,10.04 202.87,9.43 RC62.2 RC63.2 ; RA11.2 v2(40.79,29.33) ; RH525.1 124.12,77.56 123.1,78.58 123.1,82.45 120.21,85.33 120.21,85.99 v2(120.19,85.99) ; v2(199.14,120.45) 199.14,122.31 203.13,126.29 204.04,126.29 204.84,127.09 204.84,127.67 205.49,128.32 v2(205.75,128.32) ; 182.13,66.35 182.63,66.35 183.14,65.84 183.14,65.08 183.97,64.25 CS2.1 ; 182.13,66.35 182.13,67.36 182.58,67.82 CS7.1 182.58,68.56 v2(182.71,68.68) ; 182.13,66.35 v1(178.89,66.35) 177.48,66.35 CD17.1 ; CG474.1 197.89,113.43 198.4,113.94 v2(198.5,113.94) ; RH600.2 RH111.2 RH85.2 ; CD35.1 178.26,47.77 v2(178.34,47.7) 178.19,47.55 CD34.1 177.57,41.42 RD5.1 RD4.1 ; RT110.1 198.81,11.28 v2(198.95,11.42) ; v2(195.91,106.48) 196.11,106.28 CG475.1 196.78,106.28 197.29,105.77 197.29,104.93 196.9,104.54 191.73,104.54 190.13,102.94 190.13,98.21 189.42,97.5 188.71,97.5 ; v2(221.65,38.87) 221.36,38.57 CH201.1 219.18,38.57 ; RH521.1 RH588.1 RH517.1 RH520.1 216.55,31.68 v2(216.86,31.99) ; RF1.2 v2(105.11,60.37) ; RD3.1 156.55,50.29 157.43,51.17 v2(157.49,51.17) ; PR8219.1 244.04,30.01 243.66,29.63 243.66,28.31 243.98,27.99 244.82,27.99 v2(245.07,28.24) ; v2(287.41,77.52) 286.77,76.89 RF5.2 RF4.2 ; RE656.1 141.87,6.47 v2(143.01,5.32) ; CM21.1 165.72,162.82 v2(165.74,162.79) ; v2(127.38,151.74) 126.7,151.74 125.98,152.47 CM29.1 125.93,153.24 v2(125.93,154.04) 125.98,154.09 CM31.1 ; RN16.1 317.59,41.02 ; RH462.1 221.21,30.68 221.18,30.71 221.18,31.55 221.69,32.06 221.75,32.06 221.85,32.15 v2(221.88,32.15) 221.94,32.22 221.94,32.25 222.19,32.5 222.19,34.64 221.6,35.23 RH516.1 ; RF2.2 v2(105.09,62.15) ; v2(123.4,121.97) 122.42,121.97 121.52,122.86 121.52,123.6 120.65,124.47 120.65,125.98 120.02,126.61 v2(118.56,126.61)
  IN1 w0.457: v2(123.71,159.09) 123.84,159.09 124.24,158.69
  IN1 w0.508: 124.24,158.69 v2(125.93,157) ; v2(143.01,5.32) 142.57,5.32 141.11,3.86 136.98,3.86 135.9,4.94 135.9,9.02 134.91,10 134.77,10 129.82,14.96 v2(125.41,14.96)
  IN2 w0.508: v2(324.37,14.85) 323.6,15.62 322.38,15.62 321.47,16.53 321.47,17.04 319.9,18.61 317.13,18.61 312.87,14.35 v2(310.84,14.35) ; v2(70.67,18.8) 70.67,17.99 68.83,16.15 66.65,16.15 65.93,16.87 64.39,16.87 63.61,17.64 63.61,18.8 62.07,20.34 54.75,20.34 54.41,19.99 53.29,19.99 52.78,19.49 52.78,18.48 52.35,18.05 52.32,18.05 52.31,18.04 46.74,18.04 46.09,18.69 44.94,18.69 43.35,20.27 37.38,20.27 36.01,21.64 36.01,22.88 v2(34.5,24.4) 34.69,24.4 35.19,24.89 35.19,25.31 37.52,27.64 39.1,27.64 v2(40.79,29.33) ; v2(98.69,31.04) 98.69,26.65 97.81,25.77 97.81,22.1 v2(96.24,20.53) ; v2(241.5,156.65) 242.48,157.62 263.84,157.62 264.35,158.13 264.35,160.51 265.91,162.07 265.91,169.31 v2(266.2,169.6)
  IN3 w0.508: v2(277.07,146.68) 277.07,148.13 275.1,150.1 v2(275.05,150.1) 273.6,151.55 273.6,154.97 274.87,156.24 275.66,156.24 276.17,156.75 276.17,158.74 276.95,159.52 276.95,166.88 272.91,170.92 272.91,171.31 271,173.22 268.11,173.22 267,172.11 267,170.4 v2(266.2,169.6) ; v2(178.34,47.7) 178.34,49.86 179.59,51.11 179.59,55.36 v2(179.46,55.49) ; v2(127.38,151.74) 129.72,154.08 137.35,154.08 138.9,152.53 v2(138.9,151.6) ; v2(18.79,24.68) 18.22,24.68 18.04,24.86 18.04,25.9 18.79,26.65 20.1,26.65 20.68,26.06 30.94,26.06 32.61,24.4 v2(34.5,24.4) ; v2(309.72,58.65) 309.9,58.65 v2(312.3,56.25) ; v2(192.26,17.77) 192.26,17.74 193.49,16.5 193.49,15.68 193.94,15.23 201.01,15.23 201.31,15.52 201.81,15.52 202.1,15.23 203.15,15.23 203.65,14.72 203.65,14.28 v2(204.17,13.76)
  IN3 w1.016: 164.66,182.05 164.66,179.82 166.32,178.17 166.32,175.76 ; 165.87,168.01 164.98,168.9 164.98,171.12 165.24,171.38
  IN4 w0.381: v2(212.8,28.06) 212.8,28.5 212.41,28.89 211.85,28.89 210.28,30.47 v2(210.28,30.61) ; v2(217.69,26.86) 216.85,26.86 216.29,27.43 216.29,31.11 216.86,31.68 v2(216.86,31.99)
  IN4 w0.508: v2(157.49,51.17) 157.49,49.2 158.57,48.12 158.57,42.03 156.98,40.44 v2(156.98,39.55) v2(156.98,36) ; v2(198.5,113.94) 198.5,113.6 197.39,112.5 v2(197.39,111.51) 197.39,110.72 197.04,110.37 197.04,108.92 197.38,108.58 198.52,108.58 198.88,108.22 198.88,107.5 197.63,106.25 196.13,106.25 v2(195.91,106.48) ; v2(299.79,7.42) 299.79,8.07 300.3,8.58 301.18,8.58 302.11,9.5 305.34,9.5 307.07,11.23 308.81,11.23 310.84,13.26 v2(310.84,14.35) ; v2(107.01,27.55) 107.01,30 103.92,33.09 103.92,47.77 107.73,51.58 107.73,57.22 105.11,59.83 v2(105.11,60.37) 105.09,60.39 v2(105.09,62.15) ; v2(301.7,50.85) 301.43,51.12 301.43,52.67 302.78,54.02 309.79,54.02 310.49,54.71 310.49,57.89 v2(309.72,58.65)
  IN6 w0.381: 215.02,111.05 215.07,111.05 216.4,112.38 216.4,114.28 v2(216.59,114.48)
  IN6 w0.508: v2(120.19,85.99) 120.21,85.99 120.21,85.97 119.58,85.97 v2(118.37,87.18) ; 215.02,111.05 v2(214.37,111.05) 204.92,111.05 202.92,109.05 202.92,107.15 200.63,104.87 197.46,104.87 195.91,106.42 v2(195.91,106.48) ; v2(192.26,17.77) 192.26,20.03 192.61,20.38 192.61,23.03 v2(192.1,23.55)
  BOTTOM w0.254: CM33.1 125.86,157.89 126.45,158.48 UM8.24 ; RH601.1 214.63,48.04 217.32,48.04 217.71,47.65 RH604.1 RH605.1 ; U2407.1 185.89,48.42 185.7,48.62 C2498.1
  BOTTOM w0.305: JDIMM2.255 177.19,48.1 177.6,47.7 v2(178.34,47.7) ; v2(236.53,164.3) 236.57,164.27 RV672.2 ; v2(177.19,63.19) JDIMM1.255
  BOTTOM w0.356: RV16.1 236.99,167.12 236.99,166.77 236.33,166.11 v2(236.22,166.11) ; v2(203.14,157.1) 203.77,156.47 RT58.1 ; RM86.1 138.5,152 v2(138.9,151.6) ; v2(237.44,166.17) 237.35,166.08 RV671.2 ; RS2.2 97.48,17.5 96.24,18.74 v2(96.24,20.53) ; RM85.1 138.92,160.06 RM66.2 ; v2(203.59,157.47) 203.78,157.28 RT107.1
  BOTTOM w0.381: QH5.2 189.35,32.31 189.67,31.99 189.67,31.45 189.29,31.07 188.09,31.07 187.7,31.45 187.7,31.88 187.28,32.31 QH5.5 185.87,32.31 185.3,31.74 v2(185.3,31.55) ; 140.42,161.95 140.42,160.31 140.16,160.05 RM66.2 ; 140.42,161.95 141.44,161.95 142.3,162.82 146.26,162.82 148.9,160.18 v2(150.05,160.18) ; 140.42,161.95 140.42,162.66 140.15,162.93 139.2,162.93 138.92,162.65 RM26.1 ; RG517.1 206.13,127.94 v2(205.75,128.32) ; UM4.5 168.59,154.41 CM20.1 ; RT130.2 171.12,168.71 170.81,169.01 169.96,169.01 169.19,168.24 168.36,168.24 ; v2(123.71,159.09) 123.71,159.11 124.05,159.11 RM14.1 ; UM4.9 165.99,154.21 CM19.1 ; RT58.1 204.72,156.58 205.7,156.58 RT57.1 ; UM4.16 168.59,162.31 168.41,162.49 CM18.1 ; UM4.12 165.99,162.27 165.74,162.51 v2(165.74,162.79) ; RM79.1 139.4,152.78 138.87,152.25 RM86.1
  BOTTOM w0.457: v2(212.33,163.62) 212.33,162.93 QX3.1
  BOTTOM w0.508: RG200.1 190.04,59.9 188.94,61 v2(188.6,61) ; v2(184.48,32.88) 184.48,39.56 R181.1 ; v2(125.93,154.04) 125.12,154.85 125.12,155.67 125.23,155.78 CM30.1 ; CM30.1 CM33.1 ; CM30.1 v2(125.93,157) ; RH502.1 RH501.1 221.72,32.31 v2(221.88,32.15) ; v2(277.07,146.68) 277.31,146.43 PR6042.1 ; RA5.2 34.84,24.4 v2(34.5,24.4) ; RM81.1 RM76.1 v2(127.38,151.74) ; v2(172.76,159.62) 172.8,159.66 172.81,159.66 173.31,160.17 RM18.1 ; C2498.1 184.73,42.92 182.32,40.5 v2(182.32,35.04) ; RL5.2 266.59,169.21 v2(266.2,169.6) ; v2(301.7,50.85) 299.94,52.61 299.94,58.91 300.52,59.48 300.52,62.96 299.19,64.29 299.19,68.73 293.13,74.79 292.71,74.79 289.98,77.52 v2(287.41,77.52) ; RH601.1 213.56,46.97 v2(213.56,46.47) 213.56,46.32 213.8,46.08 RH5.1 ; CM18.1 168.46,163.17 168.74,163.45 169,163.45 v2(169.05,163.5) ; v2(221.43,22.89) 221.14,22.6 RH518.2 ; v2(304.19,22.03) 304.2,22.03 304.2,21.77 303.88,21.45 303.88,13.1 300.67,9.88 300.67,8.06 300.02,7.42 v2(299.79,7.42) ; v2(165.22,154.16) 165.24,154.13 CM19.1 167.12,154.13 v2(167.14,154.16) CM20.1 ; v2(170.3,152.63) RM96.1 RM20.1 ; PR820.2 228.15,38.14 227.88,37.87 227.88,36.26 225.97,34.34 225.97,33.56 226.15,33.38 226.15,32.49 225.58,31.93 224.86,31.93 224.56,31.63 224.56,30.12 224.5,30.06 224.5,28.32 222.79,26.61 222.78,26.61 ; PR5016.1 v2(123.4,121.97) ; v2(198.95,11.42) 198.95,11.6 199.46,12.11 RH584.2 202.19,12.11 ; UH3.5 v2(221.65,38.87) ; RE20.2 98.83,31.18 v2(98.69,31.04) ; v2(225.57,166.94) 226.21,167.58 226.21,167.84 227.27,168.9 QX2.1
  BOTTOM w1.016: 168.06,170.45 168.06,168.8
  vias: v2(70.67,20.07) v2(70.67,19.43) v2(71.37,20.07) v2(71.37,19.43) v2(71.37,18.8) v2(72,20.07) v2(72,19.43) v2(72,18.8) v2(72.7,20.07) v2(72.7,19.43) v2(72.7,18.8) v2(120.11,24.88) v2(120.11,24.3) v2(120.7,24.88) v2(120.7,24.3) v2(121.28,24.88) v2(121.28,24.3) v2(121.87,24.88) v2(121.87,24.3) v2(161.69,165.73) v2(161.71,165.14) v2(166.12,165.8) v2(166.59,167.4) v2(176.41,36.69) v2(176.41,36.06) v2(177.19,63.82) v2(177.49,36.57) v2(177.49,35.87) v2(178.19,36.57) v2(186.83,68.44) v2(186.89,69.08) v2(221.37,26.53) v2(221.94,26.09) v2(239.89,163.23) v2(240.29,162.74) v2(300.78,41.15) v2(301.45,41.14) v2(302.08,41.14) v2(302.72,41.14) v2(316.87,41.71) v2(317.55,41.72) v2(318.18,41.72)
+3VS_DP: length 0.4
  TOP w0.203: 239.67,165.56 v3(239.25,165.56)
  vias: v2(240.1,165.92) v2(240.1,165.28) v2(240.74,165.92) v2(240.74,165.28)
+3VS_SSD: length 135.2
  TOP w0.356: R365.2 276.04,9.07 276.81,8.31 v2(280.81,8.31) ; C623.1 331.55,33.42 331.2,33.77 330.27,33.77 329.56,33.06 R363.2
  TOP w0.508: v2(334.56,47.17) 333.78,47.96 C618.1 C617.1 333.78,49.19 333.38,49.58 C622.1 ; v2(321.61,27.68) 321.61,26.88 C624.1
  IN2 w0.508: v2(277.03,23.17) 277.03,24.1 275.35,25.78 274.43,25.78 272.07,28.15 264.18,28.15 264.18,28.15 263.69,28.64 263.69,28.64 263.33,29 257.19,29 256.79,29.4 248.69,29.4 248.64,29.45 248.6,29.45 247.99,30.06 242.53,30.06 240.71,31.88 240.71,34.5 239.49,35.72 238.48,35.72 238.45,35.69 236.91,35.69 235.69,36.9 230.64,36.9 229.83,36.1 228.63,36.1 228.13,35.59 228.13,25.73 229.99,23.86 232.44,23.86 233.33,22.96 233.68,22.96 234.6,22.04 v2(234.6,21.92)
  IN2 w2.032: 325,7.1 330.35,7.1 333.38,10.14 333.38,28.9
  BOTTOM w0.356: R364.2 236.22,19.98 234.6,21.59 v2(234.6,21.92)
  BOTTOM w0.508: v2(321.61,27.68) 321.61,28.87 322.45,29.71 324.16,29.71 324.54,29.33 331.96,29.33 v2(333.07,30.43)
  vias: v2(236.19,8.33) v2(236.77,8.33) v2(252.55,8.44) v2(253.13,8.44) v2(254.58,7.67) v2(255.16,7.67) v2(255.75,7.67) v2(255.79,10.4) v2(256.33,7.67) v2(256.37,10.4) v2(256.96,10.4) v2(260.96,16.2) v2(261.54,16.21) v2(262.12,16.23) v2(262.72,16.25) v2(277.03,22.34) v2(277.62,22.34) v2(278.14,23.17) v2(278.22,22.34) v2(280.81,8.89) v2(281.43,8.6) v2(281.43,7.99) v2(333.07,31.04) v2(333.68,31.04) v2(333.68,30.43) v2(334.6,46.53) v2(334.9,46.03) v2(335.23,47.17) v2(335.24,46.55) v3(247.15,8.18)
+3VS_TBT: length 28.4
  TOP w0.178: UT1.H9 179.68,168.53 v2(180.01,168.87)
  TOP w0.254: v3(179.85,176.89) 179.61,177.13 178.32,177.13 177.73,176.55 CT53.1
  IN2 w0.508: v2(184.35,157.6) 184.35,156.89 183.63,156.16 178.95,156.16 178.68,156.43 178.65,156.43 178.57,156.51 178.24,156.51 177.66,155.92 v2(177.66,155.86) 177.6,155.86 177.12,155.38 177.11,155.38 177.09,155.35 174.3,155.35 173.96,155.69 173.96,155.7 173.68,155.98 173.68,156.84 174.57,157.72
  IN6 w0.508: v2(178.19,153.15) 178.19,153.98 177.33,154.84 177.33,155.53 v2(177.66,155.86)
  BOTTOM w0.381: RT77.2 183.89,154.47 184.1,154.68 184.1,157.34 v2(184.35,157.6) ; v2(179.71,174.43) 179.71,174.2 179.55,174.03 RT21.1 ; v2(178.19,153.15) RT76.2 178.18,154.49 RT20.1
  vias: v2(177.55,175.76) v2(177.55,175.12)
+3VS_TOUCH: length 184
  TOP w0.381: RE661.1 195.39,15.34 195.13,15.09 194.32,15.09 193.94,14.71 v3(193.94,13.8) 193.94,13.25 C2.1
  TOP w0.508: 189.54,9.73 189.58,9.73 190.53,8.78 193.02,8.78 ; 189.54,9.73 v2(188.81,9.73) ; 189.54,9.73 189.75,9.93 189.75,10.26 190.84,11.36 193.24,11.36 193.47,11.13 194.32,11.13 194.83,11.64 v2(194.83,11.67) 194.81,11.69 C2.1 ; 193.68,6.72 193.68,5.16 v2(193.61,5.08) ; v2(301.09,7.41) 301.09,7.07 301.6,6.56 RE100.1 RE101.1
  IN1 w0.508: v2(283.66,14.04) 283.66,12.97 286.74,9.9 291.21,9.9 293.63,7.47 298.54,7.47 299.12,8.06 300.44,8.06 v2(301.09,7.41)
  IN2 w0.508: v2(283.66,14.04) 283.09,14.61 277.33,14.61 276.59,15.34 265.3,15.34 264.24,14.28 253.19,14.28 252.1,13.19 252.1,12.55 251.54,11.99 249.88,11.99 249.35,11.46 233.8,11.46 233.21,10.88 228.76,10.88 228.25,11.39 v2(228.25,11.46) ; v2(194.83,11.67) 194.83,12.31 193.24,13.9 193.24,14.56 190.86,16.93 188.27,16.93 187.52,17.68 v2(187.52,18.35)
  IN4 w0.508: v2(194.83,11.67) 195.95,10.55 202.44,10.55 202.87,10.98 202.87,11.59 203.26,11.98 206.46,11.98 209.11,9.33 215.72,9.33 216.83,10.43 227.76,10.43 228.25,10.93 v2(228.25,11.46)
  BOTTOM w0.305: JTP.11 191.82,12.27 192.12,11.97 193.11,11.97 193.89,11.19 194.52,11.19 194.83,11.5 v2(194.83,11.67)
  BOTTOM w0.381: v2(187.52,18.35) 186.83,19.05 RE663.1 ; RE33.1 185.51,16.89 184.35,15.74 183.03,15.74 181.95,14.66 RT89.1 181.95,13.03 182.65,12.34 182.65,12.01 183.29,11.37 184.45,10.21 184.45,7.96 184.46,7.95 184.46,4.96 185.15,4.27 192.79,4.27 v2(193.61,5.08)
  BOTTOM w0.508: CT116.1 188.16,12.36 188.4,12.12 188.4,11.2 188.81,10.8 v2(188.81,9.73)
+5V_HDD: length 0.8
  TOP w0.203: v3(127.43,14.15) 127.52,14.06 v2(127.52,13.34)
  vias: v2(126.88,13.34) v2(126.88,12.75) v2(127.52,12.75) v2(128.15,13.34) v2(128.15,12.75)
+5V_PVDD:
  vias: v2(28.9,42.22) v2(29.54,42.22) v3(32.46,42.64)
+5V_TOBII:
  vias: v3(153.79,163.63)
+5V_USB_PWR1: length 2
  TOP w0.127: v3(17.69,44.68) 16.55,43.54 JUSB1.1
  vias: v2(20.68,47.49) v2(20.84,46.85) v2(21.32,47.49) v2(21.9,47.49)
+5V_USB_PWR2: length 2
  TOP w0.127: v3(323.52,23.32) 322.59,22.39 CU10.1
  vias: v2(320.66,22.49) v2(320.66,21.9) v2(320.71,23.65) v2(320.72,23.07) v2(326.46,13.33) v2(326.46,12.63) v2(327.08,13.33) v2(327.1,12.63)
+5V_USBC_VBUS: length 343.4
  TOP w0.127: v2(11.63,56.79) v3(12.53,56.79)
  TOP w0.254: v2(8.39,63.37) 8.34,63.37 8.2,63.22 JUSBC2.A4 7.18,63.22 6.78,63.62 v2(6.68,63.62) 6.54,63.48 JUSBC2.B9 ; JUSBC2.B4 6.28,60.97 6.3,60.96 6.33,60.96 6.62,60.66 v2(6.72,60.66) 6.78,60.73 JUSBC2.A9 8.29,60.73 v2(8.35,60.67)
  TOP w0.279: v2(8.39,63.37) 9.15,63.37 v2(9.15,63.36)
  TOP w0.381: RU24.1 v2(295.27,66.06)
  IN2 w0.381: v2(295.27,66.06) 295.83,65.5 295.83,61.22 298.78,58.28 298.78,41.38 296.83,39.44 292.21,39.44 290.46,37.68 284.02,37.68 279.54,42.16 279.54,46.59 277.31,48.82 273.19,48.82 271.99,47.62 256.17,47.62 252.94,50.85 227.46,50.85 226.54,51.77 213.03,51.77 210.19,54.6 210.19,55.74 208.42,57.52 204.8,57.52 204.54,57.78 204.54,58.08 204.27,58.35 202.4,58.35 202.07,58.01 202.07,57.41 198.99,54.33 196.18,54.33 195.22,55.29 188.04,55.29 187.72,54.97 186.26,54.97 182.51,58.73 182.51,60.11 177.36,65.26 111.2,65.26 107.25,69.21 104.36,69.21 102.7,67.54 102.7,64.28 94.06,55.64 91.4,55.64 90.83,55.07 90.83,53.22 89.79,52.18 83.48,52.18 82.34,51.03 67.33,51.03 66.61,51.75 55.46,51.75 55.04,51.34 47.32,51.34 45.77,52.89 43.32,52.89 41.86,54.35 34.83,54.35 32.65,52.17 26.09,52.17 26.04,52.12
  vias: v2(9.53,59.81) v2(11,57.43) v2(11,56.79) v2(11,56.21) v2(11.63,57.43) v2(11.63,56.21) v2(23.57,49.69) v2(23.57,49.1) v2(23.69,48.52) v2(24.15,49.61) v2(24.15,49.03) v2(24.28,48.44)
+5VA: length 6.7
  TOP w0.203: v2(28.47,38.91) 27.76,38.91 v3(27.5,39.17)
  TOP w0.508: v2(28.47,38.91) 28.79,38.59 RA8.1
  BOTTOM w0.203: 29.55,37.26 30.42,36.39 UA1.45
  BOTTOM w0.508: 29.55,37.26 CA15.1 28.74,37.91 CA14.1 28.6,38.91 v2(28.47,38.91)
+5VALW: length 647.5
  TOP w0.254: PC308.1 247.72,19.29 246.71,20.31 PU300.7 ; v2(182.95,79.67) 183.2,79.67 183.82,79.05 C2520.1
  TOP w0.305: U19.3 178.63,79.67 v2(178.49,79.53) ; U20.3 182.95,79.67 v2(182.95,79.67)
  TOP w0.356: RE449.1 227.15,27.61 226.59,28.17 v2(226.51,28.17) ; RE529.1 226.67,34 v2(226.58,34.09) ; RE521.1 227.15,30.85 226.7,31.3 v2(226.7,31.33) ; RE525.1 226.81,24.29 226.13,23.61 v2(226.13,23.42)
  TOP w0.381: v2(224.26,27.12) 224.05,27.33 RE517.1 ; QE54.1 225.94,27.86 226.26,28.17 v2(226.51,28.17)
  TOP w0.432: QE56.1 224.78,34.19 226.48,34.19 v2(226.58,34.09) ; QE55.1 225.94,30.9 226.37,31.33 v2(226.7,31.33) ; v2(224.26,27.12) 224.64,26.74 QE54.4
  TOP w0.508: 317.57,24.57 317.31,24.57 316.57,25.3 CU48.1 315.31,25.3 CU46.1 ; v2(172.45,144.8) 172.46,144.8 172.68,145.02 PC5009.1 ; RE161.2 CE81.1 153.36,164.71 v2(152.98,164.33) ; v2(163.69,144.77) 163.78,144.77 163.78,144.77 164.12,144.77 164.63,144.26 PC5007.1 ; v2(188.28,108.02) 188.16,108.14 188.16,109.08 188.72,109.64 RG511.1 188.72,110.87 ; CV36.1 164.14,165.5 v2(163.88,165.24) ; v2(142.42,152.19) 142.03,151.8 v2(142.03,150.6) 141.96,150.54 141.17,150.54 140.71,150.08 v2(140.71,147.98) 141.1,147.98 141.4,148.28 PC5008.1 ; C2521.1 178.16,79.53 v2(178.49,79.53) ; v2(197.37,174.11) 197.65,173.83 RE156.1 ; PR14.2 65.48,9.05 v3(64.26,10.28) 62.97,11.56 v2(62.97,16.83) ; 38.78,48.92 40.46,50.6 40.46,53.01 39.02,54.45 34.91,54.45 34.24,53.78 34.24,53.58 ; PR8.1 v2(314.78,53.9) ; CG384.1 194.37,105.71 v2(193.99,105.34) ; v2(201.24,177.05) 201.3,176.99 RE154.1 ; PC308.1 247.85,18.75 v2(247.98,18.62) ; RG509.1 188.48,111.12 188.72,110.87 ; v2(120.51,149.75) 120.51,149 PR545.1 ; 188.72,110.87 190.38,110.87 191.27,109.99 RG513.1 ; v2(205.56,11.23) 205.56,12.15 JWDB.1 ; RE158.1 v2(204.99,177.03) ; v2(156.08,144.93) 156.2,145.05 PC5006.1 ; v2(179.7,144.95) 179.71,144.95 179.71,144.96 180.72,144.96 PC5002.1
  IN1 w0.508: v2(158.82,148.84) 158.56,148.84 157.97,148.25 157.97,147.6 ; v2(156.08,144.93) 156.08,145.71 157.97,147.6 ; v2(148.29,148.31) 149.1,148.31 149.95,149.15 149.95,150.35 150.07,150.48 v2(150.07,150.53) 150.07,151.13 v2(151.01,152.07) ; v2(179.7,144.95) 179.71,144.95 179.71,144.96 179.79,144.96 180.78,145.95 180.78,147.48 181.64,148.34 181.92,148.34 v2(182.36,148.77) ; 157.97,147.6 v2(157.97,147.6) ; v2(174.94,148.78) 174.2,148.04 174.2,147.29 v2(174.27,147.22) 172.45,145.41 v2(172.45,144.8) ; v2(166.43,148.8) 166.43,148.67 165.58,147.82 v2(165.58,147.58) 165.19,147.18 165.19,147.09 164.47,146.38 164.47,145.52 163.78,144.83 163.78,144.77 v2(163.69,144.77) ; v2(305.67,53.23) 305.95,53.23 306.27,53.55 309.5,53.55 309.83,53.22 314.09,53.22 v2(314.78,53.9)
  IN2 w0.508: 189.2,107.17 189.19,107.17 188.35,108 188.29,108 v2(188.28,108.02) 188.16,108.14 188.16,110.48 189.43,111.75 189.43,122.38 198.26,131.21 200.82,131.21 202.64,133.02 204.67,133.02 205.18,133.53 205.18,146.58 207.12,148.52 v2(208.54,148.52) ; 189.2,107.17 192.62,107.17 192.62,107.15 193.99,105.77 v2(193.99,105.34) ; 189.2,107.17 189.2,106.61 185.77,103.18 185.77,95.29 186.85,94.21 186.85,83.56 v2(182.95,79.67) ; v2(290.6,83.86) 290.6,82.38 292.48,80.5 292.48,74.02 296.54,69.95 296.54,61.32 299.17,58.69 304.2,58.69 305.3,57.59 305.3,53.6 v2(305.67,53.23) ; v2(221.46,166.92) 221.46,167.05 220.93,167.58 212.68,167.58 210.02,170.25 210.02,170.72 207.67,173.07 207.67,174.35 v2(204.99,177.03) ; v2(92.85,41.9) 92.85,41.65 93.35,41.14 95.77,41.14 96.21,41.58 v2(96.21,41.9)
  IN3 w0.508: v2(321.83,12.04) 321.51,12.35 321.51,14.41 324.43,17.33 324.75,17.33 324.81,17.39 324.84,17.39 325.59,18.13 325.59,21.32 329.41,25.15 329.41,31.99 330.42,33.01 330.42,34.81 330.93,35.32 331.81,35.32 332.81,36.33 332.81,41.9 331.67,43.04 331.67,43.87 331.98,44.18 331.98,44.9 331.67,45.2 331.67,46.05 332.56,46.94 332.56,48.09 332.04,48.61 320.07,48.61 v2(314.78,53.9) ; v2(166.43,148.8) 166.43,150.02 161.49,154.96 161.49,156.87 160.48,157.89 153.27,157.89 152.76,158.4 152.76,164.11 v2(152.98,164.33) ; v2(105.94,66.42) 103.32,63.8 103.32,60.98 101.9,59.56 v2(101.9,58.46) 101.9,57.55 101.19,56.84 101.19,54.32 99.45,52.58 98.25,52.58 96.71,51.04 95.07,51.04 93.04,49.01 90.88,49.01 89.32,47.45 89.32,43.84 91.26,41.9 v2(92.85,41.9)
  IN4 w0.254: 160.49,165.68 161.51,164.66 163.5,164.66 163.88,165.05 v2(163.88,165.24) 163.88,165.63 163.3,166.21 160.75,166.21 160.49,165.94 160.49,165.68
  IN4 w0.508: v2(96.21,41.9) 98.05,41.9 99.64,40.31 99.64,37.36 101.36,35.64 101.36,32.07 97.99,28.69 97.99,26.51 94.14,22.66 84.15,22.66 76.97,15.48 66.39,15.48 64.4,17.48 v2(64.4,18.02) ; v2(245.25,16.21) 245.2,16.21 244.74,16.67 241.87,16.67 239.62,18.91 237.63,18.91 237.61,18.93 237.45,18.93 236.63,19.74 228.16,19.74 226.01,21.9 226.01,23.3 v2(226.13,23.42) ; v2(152.98,164.33) 157.73,164.33 159.34,165.94 160.49,165.94
  IN6 w0.508: v2(182.36,148.77) 181.92,148.34 178.77,148.34 177.71,149.41 175.56,149.41 v2(174.94,148.78) 174.14,147.98 168.08,147.98 167.39,148.67 167.17,148.67 167.04,148.8 v2(166.43,148.8) 165.82,148.8 165.74,148.71 163.64,148.71 163.41,148.95 161.94,148.95 161.83,148.84 v2(158.82,148.84) 158.82,149.39 157.66,150.55 154.36,150.55 152.84,152.07 v2(151.01,152.07) 150.98,152.1 v2(148.34,152.1) 147.9,152.1 147.77,151.97 142.64,151.97 v2(142.42,152.19) ; v2(202.17,165.25) 202.45,165.25 203.17,164.53 203.17,162.55 v2(203.9,161.83)
  BOTTOM w0.203: v2(64.4,18.02) 64.69,17.73 U17.4 ; UT4.H10 202.28,165.37 v2(202.17,165.25)
  BOTTOM w0.254: PU507.15 140.88,148.12 140.74,147.98 v2(140.71,147.98) ; v2(174.27,147.22) 174.36,147.12 PU510.2 ; v2(142.03,150.6) 142.15,150.6 142.55,150.19 142.55,150.05 142.62,149.98 PU507.2 ; PU502.2 150.19,150.41 v2(150.07,150.53) ; v2(165.58,147.58) 165.56,147.58 165.56,147.48 165.6,147.44 PU504.2 ; PU504.15 163.96,144.96 163.78,144.77 163.78,144.77 v2(163.69,144.77) ; UZ21.4 127.6,99.51 127.35,99.25 C2519.1 ; UV17.3 164.25,165.61 v2(163.88,165.24) ; v2(148.29,148.31) 148.48,148.13 PU502.15 ; v2(157.97,147.6) 157.99,147.58 PU503.2 ; PU510.15 172.7,144.63 172.65,144.68 172.58,144.68 v2(172.45,144.8) ; PU503.15 156.71,145.08 156.23,145.08 v2(156.08,144.93) ; PU511.15 180.09,144.64 179.78,144.95 v2(179.7,144.95)
  BOTTOM w0.305: UG14.3 193.96,106.07 193.96,105.37 v2(193.99,105.34) ; v2(266.44,21.67) 266.12,21.35 U16.3
  BOTTOM w0.381: RU23.1 26.91,44.34 RU21.1 28.55,44.34 28.93,44.72 28.93,46.5 ; PR5024.1 v2(174.94,148.78)
  BOTTOM w0.406: JKB.1 223.47,10.09 223.48,10.1 223.48,10.27 224.35,11.13 v2(224.51,11.13)
  BOTTOM w0.508: RM94.1 RM93.1 152.74,164.57 v2(152.98,164.33) ; 208.24,156.19 208.24,154.6 208.41,154.43 208.41,148.65 v2(208.54,148.52) ; v2(182.95,79.67) 182.11,80.51 179.47,80.51 v2(178.49,79.53) ; v2(221.46,166.92) 221.09,167.29 220.19,167.29 CE61.1 ; v2(254.07,24.25) 253.93,24.25 253.41,24.25 249.95,27.71 249.95,28.23 249.94,28.24 249.94,31.68 250.45,32.19 250.45,33.77 249.37,34.86 PR8200.2 ; PC5005.1 148.29,152.15 v2(148.34,152.1) ; RG541.1 290.6,84.59 v2(290.6,83.86) RG543.1 ; RM92.1 148.36,165.88 148.36,164.77 147.85,164.27 RM91.1 146.57,164.27 146.44,164.39 v2(144.85,164.39) ; PR5022.1 v2(142.42,152.19) ; v2(266.44,21.67) 266.44,20.88 C2516.1 ; v2(182.36,148.77) 182.1,149.03 PR5025.1 ; PR5004.1 v2(158.82,148.84) ; 108.16,67.87 108.91,68.62 108.91,74.48 117.67,83.24 117.67,96.96 119.97,99.25 C2519.1 ; PR5020.1 v2(166.43,148.8) ; v2(92.85,41.9) 92.85,41.84 92.27,41.27 PR204.1 ; PR203.1 v2(96.21,41.9) ; v2(151.01,152.07) PR553.1 ; PR577.1 v2(125.91,150.02)
  vias: v2(21.34,43.04) v2(21.34,42.45) v2(21.86,42.74) v2(21.86,42.15) v2(29.54,48) v2(29.54,47.41) v2(30.17,48.59) v2(30.17,48) v2(30.17,47.41) v2(30.81,48) v2(36.41,44.45) v2(36.41,43.82) v2(36.98,46.19) v2(36.98,45.56) v2(36.98,44.92) v2(36.98,44.29) v2(36.98,43.65) v2(37.61,46.19) v2(37.61,45.56) v2(37.61,44.92) v2(37.61,44.29) v2(37.61,43.65) v2(38.25,46.19) v2(38.25,45.56) v2(38.25,44.92) v2(38.25,44.29) v2(38.25,43.65) v2(38.88,46.19) v2(38.88,45.56) v2(38.88,44.92) v2(38.88,44.29) v2(38.88,43.65) v2(61.73,18.72) v2(61.7,18.1) v2(61.7,17.47) v2(61.7,16.83) v2(62.37,18.72) v2(62.34,18.1) v2(62.34,17.47) v2(62.34,16.83) v2(62.97,18.1) v2(62.97,17.47) v2(105.94,68.39) v2(105.94,67.76) v2(105.94,67.1) v2(106.57,68.39) v2(106.57,67.76) v2(106.57,67.1) v2(106.57,66.42) v2(142.76,167.44) v2(142.68,165.71) v2(143.26,165.71) v2(143.46,167.5) v2(143.58,164.39) v2(143.85,165.71) v2(144.22,164.39) v2(147.46,181.35) v2(147.46,180.71) v2(148.09,181.35) v2(148.09,180.71) v2(148.73,181.35) v2(148.73,180.71) v2(149.34,181.32) v2(149.34,180.69) v2(172.42,179.92) v2(172.42,179.34) v2(173.01,179.92) v2(173.01,179.34) v2(207.65,158.12) v2(207.65,157.53) v2(207.65,156.95) v2(207.65,156.37) v2(208.24,158.7) v2(208.24,158.12) v2(208.24,157.53) v2(208.24,156.95) v2(223.59,28.31) v2(318.56,24.6) v2(318.56,24.02) v2(318.56,23.43) v2(318.56,22.8) v2(319.78,11.17) v2(320.37,11.17) v2(320.95,11.17) v3(205.95,157.28) v3(208.82,156.51)
+5VALW_LED: length 10.4
  TOP w0.508: JPWR.1 210.32,168.9 209.81,169.41 208.68,169.41 208.17,168.9 208.17,165.65 v1(208.82,165) 208.83,164.99 208.83,162.84 QE8.1
+5VALWP: length 29.5
  TOP w0.508: 42.9,44.33 42.91,44.31 43.63,44.31 45.86,46.54 52.52,46.54 53.46,45.6 v2(53.46,45.08)
  BOTTOM w0.203: v2(53.46,45.08) PU100.14
  BOTTOM w0.254: PR102.2 49.4,51.22 46.81,48.63 40.97,48.63 39.38,47.04 39.38,43.18 39.34,43.15
  vias: v1(42.77,40.52) v2(41.08,44.17) v2(41.08,43.48) v2(41.08,42.84) v2(41.08,42.21) v2(41.08,41.57) v2(41.08,40.87) v2(41.59,43.79) v2(41.59,43.16) v2(41.59,42.52) v2(41.59,41.89) v2(41.59,41.19) v2(41.59,40.55) v2(42.16,44.05) v2(42.16,43.41) v2(42.16,42.71) v2(42.16,42.08) v2(42.16,41.44) v2(42.16,40.81) v2(42.67,43.09) v2(42.67,42.4) v2(42.67,41.76) v2(42.67,41.13)
+5VS: length 615.1
  TOP w0.254: v2(196.55,115.65) 196.55,116.22 195.91,116.87 190.66,116.87 188.81,115.02 186.57,115.02
  TOP w0.356: v2(239.78,161.34) 240.13,161.69 CV23.1
  TOP w0.381: RS1.1 189.02,66.03 v2(188.9,66.16)
  TOP w0.457: PC6201.1 226.72,153.75 v2(226.72,153.9)
  TOP w0.508: v2(239.78,161.34) 238.58,161.34 238.31,161.08 RX39.1 237.33,160.97 v2(236.66,160.97) ; v2(210.55,152.04) 210.61,152.1 210.61,153.81 211.21,154.41 212.11,154.41 212.11,154.41 212.49,154.41 v2(213,153.9) ; RA8.2 30.56,39.12 30.72,39.27 v2(30.72,39.96) 30.72,40.4 RA3.2 ; v2(183.21,102.42) 183.43,102.42 183.82,102.8 183.82,112.27 186.57,115.02 ; PR6111.2 239.91,152.66 240.48,152.66 PC6114.1 240.43,153.8 240.43,154.66 240.07,155.02 238.74,155.02 238.07,154.36 v2(238.07,153.55) 237.87,153.34 PR6113.1 ; PR6106.1 251.7,153.41 v2(251.9,153.61) 251.9,154.35 252.26,154.71 253.92,154.71 254.44,154.18 v2(254.44,154.04) 254.45,154.03 254.45,153.79 254.92,153.32 PC6101.1 254.44,152.76 254.15,152.76 253.87,152.48 PR6104.2 ; PR6202.2 226.17,152.31 226.54,152.68 226.69,152.68 PC6201.1 ; PR6400.1 308.4,48.86 310.7,51.16 310.7,51.75 311.44,52.49 311.44,53.41 312.66,54.63 v2(312.9,54.63)
  TOP w1.016: 131.25,7.76 110.58,7.76 104.89,13.45 94.62,13.45 92.2,11.03 ; 131.39,12.56 131.39,17.71 126.95,22.15 108.09,22.15
  IN1 w0.508: v2(226.72,153.9) 226.72,153.7 ; 226.72,153.7 226.11,153.09 224.8,153.09 v2(224.41,153.48) ; 226.72,153.7 226.72,153.65 227.8,152.57 232.48,152.57 233.46,153.55 v2(238.07,153.55) 238.6,153.01 247.79,153.01 248.38,153.61 v2(251.9,153.61) ; 223.85,153.09 223.33,152.57 214.08,152.57 213,153.65 v2(213,153.9) ; v2(315.24,57.33) 314.52,56.62 314.52,55.13 314.02,54.63 v2(312.9,54.63) ; v2(254.44,154.04) 254.45,154.03 254.45,153.79 255.09,153.15 263.46,153.15 265.02,151.6 265.02,150.8 267.64,148.17 271.73,148.17 272.23,148.68 281.47,148.68 284.62,145.53 284.62,139.53 v2(283.96,138.87)
  IN1 w1.016: 223.29,154.35 222.87,154.77 222.87,155.45 222.58,155.74 222.58,159.27 223.07,159.77 223.07,159.78 223.24,159.95 223.24,161.04 223.07,161.2 223.07,162.54 223.24,162.7 223.24,166.78 222.38,167.64 222.38,169.51 223.39,170.53 223.85,170.53 ; 292.55,77.19 292.87,77.19 292.87,74.92 299.35,68.44 299.35,65.21
  IN2 w0.508: v2(196.55,115.65) 195.31,116.89 194.53,116.89 194.52,116.91 194.02,116.91 193.34,117.58 193.34,119.09 192.55,119.88 191.11,119.88 190.06,120.92 190.06,122.12 196.37,128.43 196.77,128.43 198.26,129.91 200.42,129.91 201.08,130.57 201.08,130.57 202.9,132.39 204.93,132.39 205.89,133.34 205.89,141.81 211.13,147.05 211.13,151.1 210.55,151.68 v2(210.55,152.04)
  IN3 w0.508: v2(181.5,71.81) 179.08,69.39 179.08,61.34 180.54,59.88 180.54,54.6 180.77,54.37 180.77,48.51 181.49,47.78 181.49,45.02 180.54,44.07 180.54,34.53 178.52,32.51 178.52,31.12 175.97,28.57 174.13,28.57 173.96,28.73 168.96,28.73 168.35,28.12 163.52,28.12 v2(162.7,27.3)
  IN3 w1.524: 283.79,21.64 283.79,19.55 282.36,18.11 282.36,10.76 283.03,10.09 283.03,8.5
  IN4 w1.016: 108.09,61.27 108.87,60.48 108.87,51.2 104.81,47.13 104.81,33.45 108.09,30.18 108.09,27.87
  IN6 w0.508: v2(181.5,71.81) 181.49,71.81 181.49,67.7 182.79,66.4 188.65,66.4 v2(188.9,66.16) ; v2(283.96,135.18) 283.96,132.23 287.22,128.97 287.22,85.78 291.55,81.45 v2(291.55,77.63)
  BOTTOM w0.203: v2(196.55,115.65) 196.55,115.15 196.66,115.05 UG12.4
  BOTTOM w0.305: v2(254.44,154.04) 254.21,153.81 PU6100.3 ; PU6200.3 v2(226.72,153.9) ; PC6214.1 213,154.54 v2(213,153.9) 213.06,153.83 PU6201.3 ; PU6101.3 240.43,153.97
  BOTTOM w0.381: UV3.16 v2(236.66,160.97)
  BOTTOM w0.508: 240.43,153.97 240.43,155.05 239.76,155.72 ; v2(162.7,27.3) 162.7,11.1 ; v2(196.55,115.65) 196.74,115.84 CG386.1 ; JKB3.5 62.93,7.94 62.43,8.44 JKB3.6 62.43,11.11 62.18,11.36 ; PC6214.1 211.83,155.71 PR6209.2 211.41,155.95 210.37,155.95 209.86,155.44 PR6207.2 209.1,153.6 PR6208.2 209.1,152.91 PR6211.1 ; v2(224.41,153.48) 224.53,153.61 PR6200.2 ; PR6047.2 v2(283.96,138.87) 283.97,138.87 284.59,138.25 284.59,137.03 ; 284.59,137.03 283.35,137.03 PR6051.2 ; 284.59,137.03 284.59,135.69 284.08,135.18 v2(283.96,135.18) PR6052.2 283.35,133.47 282.27,132.39 PR6050.2 PR6046.2 278.44,132.39 PR6048.2 277.82,132.39 277.31,132.9 PR6035.1 ; 239.76,155.72 237.72,155.72 237.36,155.36 PR6109.2 237.36,153.56 PR6110.2 v2(238.07,153.55) ; 239.76,155.72 239.76,161.31 v2(239.78,161.34) ; PR6201.2 223.14,153.99 v2(222.89,153.75) 222.89,152.58 223.27,152.2 PR6204.1 ; v2(183.21,102.42) 183.23,102.44 183.46,102.44 183.68,102.66 188.87,102.66 189.68,101.84 189.68,84.59 189.26,84.17 189.26,70.2 189.9,69.57 189.9,68.57 189.71,68.38 189.71,66.97 v2(188.9,66.16) ; v2(251.9,153.61) PR6103.2 251.14,153.62 PR6102.2
  vias: v2(34.93,52.95) v2(35.63,52.95) v2(44.27,51.24) v2(44.85,51.24) v2(59.14,10.98) v2(59.27,12.05) v2(59.52,11.48) v2(59.84,10.98) v2(59.9,12.05) v2(60.22,11.55) v2(60.54,12.05) v2(60.47,10.98) v2(60.85,11.55) v2(61.11,10.98) v2(61.17,12.05) v2(61.49,11.55) v2(90.98,9.65) v2(90.98,9.02) v2(91.61,9.65) v2(91.61,9.02) v2(92.25,9.65) v2(92.25,9.02) v2(92.85,9.64) v2(92.88,9.02) v2(93.48,9.64) v2(93.48,9.01) v2(94.12,9.64) v2(94.12,9.01) v2(106.24,62.92) v2(106.24,62.03) v2(106.94,23.74) v2(107.2,23.01) v2(131.36,9.33) v2(132,9.33) v2(132.63,9.33) v2(133.27,9.33) v2(133.9,9.33) v2(147.86,2.97) v2(148.48,2.99) v2(148.89,5.4) v2(149.5,5.4) v2(157.36,11.1) v2(157.36,10.47) v2(158,11.1) v2(158,10.47) v2(224.75,170.34) v2(225.43,170.32) v2(228.23,8.25) v2(228.99,8.25) v2(282.01,7.27) v2(282.6,7.27) v2(283.22,7.29) v2(283.73,24.57) v2(283.73,23.93) v2(283.73,23.3) v2(291.55,76.99) v2(307.34,61.8) v2(307.97,61.8) v3(144.22,8.07)
