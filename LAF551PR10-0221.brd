# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BATPRES#_CHG: length 3.2
  TOP w0.102: v1(54.24,20.45) PR727.2
  TOP w0.203: PR727.2 55.25,21.2 55.63,21.58 56.04,21.58 56.24,21.78 PU700.15
BATSRC_CHG: length 31.8
  TOP w0.203: PU700.17 57.04,21.41 56.96,21.33 56.96,21.31 56.71,21.07 v2(56.71,20.95)
  TOP w0.254: v2(78.2,30.32) 78.24,30.28 PR734.2
  IN3 w0.254: v2(56.71,20.95) 56.71,21.14 57.22,21.64 57.67,21.64 58.47,20.84 61.44,20.84 61.86,21.26 65.21,21.26 65.5,20.97 70.32,20.97 70.69,21.34 75.21,21.34 77.8,23.93 77.8,29.91 v2(78.2,30.32)
BATT+: length 0.6
  TOP w0.102: v2(81.16,22.99) v3(81.16,23.55)
BATT++: length 37.3
  TOP w0.102: v2(84.9,21.09) 84.86,21.05 v3(84.86,20.3)
  TOP w0.203: v3(84.21,22.41) v3(84.21,24.36)
  IN4 w0.508: 83.65,21.09 77.42,14.85 61.73,14.85 59.89,16.69 59.89,16.85 59.89,16.86 59.89,17.36 59.89,17.37 59.89,18.14 59.9,18.14 59.9,18.65 59.89,18.65 v2(59.89,21.71)
  BOTTOM w0.508: PD700.2 58.86,20.17 59.32,20.63 59.32,21.01 59.89,21.58 v2(59.89,21.71)
  vias: v2(85.48,21.11)
BATT_CHG_LED: length 40.3
  TOP w0.127: v2(322.71,39.06) 322.71,38.53 v1(322.8,38.43)
  TOP w0.254: UE1.19 319.61,15.58 v2(319.57,15.62)
  TOP w0.432: RE23.2 325.27,39.77 QE1.6
  TOP w0.508: v2(322.71,39.06) 322.75,39.06 323.36,39.67 324.61,39.67 324.71,39.56 RE23.2
  IN3 w0.508: v2(322.71,39.06) 322.71,37.57 317.53,32.39 317.53,31.58 315.68,29.73 315.68,29.01 316.72,27.97 316.72,27.4 316.25,26.93 316.25,26.42 316.43,26.24 316.43,20.68 316.25,20.5 314.93,19.18 314.14,19.18 v2(313.44,18.48)
  IN6 w0.508: v2(319.57,15.62) 319.57,16.98 317.89,18.66 313.62,18.66 v2(313.44,18.48)
BATT_CHG_LED#: length 51.1
  TOP w0.127: v1(325.22,43.88) 325.12,43.98 324.51,43.98 324.27,43.74 324.27,43.4 324.62,43.04 QE1.2
  TOP w0.203: v2(303.13,8.47) 303.13,9.98 UE5.90
  TOP w0.432: v2(324.68,42.19) 324.62,42.25 QE1.2
  IN3 w0.508: v2(324.68,42.19) 324.82,42.19 325.32,41.68 325.32,35.68 319.06,29.41 319.06,26.75 319.99,25.82 319.99,25.2 319.35,24.57 319.35,21.47 317.95,20.08 317.95,20.01 312.99,15.04 310.52,15.04 308.69,13.2 306.41,13.2 303.13,9.93 v2(303.13,8.47)
BATT_LOW_LED: length 52.7
  TOP w0.254: UE1.13 319.33,12.58 319.19,12.73 317.99,12.73 317.83,12.56 316.72,12.56 315.74,13.54 315.74,16.81 v2(314.78,17.77)
  TOP w0.432: QE3.6 326.48,45.41 326.85,45.78 v2(327.03,45.78)
  TOP w0.508: v2(327.03,45.78) 327.29,45.78 327.91,46.4 v1(327.91,47.48) 327.4,47.98 RE21.2
  IN3 w0.508: v2(327.03,45.78) 326.58,45.78 325.37,46.99 324.1,46.99 323.86,46.75 323.8,46.75 323.29,46.24 323.29,44.53 323.44,44.37 323.52,44.37 324,43.89 324,41.19 324.05,41.14 324.05,39.86 323.6,39.41 323.6,37.2 318.42,32.02 318.42,27.01 317.32,25.91 317.32,20.31 v2(314.78,17.77)
BATT_LOW_LED#: length 56.9
  TOP w0.127: v1(303.98,7.32) 304.4,7.74 v2(304.4,8.56)
  TOP w0.203: UE5.93 304.34,8.63 v2(304.4,8.56)
  TOP w0.432: QE3.2 325.83,46.47 325.45,46.09 324.84,46.09 v2(324.67,46.26)
  IN3 w0.508: v2(324.67,46.26) 325.09,46.26 326.55,44.8 326.55,44.44 326.59,44.4 326.59,35.15 321,29.56 321,27.42 321.52,26.9 321.52,21.85 319.22,19.55 319.22,19.48 315.97,16.23 315.97,15.81 315.86,15.7 315.44,15.28 315.44,13.66 313.27,11.48 306.49,11.48 304.4,9.4 v2(304.4,8.56)
BATT_PRS: length 7.8
  TOP w0.254: v2(82.82,11.49) 82.43,11.49 v1(81.82,12.1) 81.28,12.63 PR22.1
  BOTTOM w0.508: PBATT1.7 v2(82.82,11.49)
BBS_BIT0: length 3.1
  TOP w0.089: RH130.2 215.32,28.24 214.98,28.58 v1(214.27,28.58) 213.81,28.58 213.55,28.32 v2(213.55,28.12)
  BOTTOM w0.122: v2(213.55,28.12) 213.55,28.32 213.18,28.68 UH1.BA26
BEEP#: length 320.9
  TOP w0.102: DA1.2 41.08,26.26 41.73,26.91 41.73,32.78 41.62,32.89 41.62,34.46 39.86,36.22 39.86,36.28 39.86,38.35 39.84,38.37 v1(39.7,38.51) 36.65,41.56 36.65,41.97 36.65,42.17 36.06,42.75 36.06,43.5 35.93,43.63 35.93,44.57 36.26,44.9 36.26,45.1 36.26,46.33 36.65,46.72 36.65,47.55 40.03,50.92 40.03,52.81 39.68,53.15 36.4,53.15 v2(36.21,52.96)
  TOP w0.107: UE5.23 296.74,26.48 295.97,27.24 v2(295.97,28.69)
  IN2 w0.102: v2(295.97,28.69) 295.48,28.69 294.4,29.77 293.29,29.77 290.57,32.49 286.22,32.49 282.7,36.01 278.82,36.01 278.27,36.56 278.27,38.2 275.54,40.93 274.26,40.93 269.08,46.11 245.68,46.11 243.42,48.36 227.74,48.36 227.09,49.01 224.27,49.01 223.02,50.26 212.4,50.26 207.33,55.33 202.48,55.33 199.31,52.16 196.21,52.16 194.59,53.78 190.09,53.78 186.71,50.39 180.14,50.39 178.98,49.23 174.94,49.23 174.48,49.69 173.05,49.69 172.94,49.8 155.27,49.8 153.8,51.26 145.4,51.26 143.94,49.8 128.77,49.8 127.48,51.08 124.44,51.08 123.77,51.75 109.19,51.75 107.99,50.55 97.7,50.55 97.2,51.06 91.79,51.06 91.23,50.5 86.15,50.5 85.7,50.94 84.61,50.94 83.05,49.38 67.49,49.38 66.18,50.7 55.89,50.7 55.48,50.28 46.87,50.28 45.33,51.82 42.7,51.82 42.5,51.62 37.09,51.62 36.65,52.06 36.65,52.63 36.32,52.96 v2(36.21,52.96)
BKOFF#: length 360.7
  TOP w0.089: v2(217.24,116.28) RG569.2
  TOP w0.102: DV1.2 v2(171.76,161.19) ; v2(207.07,153.66) 205.18,153.66 204.61,153.09 204.61,150.8 202.19,148.39 199.17,148.39 198.76,148.8 197.15,148.8 193.75,152.2 191.12,152.2 190.94,152.38 190.94,152.37 190.9,152.37 190.9,152.38 190.89,152.39 190.89,152.39 v2(190.89,152.39) ; v2(300.6,18.41) 300.6,17.95 300.34,17.68 300.34,17.06 300.75,16.65 301.66,16.65 302,16.32 302,15.78 303.05,14.72 306.14,14.72 306.23,14.81 UE5.105
  IN4 w0.089: v2(217.24,116.28) 217.09,116.44 217.09,117.81 216.75,118.15 216.75,118.65 216.75,119.27 216.75,119.27 216.75,120.23 216.82,120.29 216.82,121.49 216.95,121.62 216.95,122.36
  IN4 w0.102: v2(298.01,32.25) 297.19,32.25 296.54,31.6 292.74,31.6 292.01,30.87 284.44,30.87 283.28,32.02 276.74,32.02 274.99,30.27 269.2,30.27 266.19,27.26 265.3,27.26 264.31,26.27 261.65,26.27 261.39,26 260.07,24.68 258.32,24.68 257.6,25.39 257.6,25.43 256.05,26.98 248.61,26.98 247.58,28 247.58,29.3 246.82,30.06 243.2,30.06 241.37,31.89 241.37,35.04 238.26,38.15 236.6,38.15 235.25,39.5 233.72,39.5 232.22,41 231.95,41.27 230.69,41.27 230.69,41.27 230.06,41.27 229.33,40.53 227.29,40.53 226.91,40.15 224.23,40.15 223.16,41.21 223.16,41.21 219.08,41.21 219.04,41.18 219.02,41.18 218.78,40.93 218.78,40.88 218.48,40.59 214.12,40.59 213.81,40.9 211.65,40.9 210.33,42.22 210.33,43.43 209.12,44.64 208.78,44.64 207.78,45.63 203.05,45.63 192.98,55.7 189.65,55.7 188.34,57.01 186.95,57.01 186.08,57.89 186.08,62.41 186.29,62.63 186.29,62.81 186.29,62.81 186.29,63 188.49,65.2 188.49,70.05 187.96,70.57 187.96,78.01 187.4,78.57 187.4,82.24 187.74,82.58 187.74,94.63 184.92,97.45 184.92,100.85 184.79,100.97 184.79,105.39 184.96,105.56 184.96,108.46 186.04,109.54 186.04,111.08 186.56,111.6 186.56,116.06 187.73,117.22 187.73,121.03 193.33,126.64 193.33,127.23 193.94,127.84 193.94,128.64 194.57,129.26 194.57,147.13 191.08,150.61 191.08,152.2 v2(190.89,152.39) 190.7,152.39 189.93,153.16 189.22,153.16 186.85,155.53 185.52,155.53 185.14,155.91 182.93,155.91 181.66,157.18 181.66,158.3 180.26,159.69 178.89,159.69 178.57,160.01 177.01,160.01 175.42,161.6 172.17,161.6 v2(171.76,161.19) ; v2(207.07,153.66) 207.09,153.66 207.7,153.04 207.7,150.19 206.89,149.38 206.89,145.82 210.08,142.63 210.08,134.03 211.78,132.32 211.78,128.31 212.32,127.77 215.31,127.77 216.95,126.12 216.95,122.36
  BOTTOM w0.102: v2(298.01,32.25) v1(298.4,31.87) 298.4,29.64 297.99,29.24 297.99,23.76 297.37,23.13 297.37,17.57 298.31,16.63 298.31,16.63 298.54,16.39 298.55,16.39 299.14,15.8 300.26,15.8 300.58,16.12 300.58,17.15 300.58,17.16 300.58,18.38 v2(300.6,18.41)
BOARD_ID: length 3.6
  TOP w0.089: v2(213.56,32.26) 213.64,32.26 v1(214,32.63) 214.45,33.07 214.8,33.07 RH22.1 RH21.1
  BOTTOM w0.089: v2(213.56,32.26) 213.56,32.19 213.23,31.85 UH1.BA20
BOOT_1.2V: length 1.5
  BOTTOM w0.114: v1(88.87,46.76) 89.61,46.03 PR200.2
BS2_1.0VS_VGAP: length 1.7
  BOTTOM w0.102: PR806.2 248.88,43.55 v1(249.88,42.55)
BS2_+1.8VGS: length 1.7
  BOTTOM w0.102: PC823.1 234.35,44.25 v1(235.37,43.23)
BS_1.0VS_VGAP:
  vias: v1(244.74,43.55)
BS_+1.8VGS: length 2.4
  BOTTOM w0.102: v1(234.36,41.23) 232.74,42.85 PR816.1
BST2_3V: length 1.2
  BOTTOM w0.102: PC105.2 v1(58.44,48.73)
BST2_5V: length 1.3
  BOTTOM w0.102: PR109.2 48.61,46.33 v1(48.22,46.73)
BST2_+1VALWP: length 0.9
  TOP w0.102: 248.46,23.43 v1(249.32,23.43)
BST2_VCCIO: length 1.3
  BOTTOM w0.102: PR5010.2 118.31,114.52 v1(117.83,114.04)
BST_1.2V: length 1.6
  BOTTOM w0.114: v1(87.45,46.85) 88.21,46.09 PR200.1
BST_3V: length 2.9
  BOTTOM w0.114: PR108.2 57.22,46.22 57.86,45.58 v1(59.69,45.58)
BST_+1VALWP: length 0.6
  TOP w0.102: 246.02,23.73 v1(245.46,23.73)
BST_VCCIO:
  vias: v2(119.11,116.59)
BT_OFF#: length 160.4
  TOP w0.089: v2(212.58,29.49) 212.58,29.52 213.14,30.08 214.63,30.08 215.32,30.77 RH517.2
  TOP w0.102: RN17.2 v2(317.86,37.95)
  IN2 w0.089: v2(212.58,29.49) 212.64,29.49 213.03,29.88 215.13,29.88 216.51,31.27 216.52,31.27 217.16,31.27 217.65,30.78 217.65,30.77 217.67,30.74 217.67,30.46 217.67,30.44 218.58,29.53 218.88,29.53 218.92,29.49 219.18,29.49
  IN2 w0.102: v2(234.9,17.99) 234.9,18.37 234.79,18.47 229.97,18.47 228.19,20.25 227.4,21.04 227.4,22.41 227.15,22.66 227.15,23.1 225.52,24.73 225.52,24.99 225.52,24.99 225.52,25.17 222.78,27.92 221.67,27.92 220.1,29.49 219.18,29.49
  IN6 w0.102: v2(317.95,14.72) 317.26,14.72 315.99,15.99 312.49,15.99 311.96,16.53 307.7,16.53 306.47,17.76 300.1,17.76 300.05,17.71 296.08,17.71 295.33,18.46 293.28,18.46 292.66,17.83 276.23,17.83 275.92,18.15 275.92,19.23 275.49,19.66 274.79,19.66 274.33,19.21 267.55,19.21 266.18,20.58 260.54,20.58 255.77,25.35 250.8,25.35 248.99,23.55 248.99,17.72 247.99,16.72 242.36,16.72 241.23,17.85 235.04,17.85 v2(234.9,17.99)
  BOTTOM w0.089: v2(212.58,29.49) 212.69,29.49 UH1.BA24
  BOTTOM w0.107: v2(317.95,14.72) 318.65,14.72 319.16,15.23 319.16,15.79 319.89,16.53 319.89,27.76 v1(320.89,28.76) 321.7,29.57 321.7,31.25 320.98,31.96 320.98,37.83 320.5,38.31 318.32,38.31 317.96,37.95 v2(317.86,37.95)
BT_OFF#_R: length 8.8
  TOP w0.102: v1(316.8,40.85) 316.68,40.73 v2(316.68,40.33) 316.67,40.31 RN16.2 CN25.1 316.71,38.73 RN17.1
  BOTTOM w0.107: JWLAN.46 313.57,40.44 313.97,40.04 316.4,40.04 v2(316.68,40.33)
BTST_CHG: length 1.2
  TOP w0.102: PR708.2 v1(61.41,22.29)
BTST_CHG2: length 1.2
  TOP w0.102: PR708.1 v1(62.81,22.27)
BUSPOWER#: length 6.5
  BOTTOM w0.076: 203.55,164.62 202.86,164.62 202.66,164.41 UT4.F10
  BOTTOM w0.102: 207.34,165.28 207.34,164.17 v1(207.4,164.1)
  BOTTOM w0.107: 203.55,164.62 203.6,164.57 203.95,164.57 204.57,165.19 204.62,165.19 204.97,165.54 207.08,165.54 207.34,165.28
CALDERA_ PWRGD: length 366.4
  TOP w0.102: UE6.15 331.54,47.49 v2(331.03,48) 329.99,49.04 v1(329.99,49.56)
  IN4 w0.089: 194.55,43.57 193.9,44.23 193.9,44.29
  IN4 w0.102: 193.9,44.29 193.68,44.51 190.24,44.51 188.96,45.79 188.66,45.79 188.3,46.15 188.3,46.44 188.05,46.7 188.05,52.36 187.24,53.17 187.24,53.87 186.8,54.31 186.79,54.31 185.82,55.28 185.82,55.53 185.8,55.55 185.3,56.05 185.3,56.6 184.71,57.19 184.71,62.16 184.16,62.7 184.16,62.7 184.11,62.76 184.11,63.72 184.55,64.16 184.55,69.3 184.26,69.6 184.26,69.93 185.54,71.22 185.54,76.42 185.02,76.94 185.02,83.7 185.98,84.65 185.98,88.73 186.28,89.03 186.28,94.14 182.29,98.13 182.29,100.8 182.55,101.05 182.55,107.1 183.41,107.97 183.41,109.25 183.9,109.74 183.9,112.58 184.72,113.39 184.72,120.29 191.73,127.3 191.73,127.89 192.54,128.71 192.54,128.74 192.54,129.53 193.19,130.18 193.19,136.18 192.41,136.96 192.41,138.05 193.05,138.69 193.05,142.37 192.13,143.28 192.13,147.6 189.44,150.3 189.11,150.3 185.31,154.1 185,154.1 184.74,154.37 184.57,154.53 181.71,154.53 181.06,155.18 172.35,155.18 171.68,155.85 169.44,155.85 168.61,156.68 168.61,156.89 165.93,159.57 165.93,161.73 165.08,162.58 165.08,166.25 159.52,171.82 154.54,171.82 153.69,172.67 153.69,176.26 v2(152.67,177.28) ; v2(331.03,48) 330.56,48.47 329.76,48.47 329.46,48.17 329.46,47.19 329.93,46.73 332.69,46.73 335.12,44.29 335.12,36.28 331.59,32.76 328.49,32.76 327.92,33.33 327.03,33.33 324.72,31.02 320.41,31.02 320.31,30.92 318.09,28.69 309.01,28.69 305.68,25.37 293.92,25.37 292.95,26.34 289.04,26.34 288.69,26.69 286.67,26.69 286.32,26.34 285.35,26.34 284.67,25.66 280.55,25.66 279.66,24.77 270.61,24.77 269.61,24.77 268.31,23.47 266.07,23.47 265.79,23.19 265.77,23.19 265.53,22.95 265.05,22.95 264.03,21.92 258.19,21.92 258.03,22.09 255.19,22.09 255.05,21.95 253.51,20.41 251.37,20.41 247.93,23.85 247.39,24.39 246.82,24.39 245.89,25.32 245.75,25.45 239.79,25.45 238.85,25.45 238.63,25.24 237.77,25.24 237.16,25.85 237.16,26.06 236.89,26.33 235.97,27.24 235.97,30.85 235.41,31.42 235.41,35.48 234.67,36.22 232.81,36.22 232.6,36.44 230.89,38.14 228.28,38.14 227.5,37.37 226.31,37.37 226.18,37.24 224.24,37.24 222.9,35.89 220.14,35.89 218.58,37.46 214.58,37.46 213.56,38.47 212.48,38.47 211.76,39.2 210.92,39.2 209.72,40.39 204.38,40.39 204.14,40.63 202.93,40.63 202.68,40.88 200.61,40.88 200.26,41.23 198.7,41.23 197.36,42.57 195.3,42.57 194.7,43.17 194.7,43.42 194.55,43.57
  BOTTOM w0.102: 152.66,177.27 152.24,176.86 RM42.1
  BOTTOM w0.107: 152.66,177.27 v2(152.67,177.28) JCDRA.2
CALDERA_ON: length 332.6
  TOP w0.107: v2(305.27,16.89) 305.3,16.89 306.18,16.01 UE5.108
  IN4 w0.102: v2(150.26,175.45) 150.31,175.4 150.31,173.25 151.23,172.33 151.23,169.19 151.53,168.89 151.53,163.73 152.39,162.87 154.92,162.87 155.73,162.05 160.08,162.05 160.31,162.28 163.45,162.28 164.56,161.16 164.56,156.89 165.6,155.85 167.5,155.85 168.87,154.48 171.11,154.48 171.51,154.08 171.78,153.81 172.79,153.81 174.96,151.64 185.83,151.64 188.54,148.93 188.87,148.93 190.76,147.03 190.76,143.47 190.59,143.3 190.59,138.64 191.04,138.18 191.04,129.15 190.36,128.46 190.36,127.87 183.35,120.86 183.35,117.94 181.95,116.54 181.95,113.34 182.02,113.28 182.02,113.27 182.53,112.76 182.53,110.31 182.04,109.82 182.04,108.69 180.92,107.58 180.92,95.79 178.55,93.41 178.55,88.27 183.65,83.17 183.65,76.37 184.17,75.85 184.17,71.79 182.89,70.5 182.89,70.38 182.16,69.66 182.16,66.81 182.56,66.41 182.56,61.34 182.83,61.08 182.83,57.13 183.69,56.27 183.69,55.01 183.9,54.79 183.9,53.33 186.27,50.97 186.27,46.03 190.63,41.66 193.97,41.66 194.42,41.2 197.11,41.2 198.23,40.09 199.79,40.09 201.37,38.51 201.37,37.9 201.88,37.39 201.88,36.63 202.32,36.19 204.45,36.19 206.04,34.6 206.35,34.6 206.35,34.6 206.57,34.6 207.2,33.98 207.77,33.98 208.92,32.82 212.07,32.82 212.74,33.49 213.09,33.49 213.44,33.84 216.12,33.84 217.09,34.81 218.46,34.81 218.85,34.42 218.96,34.42 220.07,33.32 221.85,33.32 223.06,34.52 223.47,34.52 224.81,35.87 226.75,35.87 226.85,35.97 229.43,35.97 229.98,35.42 229.98,35.21 230.34,34.85 230.34,34.59 231.09,33.84 231.23,33.7 231.23,33.43 231.9,32.75 232.16,32.49 232.16,26.94 234.87,24.23 235.49,24.23 237.21,22.51 239.12,22.51 240.7,24.08 245.19,24.08 246.29,22.98 246.86,22.98 250.8,19.04 254.08,19.04 254.58,19.54 257.03,19.54 258.05,20.55 264.7,20.55 265.41,21.27 266.61,21.27 267.25,21.91 272.72,21.91 272.88,21.75 292.65,21.75 292.75,21.64 293.9,20.5 296.5,20.5 297.25,21.26 300.17,21.26 301.73,22.81 305.52,22.81 306.34,21.99 306.34,17.97 v2(305.27,16.89)
  BOTTOM w0.107: RM41.2 150.62,172.72 150.26,173.08 v2(150.26,175.45) UM7.2 150.26,176.85 v1(150.84,177.43) 151.87,178.46 JCDRA.1
CALDERA_PRSNT#: length 417.9
  TOP w0.102: v2(332.11,41.08) 332.27,41.23 332.27,41.84 332.04,42.07 UE6.5 ; UE1.22 319.87,17.08 318.66,15.87 317.9,15.87 v2(317.76,15.74)
  IN3 w0.102: v2(139.13,155.19) 139.13,154.89 140.62,153.39 146.49,153.39 151.04,157.94 151.04,165.04 150.01,166.07 150.01,166.46 150.21,166.67 150.21,168.81 149.71,169.31 149.71,171.47 155.38,177.13 v2(158.95,177.13) ; v2(332.11,41.08) 331.16,41.08 330.46,40.38 330.46,39.17 330.84,38.79 330.84,37.65 326.75,33.56 326.75,26.99 326.44,26.68 326.44,24.44 323.47,21.46 323.47,19.71 322.55,18.8 320.16,18.8 317.98,16.62 317.98,15.95 v2(317.76,15.74)
  IN4 w0.102: v2(158.95,177.13) 160.28,175.8 160.28,171.38 165.31,166.35 165.31,164.6 166.16,163.74 166.16,159.66 168.84,156.99 168.84,156.77 169.53,156.08 171.78,156.08 172.44,155.41 180.97,155.41 181.16,155.41 181.81,154.76 184.67,154.76 184.97,154.47 185.1,154.33 185.4,154.33 189.21,150.53 189.53,150.53 193.42,146.64 193.42,130.09 192.77,129.43 192.77,129.41 192.77,128.84 192.77,128.84 192.77,128.61 191.96,127.8 191.96,127.2 184.95,120.19 184.95,113.3 184.13,112.49 184.13,109.65 183.82,109.33 183.82,107.41 182.77,106.37 182.77,100.63 183.21,100.19 183.21,97.54 186.51,94.24 186.51,88.51 186.2,88.21 186.2,84.55 186.17,84.51 185.49,83.84 185.49,76.8 185.64,76.65 185.77,76.52 185.77,71.12 185.07,70.42 185.07,64.36 184.34,63.62 184.34,62.85 184.47,62.72 184.94,62.25 184.94,57.29 185.53,56.69 185.53,56.14 186.05,55.62 186.05,55.38 186.89,54.54 192.41,54.54 197.48,49.47 197.48,47.82 196.69,47.03 196.69,46.48 197.3,45.86 197.3,43.46 198.99,41.78 200.49,41.78 200.84,41.43 202.9,41.43 203.16,41.18 204.37,41.18 204.61,40.94 209.95,40.94 210.75,40.13 213.43,40.13 214.92,38.64 218.63,38.64 219,39.02 220.05,39.02 220.94,39.91 221.86,39.91 222.74,39.03 223.8,39.03 224.01,39.23 225.06,39.23 225.26,39.03 227.08,39.03 227.67,39.61 229.7,39.61 229.96,39.87 230.02,39.87 230.5,40.35 231.57,40.35 233.34,38.59 234.88,38.59 236.22,37.24 237.88,37.24 239.34,35.78 239.34,33.77 239.02,33.46 239.02,28.31 240.19,27.14 246.44,27.14 247.52,26.06 255.66,26.06 256.63,25.1 256.63,25.07 257.94,23.77 260.44,23.77 262.03,25.35 264.79,25.35 265.09,25.66 265.94,25.66 269.63,29.35 275.37,29.35 275.63,29.62 280.34,29.62 280.67,29.95 297.76,29.95 298.12,30.31 298.94,30.31 300.14,31.51 304.4,31.51 304.98,32.09 309.86,32.09 310.46,32.69 319.52,32.69 319.72,32.9 324.06,32.9 326.13,34.97 328.86,34.97 329.25,35.36 331.04,35.36 332.71,37.03 332.71,40.48 v2(332.11,41.08)
  BOTTOM w0.107: JCDRA.21 160.62,178.47 160.73,178.36 160.73,177.92 159.94,177.13 v2(158.95,177.13) 158.69,176.87 RM5.2 ; v2(139.13,155.19) 138.9,155.19 RM61.1
CALDERA_RST#: length 304.5
  TOP w0.114: v2(330.94,47.42) 331.04,47.32 UE6.16
  IN1 w0.081: v2(330.94,47.42) 330.94,47.42 330.94,47.43 330.91,47.43 330.91,47.13 330.33,46.56 328.35,46.56 327.81,47.11 327.81,47.34 326.82,48.33 323.9,48.33 322.4,46.83 320.18,46.83 319.96,47.04 312.94,47.04 310.94,45.04 309.19,45.04 308.14,44 307.6,44 306.22,42.61 299.77,42.61 299.13,41.97 274.16,41.97 268.56,47.57 253.67,47.57 253.07,48.16 249.55,48.16 248.69,47.3 220.38,47.3 219.59,48.08 219.59,49.08 219.31,49.36 217.97,49.36 212.86,54.47 212.86,64.14 212.21,64.79 212.21,66.69 210.4,68.51 202.51,68.51 202.05,68.97 200.97,68.97 200.3,69.65 194.76,69.65 194.38,70.03 191.97,70.03 189.55,72.45 189.55,85.57 191.77,87.79 191.77,96.23 190.03,97.97 190.03,100.12 189.43,100.72 189.43,105.86 189.7,106.13 189.7,111.54 193.07,114.9 193.07,122.44 193.81,123.18 193.81,128.01 198.54,132.74 v2(198.54,145.68)
  IN3 w0.127: v2(163.97,173.89) 163.8,173.89 162.7,172.78 162.7,169.79 164.73,167.76 164.73,162.17 168.77,158.12 168.77,156.34 171.26,153.85 173.01,153.85 173.27,153.6 173.74,153.6 174.76,152.58 184.42,152.58 184.58,152.42 187.96,152.42 190.1,150.28 190.1,150 191.46,148.64 196.06,148.64 198.54,146.17 v2(198.54,145.68)
  BOTTOM w0.114: UM3.1 161.48,174.38 161.61,174.5 161.82,174.5 161.82,174.5 RM6.2 162.3,174.5 162.53,174.27 162.53,174.25 162.89,173.89 v2(163.97,173.89)
CAPS: length 103.6
  TOP w0.102: v2(281.24,18.9) 281.24,19.17 279.61,20.8 279.61,25.63 278.84,26.41 278.84,28.14 277.86,29.11 v1(277.86,30.69) 277.86,33.56 277.26,34.15 276.34,34.15 274.21,36.27 274.21,39 272.89,40.33 271.31,40.33 270.33,39.35 RE639.1
  IN4 w0.102: v2(281.24,18.9) 280.78,18.44 280.11,18.44 278.43,20.12 272.48,20.12 271.32,18.96 266.82,18.96 266.75,18.89 260.42,18.89 259.26,17.73 255.08,17.73 254.71,17.36 249.15,17.36 248.12,16.34 246.6,16.34 245.67,17.27 241.88,17.27 239.78,19.36 237.63,19.36 236.8,20.18 233.68,20.18 v2(233.23,20.63)
  BOTTOM w0.102: 226.64,10.34 224.14,10.34 223.86,10.07 223.86,8.81 223.63,8.57 222.79,8.57 222.47,8.89 JKB.3
  BOTTOM w0.107: 226.64,10.34 229.25,10.34 229.43,10.52 230.68,10.52 232.48,12.32 232.48,17.76 231.46,18.78 231.46,19.34 232.75,20.63 v2(233.23,20.63)
CAPS_LED: length 54.1
  TOP w0.102: v2(303.36,7.65) 303.36,8.03 303.63,8.3 303.63,8.98 303.54,9.07 UE5.91
  TOP w0.107: RE640.1 271.17,34.75 271.87,34.05 274.44,34.05 277.21,31.29 277.21,29.11 278.33,27.99 278.33,26.09 279.15,25.26 v1(279.15,19.87) 279.15,19.29 284.26,14.19 284.26,10.63 285.63,9.25 v2(287.02,9.25)
  IN6 w0.102: v2(303.36,7.65) 303.21,7.5 301.76,7.5 300.07,9.19 287.08,9.19 v2(287.02,9.25)
CDR_BTN#: length 322.4
  TOP w0.107: UE5.120 306.19,20.81 305.5,20.13 304.97,20.13 303.01,18.17 v2(302.65,18.17)
  IN4 w0.089: 200.57,41.96 199.07,41.96 198.36,42.66 198.36,43.89 197.94,44.32
  IN4 w0.102: v2(297.95,30.78) 297.36,30.18 284.15,30.18 283.74,30.6 276.29,30.6 275.27,29.58 269.54,29.58 265.84,25.89 265,25.89 264.69,25.58 261.94,25.58 260.35,23.99 258.03,23.99 256.86,25.17 256.86,25.19 255.76,26.29 247.61,26.29 246.52,27.38 243.31,27.38 242.64,28.04 242.64,29.65 240.61,31.68 240.61,34.83 237.97,37.47 236.32,37.47 234.97,38.81 233.43,38.81 231.67,40.58 230.35,40.58 229.61,39.84 227.57,39.84 227.19,39.46 223.94,39.46 222.87,40.53 219.61,40.53 219.38,40.29 219.38,40.22 218.75,39.6 218.75,39.4 218.54,39.18 218.33,39.18 217.99,38.83 215.86,38.83 214.77,39.93 213.96,39.93 213.57,40.32 210.83,40.32 210.03,41.13 204.69,41.13 204.45,41.37 203.24,41.37 202.98,41.62 200.91,41.62 200.57,41.96 ; 197.94,44.32 197.94,49.66 192.6,54.99 187.08,54.99 186.5,55.57 186.5,55.81 186.49,55.83 186.11,56.2 186.11,56.76 185.39,57.48 185.39,62.44 184.98,62.85 184.98,63.21 185.9,64.13 185.9,65.33 186.13,65.56 186.13,69.21 186.86,69.94 186.86,76.58 186.15,77.3 186.15,83.5 186.97,84.32 186.97,94.43 183.9,97.49 183.9,103.83 183.63,104.11 183.63,105.43 184.27,106.08 184.27,109.06 185.13,109.92 185.13,111.58 185.4,111.85 185.4,117.61 186.58,118.79 186.58,121.18 192.41,127.01 192.41,127.61 193.23,128.42 193.23,129.03 193.23,129.24 193.88,129.9 193.88,146.82 189.72,150.99 189.4,150.99 185.59,154.79 185.29,154.79 184.86,155.22 182,155.22 180.66,156.56 176.99,156.56 176.36,157.18 172.5,157.18 171.86,156.54 169.72,156.54 169.3,156.96 169.3,157.18 166.62,159.85 166.62,160.49 167.47,161.34 167.47,167.74 166.85,168.37 164.69,168.37 162.64,170.42 162.64,172.85 163.25,173.46 163.25,174.22 v2(164.15,175.11)
  BOTTOM w0.102: v2(302.65,18.17) 303.26,17.56 303.26,16.08 302.75,15.57 299.04,15.57 298.45,16.17 298.45,16.17 298.08,16.54 297.14,17.48 297.14,23.23 297.76,23.85 297.76,29.33 297.95,29.52 v1(297.95,30.01) v2(297.95,30.78)
  BOTTOM w0.107: v2(164.15,175.11) 164.15,175.51 163.37,176.29 RM17.2 163.14,177.48 162.62,177.99 JCDRA.26
CDR_ON_ELC: length 335.9
  TOP w0.102: v2(318.46,15.23) 318.52,15.29 318.52,15.36 319.75,16.58 UE1.21
  IN4 w0.102: v2(150.74,173.64) 151.46,172.93 151.46,169.28 151.75,168.98 151.75,163.82 152.48,163.09 155.01,163.09 155.83,162.28 157.79,162.28 158.48,162.97 160.3,162.97 160.63,162.64 161.63,162.64 162.09,163.09 162.96,163.09 164.79,161.26 164.79,156.98 165.69,156.08 167.59,156.08 168.96,154.71 171.21,154.71 171.74,154.18 171.88,154.04 172.98,154.04 175.14,151.88 185.91,151.88 188.64,149.16 188.96,149.16 190.99,147.13 190.99,143.38 190.81,143.2 190.81,138.73 191.27,138.28 191.27,129.05 190.59,128.37 190.59,127.77 183.57,120.76 183.57,117.85 182.18,116.45 182.18,113.44 182.34,113.27 182.76,112.85 182.76,110.22 182.27,109.72 182.27,108.6 181.15,107.48 181.15,97.66 181.54,97.26 181.71,97.1 184.95,93.86 184.95,90.07 184.13,89.26 184.13,84.42 183.88,84.17 183.88,76.47 184.4,75.95 184.4,71.69 184.27,71.56 183.11,70.41 183.11,69.12 183.41,68.83 183.41,64.64 182.81,64.04 182.81,62.43 183.56,61.68 183.56,56.72 183.98,56.3 183.98,55.35 184.13,55.2 184.13,53.74 184.68,53.2 184.68,52.94 186.55,51.07 186.55,46.07 190.73,41.89 194.06,41.89 194.52,41.43 197.15,41.43 198.31,40.28 199.87,40.28 200.21,39.93 202.07,39.93 202.45,39.55 202.45,38.6 203.84,37.2 205.67,37.2 206.75,36.12 206.76,36.12 207.46,35.42 207.67,35.42 208.29,34.8 208.29,34.36 208.81,33.84 211.73,33.84 212.99,35.09 213.47,35.09 213.78,35.41 216.29,35.41 216.7,35 218.22,35 218.53,35 218.93,34.61 219.1,34.61 220.16,33.54 221.75,33.54 222.96,34.75 223.37,34.75 224.72,36.1 226.66,36.1 226.76,36.2 229.53,36.2 230.21,35.52 230.21,35.3 230.56,34.94 230.56,34.69 231.19,34.06 231.45,33.8 231.45,33.52 232.02,32.95 232.39,32.58 232.39,27.04 234.97,24.46 235.58,24.46 237.31,22.74 239.03,22.74 240.6,24.31 245.28,24.31 246.35,23.24 246.54,23.24 246.92,23.24 250.89,19.27 253.99,19.27 254.48,19.76 256.94,19.76 257.96,20.78 264.5,20.78 265.32,21.61 265.61,21.61 265.8,21.61 266.25,22.05 266.26,22.05 266.5,22.28 268.98,22.28 270.32,23.63 280.25,23.63 281.64,22.24 292.48,22.24 293.99,20.73 296.4,20.73 297.16,21.49 300.08,21.49 301.63,23.04 306.59,23.04 309.7,19.93 309.7,18.32 309.8,18.22 311.54,18.22 313.57,16.18 317.95,16.18 318.46,15.68 v2(318.46,15.23)
  BOTTOM w0.102: v1(151.61,173.61) 151.58,173.64 v2(150.74,173.64)
  BOTTOM w0.107: v2(150.74,173.64) 150.74,174.19 UM7.4
CDR_TXRX_GOOD: length 367.8
  TOP w0.102: v1(329.39,48.16) 329.39,47.84 329.8,47.43 329.89,47.43 v2(329.89,47.41) 329.89,47.34 330.04,47.19 UE6.18
  IN4 w0.102: v2(150.73,178.33) 153.47,175.59 153.47,166.33 154.52,165.28 157.72,165.28 159.37,166.93 159.88,166.93 160.82,167.87 162.82,167.87 164.6,166.09 164.6,162.42 165.48,161.54 165.48,159.38 168.15,156.7 168.15,156.49 169.25,155.4 171.49,155.4 172.16,154.73 180.87,154.73 181.39,154.21 181.52,154.08 184.38,154.08 184.81,153.65 185.12,153.65 188.92,149.84 189.25,149.84 191.68,147.41 191.68,143.09 191.5,142.92 191.5,139.02 191.96,138.56 191.96,128.77 191.27,128.08 191.27,127.49 184.26,120.48 184.26,116.87 183.27,115.88 183.27,113.32 183.45,113.14 183.45,109.93 182.95,109.44 182.95,108.32 181.83,107.2 181.83,97.94 185.82,93.95 185.82,89.27 185.3,88.75 185.3,84.62 184.57,83.89 184.57,76.75 185.09,76.23 185.09,71.41 183.8,70.12 183.8,69.4 184.1,69.11 184.1,64.35 183.65,63.91 183.65,62.57 183.71,62.51 184.1,62.12 184.1,62.12 184.25,61.97 184.25,57 184.67,56.59 184.67,56.03 185.36,55.34 185.36,54.98 186.7,53.64 186.7,53.06 187.41,52.35 187.41,46.18 190.28,43.31 194.01,43.31 195.02,42.31 195.02,42.3 195.13,42.19 197.2,42.19 198.54,40.85 200.1,40.85 200.45,40.5 202.52,40.5 202.77,40.25 203.99,40.25 204.22,40.01 209.55,40.01 210.64,38.92 210.64,37.8 212.57,35.87 213.44,35.87 213.55,35.98 214.13,35.98 214.4,36.25 219.14,36.25 219.95,35.44 223.09,35.44 224.43,36.78 226.37,36.78 226.5,36.91 231.48,36.91 232.14,36.25 232.14,33.81 232.31,33.64 233.11,32.83 233.11,32.79 234.32,31.59 234.32,28.79 235.35,27.76 235.35,27.22 236.43,26.14 236.7,25.87 236.7,25.66 237.58,24.78 238.82,24.78 239.03,25 239.6,25 239.6,25 239.98,25 245.56,25 246.63,23.93 246.82,23.93 247.2,23.93 247.47,23.66 251.18,19.96 253.7,19.96 255.38,21.63 257.84,21.63 258,21.47 264.21,21.47 265.15,22.41 265.63,22.41 265.96,22.74 265.98,22.74 266.26,23.01 268.56,23.01 269.86,24.31 270.04,24.31 282.48,24.31 283.18,25.01 284.74,25.01 285.06,24.69 286.65,24.69 287.09,25.14 288.46,25.14 288.63,25.3 288.63,25.84 288.9,26.11 292.85,26.11 293.82,25.14 305.78,25.14 309.08,28.44 318.16,28.44 320.51,30.79 327.01,30.79 328.75,32.53 331.69,32.53 335.35,36.19 335.35,44.46 332.85,46.96 330.27,46.96 329.89,47.34 v2(329.89,47.41)
  BOTTOM w0.107: UM7.1 149.61,177.22 v2(150.73,178.33)
CDRA_CLK: length 366
  TOP w0.114: v2(284.26,6.87) 283.85,7.28 283.85,8.28 284.37,8.8 v1(284.62,8.8) 285.33,8.8 RE670.2
  IN3 w0.127: v2(226.46,165.61) 226.3,165.45 224.16,165.45 221.83,167.78 208.39,167.78 206.21,169.96 206.21,170.11 206.21,170.32 204.94,171.59 203.85,171.59 203.68,171.77 203.46,171.77 201.62,173.6 199.15,173.6 197.89,174.86 196.27,174.86 195.54,174.12 191.93,174.12 190.06,175.99 188.39,175.99 188.16,175.76 185.75,175.76 183.74,177.77 179.37,177.77 178.88,177.28 175.73,177.28 174.75,178.26 172.61,178.26 171.99,178.88 171.12,178.88 170.73,178.5 170.73,178.02 v2(170.58,177.87)
  IN6 w0.081: v2(284.26,6.87) 284.48,6.64 284.47,6.52 284.47,6.43 284.73,6.17 286.87,6.17 287.47,6.77 293.59,6.77 294.18,6.18 316.59,6.18 319.79,9.37 323.58,9.37 324.07,8.88 326.59,8.88 334.71,17 334.71,36.05 335.15,36.49 335.15,44.84 332.77,47.23 332.77,48.12 331.88,49 329.52,49 326.5,52.03 322.79,52.03 321.31,53.51 321.31,59.16 318.76,61.7 314.17,61.7 313.42,60.95 301.05,60.95 300.11,61.9 298.14,61.9 297.44,62.59 297.44,64.54 297.9,65 297.9,70.61 294.91,73.6 294.91,81.61 290.53,85.99 289.25,85.99 288.13,87.11 288.13,129.83 285.42,132.54 285.42,145.47 282.11,148.78 278.25,148.78 276.21,150.82 274.29,150.82 272.25,148.78 267.91,148.78 265.82,150.86 265.82,152.62 264.19,154.25 257.49,154.25 255.98,155.76 253.17,155.76 252.3,156.62 246.56,156.62 245.09,158.1 245.09,159.55 240.71,163.93 238.09,163.93 237.56,163.41 233.02,163.41 232.56,162.95 228.75,162.95 227.22,164.48 227.22,165.22 227,165.45 226.63,165.45 v2(226.46,165.61)
  BOTTOM w0.114: v2(226.46,165.61) 226.28,165.43 226.06,165.43 225.68,165.04 225.68,164.26 RM1.1 ; JCDRA.45 170.47,178.46 170.74,178.19 170.74,178.02 v2(170.58,177.87)
CDRA_DAT: length 361.4
  TOP w0.114: v2(284.87,7.03) 285,6.9 RE671.2
  IN3 w0.127: v2(226.46,165.03) 226.3,165.19 224.06,165.19 221.73,167.52 208.28,167.52 205.95,169.85 205.95,170.22 204.83,171.34 203.75,171.34 203.57,171.51 203.35,171.51 201.52,173.35 199.04,173.35 197.79,174.6 196.38,174.6 195.64,173.87 191.83,173.87 189.96,175.74 188.5,175.74 188.26,175.5 185.64,175.5 183.63,177.51 179.47,177.51 178.99,177.03 175.62,177.03 174.65,178.01 172.51,178.01 171.89,178.63 171.22,178.63 170.99,178.4 170.99,178.04 v2(171.17,177.87)
  IN6 w0.081: v2(284.87,7.03) 284.86,6.79 284.69,6.63 284.68,6.52 284.82,6.38 286.79,6.38 287.38,6.98 293.67,6.98 294.27,6.38 316.51,6.38 319.7,9.58 323.67,9.58 324.16,9.09 326.51,9.09 334.5,17.08 334.5,36.13 334.95,36.58 334.95,44.76 332.56,47.15 332.56,48.03 331.8,48.8 329.43,48.8 326.41,51.82 322.7,51.82 321.1,53.42 321.1,59.07 318.68,61.5 314.26,61.5 313.5,60.74 300.97,60.74 300.02,61.69 298.05,61.69 297.23,62.51 297.23,64.63 297.69,65.09 297.69,70.52 294.7,73.51 294.7,81.52 290.45,85.78 289.16,85.78 287.92,87.02 287.92,129.75 285.21,132.45 285.21,145.38 282.03,148.57 278.17,148.57 276.13,150.61 274.38,150.61 272.34,148.57 267.83,148.57 265.62,150.78 265.62,152.53 264.11,154.04 257.4,154.04 255.89,155.55 253.08,155.55 252.22,156.42 246.48,156.42 244.88,158.02 244.88,159.46 240.62,163.72 238.17,163.72 237.65,163.2 233.1,163.2 232.65,162.74 228.66,162.74 227.01,164.39 227.01,165.14 226.91,165.24 226.67,165.24 v2(226.46,165.03)
  BOTTOM w0.114: v2(226.46,165.03) 226.3,165.19 226.16,165.19 225.92,164.94 225.92,164.2 RM2.1 ; v2(171.17,177.87) 171,178.03 171,178.19 171.27,178.46 JCDRA.46
CDRA_LED RED: length 21.2
  IN3 w0.508: v2(164.06,177.05) 163.38,177.05 162.78,176.46 161.43,176.46 161.15,176.18 161.08,176.18 160.56,175.66 160.56,174.39 160.09,173.92 160.09,172.61 v2(158.71,171.22)
  IN4 w0.508: v2(155.11,166.11) 156.38,166.11 159.5,169.22 159.5,170.44 v2(158.71,171.22)
  BOTTOM w0.203: JCDRA.28 163.42,178.65 163.49,178.58 163.49,178.57 163.69,178.37 163.69,177.42 v2(164.06,177.05)
  BOTTOM w0.508: QM3.1 154.97,166.11 v2(155.11,166.11)
CDRA_LED RED_MOS: length 313.9
  TOP w0.107: v2(305.05,22.03) 306.24,23.21 UE5.126
  IN4 w0.089: 199.71,39.9 198.1,39.9 197.02,40.97 194.32,40.97
  IN4 w0.102: v2(149.3,165.09) 149.08,164.87 149.08,164.11 150.2,163 151.93,163 152.29,162.64 154.82,162.64 156.35,161.12 158.09,161.12 158.46,161.49 162.06,161.49 162.09,161.46 163.2,161.46 164.33,160.33 164.33,156.79 165.5,155.62 167.4,155.62 168.77,154.25 171.02,154.25 173.86,151.41 185.74,151.41 188.45,148.7 188.77,148.7 190.53,146.94 190.53,143.57 190.36,143.39 190.36,138.54 190.81,138.09 190.81,129.24 190.13,128.56 190.13,127.96 183.12,120.95 183.12,118.04 181.72,116.64 181.72,113.25 182.3,112.66 182.3,110.41 181.81,109.91 181.81,108.79 180.69,107.67 180.69,95.88 178.32,93.51 178.32,88.18 178.49,88 182.51,83.98 182.51,77.19 183.94,75.76 183.94,71.88 182.66,70.6 182.66,70.54 181.93,69.82 181.93,69.43 181.93,66.72 181.94,66.71 181.94,60.96 182.29,60.6 182.29,57.34 183.27,56.37 183.27,53.58 185.91,50.94 185.91,46.06 186.1,45.87 190.54,41.43 193.86,41.43 194.32,40.97 ; 199.71,39.9 201.18,38.43 201.18,37.77 201.65,37.3 201.65,36.53 201.94,36.25 201.94,34.41 202.19,34.15 205.72,34.15 206.04,33.83 206.71,33.83 207.48,33.06 208,33.06 208.44,32.63 212.15,32.63 212.82,33.3 213.17,33.3 213.52,33.65 217.32,33.65 217.66,33.99 218.19,33.99 218.37,34.17 218.89,34.17 219.97,33.09 221.94,33.09 222.08,33.22 223.15,34.29 225.5,34.29 226.95,35.74 229.34,35.74 229.75,35.33 229.75,35.11 230.11,34.76 230.11,34.5 231,33.61 231,33.33 231.8,32.53 231.94,32.39 231.94,26.39 232.62,25.71 232.62,25.1 233.71,24.01 235.39,24.01 237.12,22.28 240.61,22.28 241.28,21.61 241.28,21.49 241.28,21.06 243.58,18.76 245.39,18.76 246.34,19.71 249.8,19.71 250.7,18.81 254.18,18.81 254.67,19.31 257.13,19.31 258.15,20.32 264.79,20.32 265.51,21.04 266.52,21.04 266.71,21.04 267.35,21.68 272.63,21.68 272.79,21.52 292.56,21.52 293.8,20.27 296.59,20.27 297.35,21.03 300.65,21.03 302.2,22.58 304.49,22.58 v2(305.05,22.03)
  BOTTOM w0.107: QM2.5 149.95,167.57 150.06,167.46 150.06,165.52 149.78,165.24 149.45,165.24 v2(149.3,165.09)
CDRA_LED RED_R: length 4.3
  BOTTOM w0.508: RM93.2 152.87,165.48 153.36,165.98 153.36,166.01 153.88,166.53 153.91,166.53 154.06,166.68 154.49,166.68 155.22,167.4 QM3.3
CDRA_LED WHITE: length 35.1
  IN3 w0.508: v2(144.51,165.62) 145.27,165.62 145.6,165.96 145.6,166.65 145.94,166.99 145.94,169.2 148.95,172.21 148.95,175.44 149.64,176.13 149.64,178.26 150.5,179.12 162.24,179.12 v2(163.24,178.13)
  BOTTOM w0.102: QM1.1 142.97,166.6 142.34,167.24 v1(142.34,168.19)
  BOTTOM w0.203: v2(163.24,178.13) 163.02,178.35 JCDRA.27
  BOTTOM w0.508: v2(144.51,165.62) 144.51,166.09 144,166.6 QM1.1
CDRA_LED WHITE_MOS: length 301.7
  TOP w0.102: UE5.21 297.54,24.16 296.83,23.45 296.83,22.05 296.43,21.64 v2(296.43,21.61)
  IN4 w0.102: v2(152.31,167.43) 152.31,167.11 152.07,166.87 152.07,164.04 152.78,163.32 155.11,163.32 155.92,162.51 157.7,162.51 158.38,163.2 160.4,163.2 160.73,162.87 161.53,162.87 161.99,163.32 163.05,163.32 165.02,161.35 165.02,157.08 165.79,156.31 167.68,156.31 169.06,154.94 171.3,154.94 171.97,154.27 175.87,154.27 178.02,152.11 186.01,152.11 188.73,149.39 189.06,149.39 191.22,147.22 191.22,143.28 191.04,143.11 191.04,138.83 191.5,138.37 191.5,128.96 190.81,128.27 190.81,127.68 183.8,120.67 183.8,117.75 182.41,116.35 182.41,113.53 182.99,112.95 182.99,110.12 182.5,109.63 182.5,108.51 181.38,107.39 181.38,97.75 181.64,97.49 181.8,97.33 185.18,93.95 185.18,93.76 185.17,89.98 184.36,89.16 184.36,84.33 184.11,84.08 184.11,76.56 184.63,76.04 184.63,71.6 183.34,70.31 183.34,69.22 183.64,68.92 183.64,64.54 183.04,63.94 183.04,62.53 183.07,62.51 183.07,62.5 183.79,61.78 183.79,56.81 184.21,56.4 184.21,55.84 184.9,55.15 184.9,54.49 186.24,53.15 186.24,52.87 186.88,52.23 186.88,46.06 190.82,42.12 194.16,42.12 194.61,41.66 197.2,41.66 198.39,40.47 199.95,40.47 200.29,40.12 202.36,40.12 203.53,38.95 203.53,38.71 204.69,37.54 205.6,37.54 206.83,36.31 207.91,36.31 208.68,35.54 209.75,35.54 209.81,35.48 211.97,35.48 212.16,35.29 213.39,35.29 213.7,35.6 214.29,35.6 214.56,35.87 218.78,35.87 219.52,35.13 219.52,34.55 220.29,33.77 221.66,33.77 222.87,34.98 223.28,34.98 224.62,36.33 226.56,36.33 226.66,36.43 229.75,36.43 230.44,35.74 230.44,35.39 230.68,35.16 231.01,35.16 231.14,35.28 231.36,35.28 231.68,34.96 231.68,33.62 232.12,33.18 232.65,32.64 232.65,32.61 233.46,31.8 233.46,26.3 235.06,24.69 235.68,24.69 236.12,24.25 240.1,24.25 240.39,24.54 245.37,24.54 246.44,23.47 247.01,23.47 250.99,19.5 253.89,19.5 254.39,19.99 256.84,19.99 257.86,21.01 264.4,21.01 265.23,21.83 265.71,21.83 266.15,22.28 266.17,22.28 266.4,22.51 268.88,22.51 270.23,23.85 280.35,23.85 281.73,22.47 285.31,22.47 286.39,23.55 290.98,23.55 292.06,22.47 292.57,22.47 294.03,21.01 295.83,21.01 v2(296.43,21.61)
  BOTTOM w0.107: QM2.2 151.59,167.43 v2(152.31,167.43)
CDRA_LED WHITE_R: length 5.3
  BOTTOM w0.102: v1(142.79,164.96) 144.95,164.96 145.63,165.64 QM1.3
  BOTTOM w0.508: QM1.3 146.34,165.03 147.3,165.03 RM91.2
CDRA_RST#: length 3.7
  BOTTOM w0.114: UM3.4 159.82,176.44 v1(160.71,177.33) 161.02,177.64 JCDRA.22
CFG0: length 94.2
  TOP w0.114: v2(123.09,159.71) 123.09,159.35 JPCMC.1
  IN6 w0.081: v2(134.63,113.25) 134.63,113.2 133.79,112.36 133.22,112.36 131.96,111.1 131.96,109.57 131.73,109.35 131.4,109.35 129.83,107.78 129.83,105.4 128.86,104.43 128.86,102.8 128.39,102.32 128.39,100.8 126.34,98.75 118.28,98.75 115.4,101.63 115.4,124.87 115.43,124.9 115.43,141.11 115.57,141.26 115.8,141.48 115.8,143.33 115.3,143.83 115.3,150.04 117.82,152.56 117.82,153.25 118.18,153.61 119.32,153.61 122.24,156.53 122.24,157.36 122.85,157.98 122.85,159.47 v2(123.09,159.71)
  BOTTOM w0.076: v2(134.63,113.25) 134.31,112.93 UC1.BN25
CFG1: length 53.9
  TOP w0.089: v2(134.63,114.83) 134.61,114.83 134.02,115.42 v1(133.75,115.42)
  TOP w0.114: JPCMC.3 123.01,158.21 123.18,158.21 123.99,157.4 123.99,153.25 v2(121.8,151.06)
  IN6 w0.081: 132.86,116.6 v2(134.63,114.83) ; 129.44,118.59 127.45,120.58 127.45,124.04 127.45,124.79 121.14,131.09 121.14,133.15 120.66,133.63 120.66,136.23 120.95,136.52 120.95,139.28 120.63,139.59 120.63,146.29 120.64,146.3 120.64,146.41 121.06,146.83 121.06,149.75 121.8,150.5 v2(121.8,151.06)
  IN6 w0.089: 129.44,118.59 130.06,117.97 131.49,117.97 132.86,116.6
  BOTTOM w0.076: UC1.BN27 134.31,114.5 v2(134.63,114.83)
CFG2: length 86.4
  TOP w0.089: v1(132.86,112.89) 133.81,112.89 133.98,113.06 v2(133.98,113.25) 133.68,113.55 133.68,113.6 133.33,113.95 RH184.1
  TOP w0.114: v2(123.58,156.79) 123.43,156.79 123.19,157.03 123.15,157.03 JPCMC.5
  IN6 w0.081: v2(123.58,156.79) 123.58,156.14 117.7,150.26 117.7,148.95 117.23,148.47 117.23,144.63 117.5,144.36 117.73,144.13 117.73,140.53 117.36,140.16 117.36,124.1 117.33,124.07 117.33,102.43 119.08,100.68 122.31,100.68 127.06,105.43 127.06,107.69 128.6,109.23 128.6,111.24 130.21,112.86 133.58,112.86 v2(133.98,113.25)
  BOTTOM w0.076: UC1.BN26 134.31,113.58 v2(133.98,113.25)
CFG3: length 63.9
  TOP w0.114: v2(115.84,153.67) 115.84,158.87 116.59,159.62 JPCMC.23 ; v2(120.85,150.74) 121.17,151.06 121.17,151.07 122.7,152.6 122.7,156.25 122.42,156.53 JPCMC.7
  IN6 w0.081: v2(133.98,114.83) 133.98,114.93 132.08,116.83 130.58,116.83 127.06,120.35 127.06,124.63 120.01,131.68 120.01,133.49 120.15,133.63 120.15,137.43 119.58,138 119.58,143.85 119.89,144.16 119.89,146.09 120.25,146.46 120.25,148.5 120.11,148.64 120.11,150.05 120.8,150.74 v2(120.85,150.74)
  BOTTOM w0.076: UC1.BN28 134.31,115.15 v2(133.98,114.83)
  BOTTOM w0.114: v2(115.84,153.67) 117.77,151.74 v1(119.19,151.74) 119.6,151.74 120.51,150.83 120.76,150.83 v2(120.85,150.74)
CFG4: length 90.3
  TOP w0.114: JPCMC.9 121.86,155.87 121.86,153.19 118.87,150.2 115.75,150.2 115.57,150.02 v2(114.51,150.02)
  IN6 w0.081: 129.44,102.29 129.16,102 129.16,100.48 126.02,97.34 118.6,97.34 114.51,101.42 v2(114.51,150.02) ; v2(131.2,108.07) 131.14,108.07 130.53,107.46 130.53,104.76 130.1,104.33
  IN6 w0.089: 130.1,104.33 129.93,104.16 129.93,102.77 129.44,102.29
  BOTTOM w0.076: UC1.BR20 133.01,108.64 132.91,108.55 132.2,108.55 132.01,108.74 131.87,108.74 v2(131.2,108.07)
  BOTTOM w0.114: RH185.1 130.72,108.07 v2(131.2,108.07)
CFG5: length 85.2
  TOP w0.107: v2(134.63,108.53) 134.63,107.72 RH186.1
  TOP w0.114: v2(115.69,151.17) 115.77,151.25 118.74,151.25 121.02,153.54 121.02,155.39 JPCMC.11
  IN1 w0.081: v2(115.69,151.17) 115.69,150.79 115.7,150.78 115.7,150.45 115.49,150.24 115.49,143.03 115.97,142.55 115.97,134.39 115.4,133.82 115.4,101.32 117.4,99.32 125.93,99.32 130.5,103.89 130.5,104.77 130.87,105.14 132.4,105.14 134.63,107.37 v2(134.63,108.53)
  BOTTOM w0.114: UC1.BM20 134.96,108.86 v2(134.63,108.53)
CFG6: length 88.5
  TOP w0.114: JPCMC.13 120.19,155.16 120.19,153.89 118.39,152.09 116.24,152.09 115.28,153.05 v2(114.54,153.05)
  IN6 w0.081: v2(131.2,108.64) 130.15,107.59 130.15,104.93 129.52,104.3 129.52,102.91 128.78,102.16 128.78,100.64 125.86,97.73 118.76,97.73 115.01,101.47 115.01,125.03 115.04,125.06 115.04,141.27 115.41,141.64 115.41,143.17 114.91,143.67 114.91,152.68 v2(114.54,153.05)
  BOTTOM w0.076: v2(131.2,108.64) 131.48,108.92 UC1.BT20
  BOTTOM w0.114: v2(131.2,108.64) 130.34,108.64 RH187.1
CFG7: length 83.4
  TOP w0.114: JPCMC.15 119.35,155.17 119.35,154.23 118.21,153.1 v2(118.21,153.09)
  IN6 w0.081: v2(118.21,153.09) 118.21,153.08 118.23,153.07 118.23,152.43 115.68,149.88 115.68,143.99 116.18,143.49 116.18,141.25 115.81,140.88 115.81,124.74 115.78,124.71 115.78,101.79 118.44,99.13 126.18,99.13 127.95,100.91 127.95,104.07 129.45,105.56 129.45,107.9 v2(131.01,109.46)
  BOTTOM w0.076: UC1.BP20 133.36,109.22 133.13,109.22 132.93,109.42 132.1,109.42 131.98,109.29 131.5,109.29 131.33,109.46 v2(131.01,109.46)
  BOTTOM w0.114: RH188.1 130.21,109.46 v2(131.01,109.46)
CFG8: length 86
  TOP w0.114: v2(123.25,158.73) 123.25,158.73 123.18,158.66 JPCMC.2
  IN6 w0.081: v2(123.25,158.73) 123.25,157.83 122.62,157.2 122.62,156.28 116.93,150.58 116.93,149.27 116.45,148.79 116.45,144.31 116.96,143.81 116.96,140.85 116.58,140.48 116.58,124.42 116.56,124.39 116.56,102.11 118.76,99.91 124.56,99.91 127.01,102.35 127.01,104.29 128.68,105.95 128.68,108.22 130.96,110.5 v2(130.96,110.85)
  BOTTOM w0.076: UC1.BR23 132.61,111.68 131.03,111.68 130.96,111.6 v2(130.96,110.85)
CFG9: length 81.7
  TOP w0.114: v2(123.39,157.41) 123.01,157.79 122.65,157.79 JPCMC.4
  IN1 w0.081: v2(133.32,110.15) 133.28,110.15 132.62,109.48 132.62,106.88 131.61,105.88 129.72,105.88 127.43,103.58 126.53,103.58 126.19,103.24 125.96,103.02 118.07,103.02 116.94,104.14 116.94,133.18 117.51,133.75 117.51,143.19 117.03,143.67 117.03,147.58 117.7,148.25 117.7,152.25 117.47,152.48 117.02,152.92 117.02,154.45 117.37,154.79 118.36,154.79 118.6,155.03 119.93,155.03 122.31,157.41 v2(123.39,157.41)
  BOTTOM w0.114: v2(133.32,110.15) 133.01,110.46 UC1.BR22
CFG10: length 81.1
  TOP w0.114: v2(123.02,156.62) 122.93,156.62 122.43,157.11 JPCMC.6
  IN6 w0.081: v2(131.31,111.32) 129.92,111.32 129.79,111.19 129.79,109.88 127.44,107.53 127.44,105.27 122.47,100.29 118.92,100.29 116.94,102.27 116.94,124.23 116.97,124.26 116.97,140.32 117.34,140.69 117.34,143.97 116.84,144.47 116.84,148.63 117.31,149.11 117.31,150.42 123.02,156.13 v2(123.02,156.62)
  BOTTOM w0.114: v2(131.31,111.32) 132.32,111.32 UC1.BT23
CFG11: length 83.8
  TOP w0.114: v2(116.53,149.43) 118.7,149.43 122.28,153.02 122.28,156.06 JPCMC.8
  IN6 w0.081: v2(131.44,110.33) 131.33,110.33 129.06,108.06 129.06,105.79 127.57,104.3 127.57,101.07 126.02,99.52 118.6,99.52 116.17,101.95 116.17,124.55 116.2,124.58 116.2,140.72 116.57,141.09 116.57,143.65 116.07,144.15 116.07,148.97 v2(116.53,149.43)
  BOTTOM w0.089: v2(131.44,110.33) 132.18,110.33 UC1.BT22
CFG12: length 87
  TOP w0.114: v2(115.31,150.61) 115.31,150.62 118.7,150.62 121.44,153.36 121.44,155.74 121.28,155.9 JPCMC.10
  IN1 w0.081: v2(135.28,108.53) 135.28,107.64 132.59,104.95 131,104.95 130.89,104.83 130.89,103.73 126.09,98.94 117.56,98.94 116.9,98.94 115.05,100.79 115.05,101.13 115.01,101.16 115.01,133.98 115.58,134.55 115.58,142.39 115.1,142.87 115.1,150.41 v2(115.31,150.61)
  BOTTOM w0.114: v2(135.28,108.53) 134.96,108.21 UC1.BM19
CFG13: length 88.3
  TOP w0.114: JPCMC.12 120.55,155.48 120.61,155.43 120.61,153.71 118.57,151.67 114.51,151.67 v2(114.47,151.7)
  IN6 w0.081: v2(114.47,151.7) 114.12,151.35 114.12,101.27 118.44,96.96 126.18,96.96 129.55,100.32 129.55,101.66 ; v2(130.95,107.35) 130.89,107.3 130.89,104.59 130.6,104.29
  IN6 w0.089: 129.55,101.66 129.55,101.76 130.31,102.52 130.31,104 130.6,104.29
  BOTTOM w0.076: v2(130.95,107.35) 131.34,107.74 132,107.74 132.1,107.64 132.63,107.64 133.01,108.01 UC1.BR19
CFG14: length 82.4
  TOP w0.114: v2(115.84,153.09) 116.41,152.51 118.22,152.51 119.77,154.06 119.77,155.51 JPCMC.14
  IN1 w0.081: v2(133.35,108.49) 133.35,108.49 133.35,106.54 132.14,105.32 130.74,105.32 130.12,104.7 130.12,104.06 125.79,99.73 117.56,99.73 115.78,101.5 115.78,133.66 116.35,134.23 116.35,142.71 115.87,143.19 115.87,150.08 116.09,150.29 116.09,150.94 116.08,150.95 116.08,151 116.09,151.01 116.09,151.34 116.08,151.35 116.08,151.79 115.84,152.03 v2(115.84,153.09)
  BOTTOM w0.114: v2(133.35,108.49) 133.35,108.49 133.35,108.49 133.36,108.49 133.66,108.19 UC1.BP19
CFG15: length 70.9
  TOP w0.114: JPCMC.16 118.99,155.38 118.9,155.29 v2(118.9,154.63)
  IN1 w0.081: v2(131.83,108.1) 131.89,108.04 131.89,107.11 131.7,106.92 129.99,106.92 129.68,107.24 128.55,107.24 125.48,104.17 118.55,104.17 118.17,104.54 118.17,114.51 120.01,116.34 120.01,119.21 118.1,121.12 118.1,132.7 118.67,133.27 118.67,135.19 118.67,143.66 118.86,143.84 118.86,145.61 118.19,146.27 118.19,147.1 118.86,147.77 118.86,149.6 119.24,149.99 119.47,150.21 119.47,153.01 118.9,153.58 v2(118.9,154.63)
  BOTTOM w0.089: UC1.BT19 131.87,108.14 v2(131.83,108.1)
CFG16: length 78.1
  TOP w0.114: JPCMC.21 116.49,155.95 116.49,155.44 v2(117.54,154.4)
  IN1 w0.081: v2(133.33,111.68) 132.25,110.59 132.25,107.14 131.58,106.48 130.95,106.48 130.76,106.67 129.74,106.67 129.61,106.8 128.66,106.8 126.28,104.42 125.64,103.79 118.39,103.79 117.72,104.46 117.72,114.64 117.8,114.72 117.84,114.72 119.62,116.5 119.62,119.05 117.72,120.96 117.72,132.86 118.29,133.43 118.29,135.03 118.29,143.82 118.47,144 118.47,145.45 117.8,146.11 117.8,147.26 118.47,147.93 118.47,149.76 119.08,150.37 119.08,152.85 v2(117.54,154.4)
  BOTTOM w0.114: UC1.BP23 133.66,111.35 v2(133.33,111.68)
CFG17: length 75.7
  TOP w0.114: v2(117.42,153.09) 118.48,154.15 118.48,155.43 JPCMC.17
  IN1 w0.081: v2(117.42,153.09) 117.41,153.08 117.86,152.64 118.09,152.41 118.09,148.09 117.42,147.42 117.42,143.83 117.9,143.35 117.9,134.87 117.9,133.59 117.33,133.02 117.33,104.3 118.23,103.4 125.8,103.4 126.44,104.04 128.8,106.4 130.17,106.4 130.51,106.06 131.48,106.06 132.43,107.01 132.43,110.11 133.98,111.66 v2(133.98,111.68)
  BOTTOM w0.114: UC1.BN23 134.31,111.35 v2(133.98,111.68)
CFG18: length 81.5
  TOP w0.114: JPCMC.20 117.6,156.46 116.91,155.77 v2(116.91,155.63)
  IN1 w0.081: v2(116.91,155.63) 116.23,154.95 116.23,152.45 116.93,151.75 116.93,148.57 116.26,147.9 116.26,143.35 116.74,142.87 116.74,134.07 116.17,133.5 116.17,101.69 117.73,100.13 125.06,100.13 130.13,105.2 130.23,105.2 130.54,105.51 131.88,105.51 132.99,106.62 132.99,108.8 133.85,109.66 134.24,109.66 v2(134.68,110.1)
  BOTTOM w0.114: UC1.BN22 134.68,110.13 v2(134.68,110.1)
CFG19: length 80.3
  TOP w0.114: JPCMC.18 118.26,155.8 118.06,155.6 118.06,154.32 117.72,153.98 116.79,153.98 v2(116.63,154.14)
  IN1 w0.081: v2(133.96,110.14) 132.8,108.98 132.8,106.75 131.75,105.69 130.41,105.69 130.32,105.6 129.99,105.6 124.92,100.53 117.9,100.53 116.56,101.87 116.56,133.34 117.13,133.91 117.13,143.03 116.9,143.26 116.65,143.51 116.65,147.74 117.31,148.41 117.31,152.09 116.63,152.77 v2(116.63,154.14)
  BOTTOM w0.114: v2(133.96,110.14) 133.66,110.43 UC1.BP22
CFG_RCOMP: length 3.4
  BOTTOM w0.102: RH59.1 129.87,111.74 v1(130.39,112.26) 130.99,112.86 UC1.BT25
CHG_B+:
  vias: v1(68.02,30.78) v2(62.37,31.3) v2(62.37,30.66) v2(62.87,31.61) v2(62.87,30.98) v2(62.87,30.34) v2(63.51,31.61) v2(63.51,30.98) v2(63.51,30.34) v2(64.14,31.61) v2(64.14,30.98) v2(64.14,30.34) v2(64.78,31.61) v2(64.78,30.98) v2(64.78,30.34)
CHR_USB20_N1: length 8.1
  TOP w0.102: 22.4,47.02 22.33,46.95 UU1.11
  TOP w0.107: v2(23.11,47.92) 23.27,47.76 23.27,47.65 23.14,47.52 22.75,47.52 22.51,47.27 22.51,47.13 22.4,47.02
  BOTTOM w0.107: LU3.1 24.4,42.67 24.51,42.78 24.51,43.16 24.32,43.36 24.32,44.31 23.91,44.72 23.91,46.5 23.27,47.14 23.27,47.76 v2(23.11,47.92)
CHR_USB20_N1_R: length 13.3
  BOTTOM w0.107: LU3.2 24.4,40.94 24.53,40.81 24.53,40.63 24.39,40.48 23.91,40.48 23.4,39.97 23.4,38.44 23.24,38.29 22.53,38.29 22.45,38.36 DU1.2 22.11,38.78 22.11,38.39 22,38.28 21.85,38.28 20.45,39.68 v4(18.94,39.68) 16.67,39.68 16.55,39.8 JUSB1.2
CHR_USB20_P1: length 8.1
  TOP w0.102: UU1.10 22.83,47.02
  TOP w0.107: 22.83,47.02 22.74,47.11 22.74,47.17 22.85,47.28 23.24,47.28 23.5,47.55 23.5,47.73 v2(23.69,47.92)
  BOTTOM w0.107: LU3.4 24.9,42.6 24.75,42.75 24.75,43.26 24.56,43.45 24.56,44.41 24.14,44.82 24.14,46.6 23.5,47.23 23.5,47.73 v2(23.69,47.92)
CHR_USB20_P1_R: length 13.5
  BOTTOM w0.107: LU3.3 24.9,40.88 24.77,40.75 24.77,40.53 24.48,40.25 24.01,40.25 23.63,39.87 23.63,38.34 23.34,38.05 22.56,38.05 22.45,37.95 DU1.3 22.11,37.53 22.11,37.97 22.03,38.05 21.75,38.05 20.36,39.45 16.63,39.45 16.55,39.37 JUSB1.3
CLK_PCI_LPC: length 99.4
  TOP w0.107: v1(215.86,22.48) 216.1,22.72 v2(216.87,22.72) 216.87,23.42 RH89.1 ; v2(300.68,23.36) 300.68,23.81 301.14,24.27 UE5.12 301.14,26.48 302.13,27.48 RE89.2
  IN3 w0.127: v2(300.68,23.36) 300.68,23.99 300.3,24.37 298.03,24.37 296.94,23.28 292.53,23.28 287.82,27.99 278.81,27.99 278.11,28.69 267.81,28.69 266.12,30.38 259.81,30.38 259.8,30.37 249.2,30.37 247.74,28.91 247.54,28.91 245.72,27.09 242.02,27.09 237.33,22.41 230.22,22.41 230.09,22.28 229.4,22.28 229.08,21.96 227.58,21.96 227.4,22.14 224.84,22.14 224.73,22.03 223.58,22.03 223.55,22.05 223.43,22.17 221.39,22.17 221.31,22.25 219.47,22.25 219.27,22.05 218.92,22.05 218.83,21.96 217,21.96 216.87,22.09 v2(216.87,22.72)
CLK_PCIE_DGPU#_C: length 18.8
  IN6 w0.089: v2(161.66,163.9) 161.66,164.3 162.29,164.93 162.29,167.28 164.26,169.24 164.26,170.34 164.84,170.91 164.84,176.31 v2(165.04,176.51)
  BOTTOM w0.099: JCDRA.34 165.82,178.5
  BOTTOM w0.107: CM99.2 162.44,163.81 162.14,164.11 161.88,164.11 v2(161.66,163.9) ; 165.82,178.5 165.74,178.43 165.74,177.85 164.9,177 164.9,176.65 v2(165.04,176.51)
CLK_PCIE_DGPU_C: length 18.9
  IN6 w0.089: v2(164.46,176.51) 164.67,176.3 164.67,170.98 164.09,170.4 164.09,169.31 162.12,167.34 162.12,164.99 161.34,164.21 v2(161.17,164.21)
  BOTTOM w0.099: JCDRA.33 165.42,178.46
  BOTTOM w0.107: v2(161.17,164.21) 161.4,164.21 161.5,164.32 162.14,164.32 CM98.2 ; 165.42,178.46 165.54,178.34 165.54,177.94 164.69,177.08 164.69,176.74 v2(164.46,176.51)
CLK_PCIE_N1: length 157.2
  IN1 w0.089: v2(199.47,30.6) 199.47,29.95 199.66,29.76 200.47,29.76 201.01,29.22 201.01,26.51 201.69,25.84 207.84,25.84 208.23,25.45 208.86,25.45 209.24,25.07 209.77,25.07 209.93,24.91 211.57,24.91 212.16,24.31 212.41,24.31 212.43,24.32 212.73,24.32 212.74,24.31 213.52,24.31 215.62,22.21 215.62,21.64 216.71,20.55 216.71,20.14 217.19,19.66 217.74,19.66 218.02,19.94 218.02,20.42 218.69,21.1 221.14,21.1 221.55,21.5 223.15,21.5 224.09,20.56 225.07,20.56 225.42,20.21 226.09,20.21 226.69,19.61 228.87,19.61 229.04,19.44 234.65,19.44 235.84,20.63 237.17,20.63 237.73,21.19 237.87,21.19 239.66,22.98 239.66,23.88 243.32,27.54 245.32,27.54 248.94,31.16 272.37,31.16 272.56,30.97 274.83,30.97 275.51,31.64 279.27,31.64 279.51,31.41 286.3,31.41 286.56,31.68 289.16,31.68 292.19,34.71 293.92,34.71 294.38,35.17 321.22,35.17 322.74,36.69 323.31,36.69 323.49,36.51 v2(323.49,36.05)
  IN6 w0.089: v2(207.47,36.89) 207.36,37 207.36,37.44 207.18,37.62 206.63,37.62 205.46,36.44 205.46,35.96 201.58,32.08 201.58,32.06 201.12,31.6 199.78,31.6 199.47,31.28 v2(199.47,30.6)
  BOTTOM w0.099: JSSD1.53 324.92,36.91
  BOTTOM w0.107: UH1.AH9 207.27,37.09 v2(207.47,36.89) ; v2(323.49,36.05) 323.69,36.25 323.69,36.68 323.92,36.91 324.92,36.91
