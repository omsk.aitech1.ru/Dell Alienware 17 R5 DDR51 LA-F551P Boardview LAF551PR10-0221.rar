# Allegro board LAF551PR10-0221.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1V8_MAIN on TOP (solid shape): 230.89,118.67 230.89,118.29 231.21,117.97 232.61,117.97 233.09,117.49 233.09,113.99 232.95,113.85 232.95,112.9 233.15,112.7 233.56,112.7 233.69,112.58 233.69,112.2 233.56,112.07 232.61,112.07 232.55,112.13 232.55,112.73 232.57,112.76 232.57,114.46 232.69,114.67 232.57,114.88 232.57,116.04 232.55,116.06 232.55,117.53 232.43,117.65 230.27,117.65 229.82,118.1 229.82,118.72 229.88,118.78 230.79,118.78
+1V8_MAIN on TOP (solid shape): outline of 209 points within 235.97,110 240.67,112.6
+1V8_MAIN on TOP (solid shape): outline of 1474 points within 210.08,103.7 227.62,113.09
+1V8_MAIN on BOTTOM (solid shape): 199.29,112.77 199.29,112.11 199.06,111.88 199.06,111.55 199.13,111.47 199.13,111.28 199.02,111.17 199,111.19 197.8,111.19 197.75,111.24 197.75,111.41 197.76,111.48 197.75,111.56 197.75,111.68 197.52,111.91 197.48,111.91 197.35,112.04 197.35,112.89 197.41,112.95 199.11,112.95
+1V8_MAIN on BOTTOM (solid shape): 226.54,109.53 226.54,103.9 226.4,103.75 226.22,103.75 225.97,103.87 225.72,103.75 225.47,103.75 225.22,104 225.21,104.01 225.16,104.1 225.07,104.17 225.07,105.03 225.52,105.47 225.71,105.47 226.29,105.65 225.71,105.83 225.49,105.83 225.09,106.23 225.09,106.4 225.22,106.53 225.22,106.8 225.09,106.93 225.09,107.15 225.44,107.5 225.44,107.55 225.47,107.57 225.71,107.57 226.29,107.75 225.71,107.93 225.47,107.93 225.44,107.95 225.44,107.98 225.17,108.25 225.14,108.31 225.14,109.25 225.59,109.7 226.37,109.7
+1V8_MAIN on BOTTOM (solid shape): outline of 89 points within 235.89,110.42 240.99,112.83
+1V8_MAIN on IN1 (solid shape): outline of 4254 points within 191.73,104.25 236.65,117.56
+1V8_MAIN on IN2 (solid shape): outline of 3503 points within 225.34,102.17 240.99,113.02
+1V8_MAIN on IN5: 199.95,105.59 199.72,105.82 199.72,111.52 200.27,112.07 217.58,112.07 217.81,111.84 217.81,109.06 214.34,105.59
+1V_MPHY on TOP (solid shape): outline of 474 points within 195.87,19.1 203.46,26.99
+1V_MPHY on BOTTOM (solid shape): 195.76,17.69 195.76,16.85 195.66,16.76 195.26,16.76 195.02,17 194.51,17 194.44,17.08 194.44,17.69 194.48,17.74 195.7,17.74
+1V_MPHY on BOTTOM (solid shape): 191.4,42.85 191.93,42.85 192.56,42.22 193.86,42.22 194.82,41.26 194.82,41.05 195.03,40.83 195.03,40.67 194.9,40.54 194.59,40.54 194.43,40.38 194.43,40.04 194.33,39.94 194.05,39.94 194.01,39.98 193.98,40.02 193.98,40.2 194.03,40.36 193.98,40.52 193.98,40.7 194.02,40.77 194.03,40.86 194.01,40.88 194.01,40.9 193.92,41.05 193.75,41.11 193.57,41.11 193.41,40.96 192.78,40.96 192.58,41.15 192.21,41.32 191.83,41.19 191.52,41.27 191.27,41.06 191.05,41.05 190.85,40.96 190.83,40.96 190.71,41.08 190.71,41.1 190.2,41.6 190.2,42.22 190.43,42.45 190.61,42.45 190.71,42.54 190.71,42.77 190.84,42.9 191.35,42.9
+1V_PCH on TOP (solid shape): 201.02,44.6 201.02,44.58 201.18,44.42 201.18,42.65 201.11,42.58 201.08,42.59 200.76,42.51 200.68,42.19 200.69,42.16 200.66,42.13 200.9,41.94 201.2,42 201.24,42.02 201.27,41.99 201.92,41.99 202.04,41.93 202.16,41.92 203.72,41.92 203.75,41.89 203.75,41.1 203.72,41.07 199.75,41.07 199.43,41.39 199.43,41.86 199.42,41.87 198.88,41.87 198.87,41.88 198.87,42.05 198.9,42.08 199.37,42.08 199.43,42.14 199.43,42.45 199.44,42.48 199.48,42.5 199.82,42.88 199.43,43.21 199.35,43.23 199.32,43.31 199.32,44.2 199.84,44.72 200.9,44.72
+1V_PCH on IN2 (solid shape): outline of 2066 points within 200.03,29.59 211.53,36.17
+1V_PCH on IN3 (solid shape): outline of 1527 points within 205.53,29.72 211.07,44
+1V_PCH on IN4 (solid shape): 200.56,44.48 200.75,44.48 201.47,43.77 205.1,43.77 205.14,43.81 205.52,43.81 205.71,44 206.26,44 206.37,43.88 206.37,43.56 206.35,43.44 206.36,43.31 206.36,42.94 206.34,42.9 206.23,42.79 206,42.76 205.84,42.59 205.14,42.59 204.92,42.71 204.69,42.65 204.49,42.65 204.26,42.71 204.05,42.61 203.47,42.61 203.32,42.64 203.17,42.6 202.92,42.6 202.72,42.64 202.54,42.57 202.34,42.57 202.17,42.63 201.99,42.6 201.82,42.6 201.65,42.68 201.46,42.65 200.68,42.65 199.8,43.53 199.8,44.09 200.02,44.31 200.04,44.31 200.22,44.49 200.56,44.49
+1VALW on TOP (solid shape): 184.02,82.26 184.02,80.86 183.89,80.74 182.75,80.74 182.5,80.48 182.5,76.16 182.11,75.78 177.1,75.78 176.65,76.23 176.65,79.56 177.4,79.56 177.4,78.79 177.99,78.79 177.99,78.64 177.4,78.64 177.4,77.88 177.77,77.88 178.36,77.29 178.67,77.29 178.89,77.51 178.89,78.47 179.64,79.21 179.64,80.67 179.51,80.8 178.43,80.8 178.18,80.55 178.18,79.97 178.11,79.91 178.01,79.91 177.65,79.56 176.65,79.56 176.65,82.07 177.03,82.45 183.83,82.45
+1VALW on TOP (solid shape): outline of 3042 points within 193.45,15.87 207.34,42.65
+1VALW on BOTTOM (solid shape): 241.18,31.17 241.95,31.17 242.9,30.23 248.79,30.23 249.12,29.9 249.12,28.49 249.06,28.44 249.01,28.38 248.36,28.38 248.36,28.83 247.65,28.83 247.65,28.38 247.16,28.38 247.16,28.83 246.45,28.83 246.45,28.38 245.4,28.38 245.07,28.6 244.74,28.38 243.15,28.38 243.15,28.83 242.45,28.83 242.45,28.38 241.95,28.38 241.95,28.83 241.25,28.83 241.25,28.38 239.88,28.38 239.82,28.65 239.57,28.79 239.57,31.02 239.72,31.17 239.88,31.17 240.05,31.34 240.1,31.4 240.13,31.46 240.15,31.49 240.86,31.49
+1VALW on IN3 (solid shape): outline of 3298 points within 195.72,22.53 208.31,35.8
+1VALW on IN6 (solid shape): outline of 844 points within 232.74,26.67 246.83,37.44
+1VALW on IN5: 201.22,26.47 198.17,29.52 188.9,29.52 179.52,38.9 179.52,39.29 179.57,79.87 186.47,79.87 187.27,79.07 187.27,50.18 195.61,41.84 237.39,41.84 239.78,39.45 239.78,36.46 241.05,35.19 241.05,29.5 240.31,28.76 237.92,28.76 237.16,29.52 209.39,29.52 206.34,26.47
+1VALWP on BOTTOM (solid shape): 240.57,28.18 241.35,28.18 241.35,28.18 241.85,28.18 241.85,28.18 242.55,28.18 242.55,28.18 243.05,28.18 243.05,28.18 243.83,28.18 243.83,28.18 244.72,28.18 244.73,28.15 245.07,27.89 245.42,28.15 245.43,28.18 245.78,28.18 245.78,28.18 246.56,28.18 246.56,28.18 247.05,28.18 247.05,28.18 247.76,28.18 247.76,28.18 248.25,28.18 248.25,28.18 248.89,28.18 248.96,28.1 248.98,28.06 248.98,27.76 250.45,26.28 250.45,19.93 250.03,19.51 247.88,19.51 247.68,19.71 247.68,20.39 247.68,20.39 247.68,21.28 247.67,21.29 247.67,21.31 247.64,21.46 247.55,21.58 247.53,21.59 247.53,21.65 247.55,21.67 247.67,21.96 247.52,22.23 246.32,23.42 243.26,23.42 243.18,23.46 243.15,23.54 243.1,23.79 242.88,23.94 242.46,23.95 242.32,23.56 242.3,23.47 242.22,23.42 241.75,23.42 241.31,22.98 238.71,22.98 238.51,23.18 238.51,23.5 238.48,23.53 238.48,26.07 238.51,26.11 238.54,26.18 239.25,26.88 239.25,27.9 239.44,28.09 239.47,28.09 239.64,28.1 239.78,28.18 240.57,28.18
+1VALWP_B+ on TOP (solid shape): 259.36,24.48 259.78,24.48 260.1,24.16 260.1,22.81 260.66,22.25 260.66,20.2 260.49,20.02 260.49,16.18 260.22,15.92 259.5,15.92 259.5,16.45 259.06,16.45 259.06,15.92 258.77,15.92 258.77,16.88 258.96,17.07 258.96,18.66 259,18.73 259.08,18.75 259.51,19.1 259.08,19.45 259,19.47 258.96,19.55 258.96,20.09 259.69,20.82 259.69,21.47 259.53,21.62 257.94,21.62 257.64,21.32 256.86,21.32 256.77,21.36 256.68,21.37 256.64,21.4 255.23,21.4 255.22,21.42 255.22,23.66 255.48,23.93 257.37,23.93 257.95,24.5 259.34,24.5
+2.5V_MEM on TOP (solid shape): 179.61,65.09 179.61,59.95 179.42,59.76 178.02,59.76 177.89,59.89 177.89,65.16 178.08,65.35 179.35,65.35
+2.5V_MEM on TOP (solid shape): 180.92,51.43 180.92,47.87 180.73,47.68 180.29,47.68 179.84,48.12 179.71,48.12 179.65,48.13 179.58,48.12 179.21,48.12 178.82,48.5 178.82,48.82 179.65,49.65 179.65,51.62 179.84,51.81 180.54,51.81
+2.5V_MEM on BOTTOM (solid shape): 179.96,62.41 179.96,59.8 179.73,59.57 177.76,59.57 177.55,59.78 177.55,60.17 177.53,60.19 177.53,62.65 177.63,62.75 179.62,62.75
+2.5V_MEM on BOTTOM (solid shape): 180.41,48.74 180.04,48.37 179.45,48.37 179.21,48.12 177.66,48.12 177.53,48.25 177.53,50.41 177.76,50.64 179.14,50.64 179.42,50.92 180.41,50.92
+2.5V_MEM on BOTTOM (solid shape): 107.42,47.93 107.45,47.84 107.5,47.77 107.93,47.35 108.12,47.92 108.12,47.93 109.99,47.93 110.44,47.49 110.44,46.35 109.93,45.84 109.17,45.84 104.53,41.2 103.32,41.2 103.13,41.4 103.13,41.75 103.66,41.75 103.66,42.26 103.13,42.26 103.13,42.55 103.66,42.55 103.66,43.06 103.13,43.06 103.13,44.25 106.82,47.93
+2.5V_MEM on IN6 (solid shape): 111.2,49.08 111.2,48.12 110.56,47.49 110.56,46.79 110.05,46.28 109.23,46.28 108.97,46.54 108.97,48.63 109.55,49.2 111.07,49.2
+2.5V_MEM on IN6 (solid shape): 180.22,50.85 180.22,49.46 179.21,48.44 178.7,48.44 178.25,48.89 178.25,49.39 179.14,50.28 179.14,50.92 179.21,50.98 180.09,50.98
+2.5V_MEMP on BOTTOM (solid shape): 101.86,46.4 101.86,44.7 102.24,44.31 102.69,44.31 103,44 103,43.53 103,43.53 103,42.95 103,42.93 103.52,42.93 103.52,42.68 103,42.68 103,42.66 103,42.15 103,42.13 103.52,42.13 103.52,41.93 103.47,41.88 103,41.88 103,41.86 103,41.41 102.92,41.33 101.8,41.33 101.58,41.11 101.58,39.96 101.48,39.86 100.88,39.86 100.78,39.95 100.78,44.19 101.16,44.57 101.16,46.41 101.35,46.6 101.66,46.6
+2.5VOUT on IN2 (solid shape): outline of 587 points within 129.83,152.83 138.35,163.05
+2.5VSP_VIN on BOTTOM (solid shape): 100.95,55.86 101.5,55.86 101.5,56.41 101.74,56.41 101.74,55.86 102.29,55.86 102.29,56.41 102.91,56.41 103.2,56.12 103.2,55.17 102.37,54.35 102.37,52.12 101.99,51.74 101.99,49.97 101.8,49.77 101.35,49.77 101.16,49.97 101.16,54.22 100.4,54.98 100.4,56.34 100.47,56.42 100.95,56.42
+3.3V_1.8V_DVDD on TOP (solid shape): 38.61,33.59 38.84,33.42 39.13,33.48 39.14,33.49 39.24,33.49 39.24,33.49 39.28,33.49 39.29,33.48 39.47,33.41 39.66,33.45 39.7,33.47 39.76,33.4 39.76,33.39 40.17,32.99 41.07,32.99 41.2,32.86 41.2,32.58 41.22,32.57 41.22,31.36 40.34,31.36 40.34,31.04 40.28,30.98 39.78,30.98 39.69,31.07 39.68,31.11 39.68,31.48 39.71,31.49 39.91,31.88 39.58,32.17 39.56,32.17 38.94,32.17 38.81,32.3 38.81,32.74 38.71,32.84 38.14,32.84 38.07,32.91 38.07,33.54 38.13,33.59
+3.3V_1.8V_DVDD_IO on BOTTOM (solid shape): 33.33,29.16 33.33,28.31 33.57,28.07 33.57,27.7 34.12,27.16 34.12,23.27 34.1,23.25 33.34,23.25 33.21,23.37 33.21,28.08 33.1,28.2 33.1,29.16 33.15,29.21 33.28,29.21
+3.3V_ELC on TOP (solid shape): 167.2,24.42 167.2,22.7 167.04,22.53 159.56,22.53 159.35,22.74 159.35,24.27 159.6,24.52 167.1,24.52
+3.3V_ELC on TOP (solid shape): 326.72,50.28 326.72,48.7 326.59,48.57 323.1,48.57 322.91,48.76 322.91,50.35 323.03,50.47 326.53,50.47
+3.3V_ELC on BOTTOM (solid shape): 160.87,31.91 160.87,23.12 160.57,22.82 159.49,22.82 159.2,23.1 159.2,30.47 157.95,31.72 154.94,31.72 154.55,32.11 154.55,32.82 154.74,33.01 159.77,33.01
+3.3V_ELC on BOTTOM (solid shape): 166.9,28.76 166.9,27.47 167.18,27.19 167.18,23.86 167.09,23.77 166.22,23.77 166.08,23.91 166.08,27.53 166.3,27.74 166.3,28.73 166.46,28.89 166.76,28.89
+3.3V_ELC on BOTTOM (solid shape): 104.02,29.4 104.02,26.98 104.22,26.78 104.22,25.03 104.03,24.83 103.22,24.83 103.03,25.03 103.03,26.42 102.83,26.62 102.83,27.63 102.65,27.8 102.13,27.8 101.89,28.04 101.89,29.16 102.35,29.62 102.35,30.27 102.52,30.45 102.98,30.45
+3.3V_ELC on IN1 (solid shape): 224.61,162.3 224.68,162.27 224.71,162.2 224.72,162.13 224.75,162.06 224.77,162.02 224.79,161.99 224.81,161.93 224.79,161.86 224.75,161.48 225.08,161.28 225.15,161.25 225.18,161.18 225.18,155.63 224.68,155.13 223.64,155.13 223.5,155.27 223.5,155.71 223.21,156.01 223.21,158.18 223.25,158.26 223.35,158.28 223.82,158.64 223.29,158.93 223.28,158.92 223.23,158.93 223.21,158.97 223.21,159.01 223.71,159.51 223.71,159.52 223.88,159.69 223.88,161.29 223.71,161.47 223.71,162.27 223.73,162.3
+3.3V_ELC on IN2 (solid shape): 105.16,20.54 105.16,19.74 105.08,19.66 102.9,19.66 102.75,19.8 102.75,20.42 103.01,20.67 105.04,20.67
+3.3V_ELC on IN2 (solid shape): 168.3,24.64 168.3,23.78 168.24,23.71 164.84,23.71 164.78,23.77 164.78,24.7 164.82,24.75 168.2,24.75
+3.3V_ELC on IN2 (solid shape): 225.48,155.56 225.48,154.4 225.36,154.28 223.91,154.28 223.65,154.54 223.65,155.48 223.86,155.68 225.36,155.68
+3.3V_ELC on IN2 (solid shape): outline of 3355 points within 290.14,30.66 326.21,50.6
+3.3V_ELC on IN4 (solid shape): 102.65,29.35 102.69,29.32 102.72,29.29 103.55,28.46 103.55,27.17 101.8,25.42 101.8,22.88 104.17,20.51 104.17,20.06 104.05,19.94 103.07,19.94 100.78,22.22 100.78,25.84 102.54,27.59 102.54,28.01 101.82,28.72 101.82,28.89 102.4,29.46 102.54,29.46
+3.3V_FLASH on TOP (solid shape): outline of 213 points within 194.7,160.66 197.87,165.03
+3.3V_TBT_SX on IN6 (solid shape): outline of 1512 points within 169.55,162.23 179.84,170.89
+3V3_SYS on BOTTOM (solid shape): 196.43,119.26 196.58,119.26 197.06,118.78 197.06,118.09 196.86,117.9 196.71,117.9 196.54,117.73 196.54,117.23 196.34,117.03 195.63,117.03 195.54,117.12 195.54,119.3 195.66,119.42 196.28,119.42
+3V3_SYS on IN4 (solid shape): outline of 100 points within 196.5,117.87 199.02,119.41
+3V_PCH on TOP (solid shape): 224.63,40.85 225.56,40.85 225.61,40.81 225.61,40.36 225.62,40.35 226.13,40.35 226.15,40.33 226.15,40.08 226.14,40.08 225.61,40.08 225.6,40.07 225.6,39.55 225.61,39.54 226.14,39.54 226.15,39.53 226.15,39.28 226.13,39.26 225.61,39.26 225.6,39.25 225.6,38.72 225.53,38.65 223.6,38.65 223.27,38.98 222.71,38.98 221.47,40.22 220.91,40.78 220.91,41.63 221.17,41.89 223.59,41.89
+3V_PCH on TOP (solid shape): 204.09,24.83 204.12,24.83 204.19,24.76 204.19,23.56 204.09,23.46 204.09,23.38 204.02,23.38 203.79,23.35 203.64,23.18 203.64,23.16 203.58,23.1 203.58,22.2 203.51,22.2 203.51,21.49 203.44,21.42 202.69,21.42 202.64,21.47 202.64,22.71 202.66,22.72 202.83,23 202.66,23.28 202.64,23.29 202.64,24.53 202.94,24.84 204.09,24.84
+3V_PCH on TOP (solid shape): outline of 203 points within 208.94,23.78 216.4,27.05
+3V_PCH on TOP (solid shape): outline of 247 points within 205.7,13.87 210.14,25.5
+3V_PCH on BOTTOM (solid shape): 229.54,17.1 229.54,15.95 229.09,15.5 228.28,15.5 228.23,15.55 227.16,15.55 226.84,15.87 226.84,16.13 227.4,16.69 228.04,16.69 228.05,16.7 228.16,16.7 228.72,17.26 229.38,17.26
+3V_PCH on IN2 (solid shape): outline of 3569 points within 205.93,16.61 229.59,27.05
+3V_PCH on IN3 (solid shape): outline of 4423 points within 209.14,23.32 225.06,41.58
+3VALW on TOP (solid shape): 53.09,11.17 53.09,8.94 53.03,8.88 52.08,8.88 51.7,9.26 51.7,11.17 51.95,11.42 52.84,11.42
+3VALW on TOP (solid shape): 235.52,35.3 235.52,34.53 235.45,34.47 234.44,34.47 234.37,34.53 234.37,35.1 234.76,35.49 235.33,35.49
+3VALW on TOP (solid shape): 235.52,32.06 235.52,31.3 235.45,31.23 234.49,31.23 234.45,31.27 234.45,32.07 234.63,32.24 235.33,32.24
+3VALW on TOP (solid shape): 235.52,28.82 235.52,28.06 235.45,27.99 234.44,27.99 234.37,28.06 234.37,28.88 234.5,29.01 235.33,29.01
+3VALW on TOP (solid shape): 298.46,7.1 298.46,6.43 298.41,6.38 297.07,6.38 296.96,6.5 296.96,7.06 297.11,7.22 298.34,7.22
+3VALW on TOP (solid shape): 28.96,50.28 28.96,49.9 28.71,49.65 25.73,49.65 25.66,49.71 25.66,50.03 25.73,50.09 28.39,50.09 28.65,50.35 28.9,50.35
+3VALW on TOP (solid shape): 306.49,10.79 306.49,8.41 306.37,8.28 305.75,8.28 305.65,8.38 305.65,8.86 305.43,9.09 305.43,10.81 305.5,10.89 306.4,10.89
+3VALW on TOP (solid shape): 297.4,27.98 297.4,27.07 297.3,26.97 297.3,24.8 297.19,24.7 297.09,24.7 296.98,24.8 296.98,26.49 296.93,26.55 296.9,26.58 296.87,26.6 296.71,26.76 296.71,27.97 296.81,28.07 297.3,28.07
+3VALW on TOP (solid shape): 290.28,27.73 290.28,26.19 290.49,25.99 290.49,24.66 290.71,24.44 292.1,24.44 292.41,24.12 292.41,23.93 292.33,23.85 290.25,23.85 289.69,24.41 289.68,24.41 289.12,24.41 288.36,25.17 288.36,27.75 288.73,28.11 289.89,28.11
+3VALW on TOP (solid shape): 303.38,27.94 303.38,27.39 302.48,26.5 302.48,25.51 302.47,25.5 302.47,24.81 302.4,24.74 302.28,24.74 302.21,24.8 302.21,26.76 302.69,27.24 302.69,27.71 302.69,27.8 302.66,27.89 302.65,27.92 302.72,27.99 303.33,27.99
+3VALW on TOP (solid shape): 49.35,25.77 49.35,22.79 48.9,22.34 47.75,22.34 47.75,22.34 46.55,22.34 46.55,22.86 45.85,22.86 45.85,22.34 45.35,22.34 45.35,22.86 44.65,22.86 44.65,22.34 41.28,22.34 41.28,22.86 40.58,22.86 40.58,22.34 40.08,22.34 40.08,22.86 39.38,22.86 39.38,22.34 38.78,22.34 38.55,22.58 38.55,24.26 38.55,24.27 38.55,25.01 38.81,25.26 41.98,25.26 42.68,25.96 49.16,25.96
+3VALW on TOP (solid shape): 223.96,46.84 224.16,46.84 224.16,46.41 224.38,46.19 224.38,45.64 224.6,45.43 225.12,45.43 225.18,45.5 225.19,45.5 225.35,45.6 225.44,45.75 225.45,45.76 225.7,46.02 226.56,46.02 226.86,45.72 226.87,45.7 226.87,45.12 226.86,45.11 226.82,44.96 226.85,44.8 226.86,44.77 225.46,43.37 223.32,43.37 223.19,43.5 223.19,45.6 222.92,45.87 221.4,45.87 221.33,45.93 221.33,47.31 221.46,47.43 223.96,47.43
+3VALW on TOP (solid shape): 311.15,26.05 311.35,25.99 311.55,26.05 311.77,26.05 311.86,26 311.95,25.98 311.97,25.98 312.11,25.84 312.11,24.49 311.64,24.02 311.29,23.93 311.2,23.58 311.08,23.47 311.08,22.29 310.88,22.08 310.27,22.08 310.25,22.11 310.25,23.06 310.09,23.22 308.89,23.22 308.8,23.12 308.72,23.12 308.72,23.05 308.38,22.7 306.25,22.7 306.25,22.89 306.35,22.98 308.1,22.98 308.33,23.21 308.33,23.72 308.85,24.25 308.85,24.26 308.92,24.33 310.07,24.33 310.2,24.46 310.24,24.46 310.46,24.69 310.46,24.73 310.64,24.9 310.64,25.93 310.7,25.99 310.82,26 310.94,26.05
+3VALW on TOP (solid shape): outline of 90 points within 313.32,55.93 316.07,58.79
+3VALW on BOTTOM (solid shape): 229.59,25.58 229.59,24.82 229.52,24.76 228.51,24.76 228.44,24.82 228.44,25.64 228.57,25.77 229.4,25.77
+3VALW on BOTTOM (solid shape): 229.61,31.9 229.61,31.21 229.57,31.16 228.52,31.16 228.44,31.24 228.44,31.95 228.64,32.15 229.37,32.15
+3VALW on BOTTOM (solid shape): 235.52,35.3 235.52,34.53 235.45,34.47 234.44,34.47 234.37,34.53 234.37,35.02 234.84,35.49 235.33,35.49
+3VALW on BOTTOM (solid shape): 235.52,25.58 235.52,24.82 235.45,24.76 234.44,24.76 234.37,24.82 234.37,25.64 234.5,25.77 235.33,25.77
+3VALW on BOTTOM (solid shape): 229.59,28.82 229.59,28.06 229.52,27.99 228.51,27.99 228.44,28.06 228.44,28.88 228.57,29.01 229.4,29.01
+3VALW on BOTTOM (solid shape): 235.52,32.06 235.52,31.3 235.45,31.23 234.44,31.23 234.37,31.3 234.37,32.12 234.5,32.24 235.33,32.24
+3VALW on BOTTOM (solid shape): 235.52,28.82 235.52,28.06 235.45,27.99 234.44,27.99 234.37,28.06 234.37,28.88 234.5,29.01 235.33,29.01
+3VALW on BOTTOM (solid shape): 229.59,35.49 229.59,34.53 229.52,34.47 228.51,34.47 228.44,34.53 228.44,35.5 228.59,35.65 229.43,35.65
+3VALW on BOTTOM (solid shape): 270.47,174.2 270.47,173.51 270.66,173.32 271.35,173.32 271.4,173.28 271.4,171.21 271.3,171.11 269.76,171.11 269.55,171.32 269.55,174.16 269.64,174.24 270.43,174.24
+3VALW on BOTTOM (solid shape): 31,15.48 31,14.98 31.5,14.98 31.57,15.04 31.57,15.48 31.63,15.55 32.71,15.55 32.77,15.48 32.77,14.28 32.58,14.09 30.93,14.09 30.62,14.41 30.62,15.42 30.74,15.55 30.93,15.55
+3VALW on BOTTOM (solid shape): 227.56,45.44 227.56,45.01 227.62,44.95 227.62,43.64 227.92,43.34 228.47,43.34 228.53,43.27 228.53,43.06 228.51,43.03 227.28,43.03 226.74,43.56 226.07,43.56 225.58,44.06 225.58,44.72 225.52,44.77 225.52,45.7 225.62,45.8 227.2,45.8
+3VALW on BOTTOM (solid shape): 162.57,176.77 162.57,176.09 162.45,175.97 161.28,175.97 160.2,174.89 159.91,174.89 159.82,174.9 159.73,174.89 158.54,174.89 158.36,175.07 158.36,175.85 158.47,175.96 159.24,175.96 159.5,175.7 160.21,175.7 160.64,176.13 160.64,176.68 160.79,176.84 162.51,176.84
+3VALW on BOTTOM (solid shape): 68.45,20.31 68.45,19.71 68.56,19.6 68.56,16.96 68.12,16.51 65.45,16.51 65.39,16.58 65.39,17.4 65.86,17.87 65.86,18.94 65.98,19.07 66.26,19.07 66.47,19.27 66.47,19.57 67.41,20.51 68.25,20.51
+3VALW on BOTTOM (solid shape): 177.17,176.56 177.17,175.85 176.97,175.64 175.75,175.64 175.55,175.44 175.55,174.83 175.41,174.7 174.55,174.7 174.47,174.78 174.47,175.12 174.6,175.25 174.61,175.25 174.8,175.57 174.6,175.89 174.6,176.35 175.04,176.79 176.95,176.79
+3VALW on BOTTOM (solid shape): 22.23,51.24 22.23,51.17 22.26,51.14 22.26,51.14 22.43,50.97 22.66,50.95 22.74,50.93 22.78,50.85 22.78,50.45 22.74,50.41 22.05,50.41 21.09,50.41 20.96,50.28 20.96,49.46 20.52,49.01 20.32,49.01 20.07,49.26 20.07,49.39 19.88,49.58 18.55,49.58 18.49,49.65 18.49,50.35 18.55,50.41 19.82,50.41 20.27,50.85 20.9,50.85 21.09,51.04 21.09,51.24 21.28,51.43 22.04,51.43
+3VALW on BOTTOM (solid shape): 270.9,26.36 270.9,25.79 270.72,25.61 270.65,25.6 270.6,25.59 270.22,25.59 270.22,25.59 269.92,25.59 269.91,25.59 269.64,25.59 269.63,25.59 269.34,25.59 269.13,25.38 269.13,25.08 269.18,25.03 269.18,23.36 268.33,22.51 266.77,22.51 266.28,22.02 266.28,22.01 266.17,21.94 266.1,21.84 266.1,21.83 266.05,21.78 265.52,21.78 265.39,21.66 265.39,20.48 265.37,20.47 263.8,20.47 263.78,20.49 263.78,23.42 265.5,25.15 266.8,25.15 267.43,25.78 267.55,25.78 267.55,25.9 268.2,26.55 270.7,26.55
+3VALW on BOTTOM (solid shape): outline of 758 points within 308.03,9.77 312.38,27.55
+3VALW on IN1 (solid shape): outline of 113 points within 63.23,14.54 69.58,20.48
+3VALW on IN1 (solid shape): outline of 556 points within 288.95,24.04 311.95,29.3
+3VALW on IN1 (solid shape): outline of 1406 points within 221.24,31.56 240.07,46.74
+3VALW on IN2 (solid shape): outline of 1898 points within 228.51,19.96 244.33,36.52
+3VALW on IN6 (solid shape): 274.48,169.6 277.97,169.6 278.8,170.42 280.32,170.42 280.78,169.96 280.78,169.29 280.72,169.22 280.69,169.24 280.31,169.15 280.23,168.78 280.24,168.75 280.07,168.58 279.84,168.58 279.75,168.63 279.75,168.73 279.43,169.26 279.12,168.73 279.12,168.63 279.03,168.58 274.07,168.58 272.09,170.57 271.43,170.57 270.65,171.35 270.65,171.98 270.95,172.28 271.8,172.28
+3VALW on IN6 (solid shape): outline of 122 points within 21.73,50.35 25.28,51.87
+3VALW on IN6 (solid shape): outline of 836 points within 31.38,8.5 53.22,15.17
+3VALW on IN5: outline of 117 points within 44.01,14.66 334.15,175.31 ; 1 cut-out
+3VALW_PD on TOP (solid shape): 196.11,166.53 196.12,166.53 196.2,166.45 196.66,166.45 196.87,166.67 197.21,166.67 197.38,166.5 197.38,165.68 197.3,165.6 196.59,165.6 196.15,165.15 195.4,165.15 195.31,165.25 195.31,166.52 195.31,166.53 195.31,166.61 195.37,166.67 195.97,166.67
+3VALWP on TOP (solid shape): 39.98,22.21 40.68,22.21 40.68,22.22 41.18,22.22 41.18,22.21 41.96,22.21 41.96,22.22 43.97,22.22 43.97,22.21 44.75,22.21 44.75,22.22 45.25,22.22 45.25,22.21 45.95,22.21 45.95,22.22 46.45,22.22 46.45,22.21 47.23,22.21 47.23,22.22 47.7,22.22 48.14,21.77 48.14,18.91 47.76,18.53 43.76,18.53 42.36,19.93 38.87,19.93 38.68,20.12 38.68,20.5 38.72,20.58 38.8,20.6 39.18,20.78 39.13,21.19 39.1,21.26 39.13,21.33 39.18,21.75 38.8,21.93 38.72,21.95 38.68,22.03 38.68,22.09 38.8,22.21 39.48,22.21 39.48,22.22 39.98,22.22
+3VALWP on BOTTOM (solid shape): 43.63,25.84 43.63,25.56 43.63,25.55 43.61,25.43 43.63,25.3 43.63,25.3 43.63,23.68 44.4,22.91 51.44,22.91 51.63,22.72 51.63,18.98 51.44,18.79 41.46,18.79 41.09,19.16 41.09,19.87 39.89,21.07 39.89,25.9 40.33,26.34 43.13,26.34
+3VLP on TOP (solid shape): 306.39,17.38 307.94,17.38 307.96,17.39 308.55,17.39 308.8,17.14 309.31,17.14 309.5,16.95 309.5,16.56 309.37,16.43 308.73,16.43 308.1,17.06 308.09,17.06 306.35,17.06 306.27,17.14 306.27,17.3 306.36,17.39
+3VS on TOP (solid shape): 177.7,66.17 177.7,62.97 177.54,62.81 176.94,62.81 176.68,63.06 176.68,64.01 176.35,64.35 176.35,66.22 176.56,66.43 177.45,66.43
+3VS on TOP (solid shape): 300.19,7.57 300.19,6.89 299.67,6.37 298.76,6.37 298.69,6.44 298.69,7.09 298.82,7.22 299.24,7.22 299.27,7.22 299.78,7.74 300.02,7.74
+3VS on TOP (solid shape): 276.78,150.33 277.36,150.33 277.52,150.18 277.52,149.03 277.41,148.92 276.57,148.92 276.16,149.33 275.55,149.33 275.11,149.77 274.81,149.77 274.7,149.88 274.7,150.49 275,150.79 276.32,150.79
+3VS on TOP (solid shape): 244.44,166.65 244.44,164.21 243.46,163.23 241.12,163.23 240.38,162.49 240.2,162.49 239.62,163.06 239.62,163.3 240.66,164.34 243.08,164.34 243.41,164.68 243.41,165.88 243.41,165.89 243.41,166.63 243.5,166.72 244.38,166.72
+3VS on TOP (solid shape): 187.73,69.06 187.73,67.44 187.57,67.28 187.49,67.28 187.4,67.27 186.35,67.27 186.27,67.35 186.27,68.08 186.36,68.16 186.45,68.16 186.61,68.33 186.61,69.18 186.75,69.31 187.48,69.31
+3VS on TOP (solid shape): 303.49,44.08 303.57,44.07 303.65,44.08 304.41,44.08 304.94,43.55 304.94,41.33 304.83,41.23 303.69,41.23 303.35,40.88 300.49,40.88 300.3,41.08 300.3,42.9 300.41,43.02 302.03,43.02 302.53,43.52 302.53,43.98 302.63,44.08
+3VS on TOP (solid shape): 221.48,30.93 221.48,29.79 221.45,29.6 221.52,29.43 221.52,29.24 221.49,28.94 221.71,28.72 221.71,26.77 222.21,26.27 222.21,26 221.91,25.7 221.75,25.7 221.43,26.03 221.34,26.03 220.88,26.48 220.88,26.84 220.71,27 220.71,29.05 220.86,29.2 220.86,30.9 220.93,30.96 221.45,30.96
+3VS on TOP (solid shape): 314.77,44.58 314.77,44.21 314.91,44.07 316.24,44.07 316.34,44.05 316.44,44.07 317.48,44.07 318.11,43.44 318.73,43.44 318.9,43.27 318.9,42.28 318.47,41.85 318.1,41.48 318.1,41.15 317.93,40.97 317.05,40.97 316.85,41.12 316.61,41.05 316.2,41.46 315.3,41.46 315.2,41.35 315.2,40.92 315.07,40.79 314.52,40.79 314.41,40.91 314.41,41.98 313.82,42.57 313.82,44.57 313.86,44.61 314.74,44.61
+3VS on BOTTOM (solid shape): 242,163.98 242,163.31 241.09,162.4 240.17,162.4 239.53,163.05 239.53,163.25 239.86,163.59 240.79,163.59 241.27,164.08 241.9,164.08
+3VS on BOTTOM (solid shape): 318.92,43.46 318.92,41.59 318.15,40.82 316.72,40.82 316.56,40.98 316.56,41.33 316.56,41.33 316.56,41.9 316.62,41.96 317.69,41.96 317.89,42.16 317.89,43.6 317.99,43.71 318.68,43.71
+3VS on BOTTOM (solid shape): 301.23,43.63 301.23,42.1 301.44,41.89 302.87,41.89 303.03,41.73 303.03,40.83 302.96,40.76 300.61,40.76 300.27,41.09 300.27,43.56 300.4,43.69 301.16,43.69
+3VS on BOTTOM (solid shape): 221.83,28.22 221.83,27.79 222.39,27.23 222.79,27.23 223.14,26.88 223.14,25.98 222.97,25.81 221.68,25.81 221.46,26.03 221.46,26.25 221.4,26.31 221.38,26.31 220.73,26.96 220.73,28.56 220.88,28.71 221.34,28.71
+3VS on BOTTOM (solid shape): 73.02,20.28 73.02,14.48 72.47,13.93 72.47,12.11 72.25,11.88 72.19,11.88 72.19,11.88 71.04,11.88 70.44,12.48 70.44,15.32 69.89,15.32 69.89,15.61 70.44,15.61 70.44,16.12 69.89,16.12 69.89,16.41 70.44,16.41 70.44,17.19 70.13,17.5 70.13,20.29 70.33,20.49 72.81,20.49
+3VS on BOTTOM (solid shape): 195.62,108.25 195.62,106.95 196.29,106.28 196.78,106.28 196.88,106.18 196.88,105.64 196.82,105.58 196.27,105.58 195.92,105.88 195.57,105.58 194.68,105.58 194.46,105.8 194.46,106.34 194.26,106.53 193.15,106.53 193.11,106.58 193.11,108.3 193.15,108.35 195.52,108.35
+3VS on BOTTOM (solid shape): 204.42,13.96 204.42,13.4 204.59,13.22 206.5,13.22 206.77,13.49 206.77,13.59 206.96,13.77 207.43,13.77 207.62,13.58 207.62,12.19 207.58,12.15 204.92,12.15 204.58,11.8 203.17,11.8 202.95,11.59 202.95,10.96 202.82,10.82 202.12,10.82 201.99,10.95 201.99,11.52 201.79,11.73 201.79,12.36 201.88,12.45 203.01,12.45 203.15,12.31 203.84,12.31 203.89,12.36 203.89,12.93 203.97,13.01 203.97,13.92 204.1,14.05 204.33,14.05
+3VS on BOTTOM (solid shape): 166.38,173.09 166.38,172.53 166.38,172.46 166.7,172.14 167.98,172.14 168,172.11 168.11,171.97 168.28,171.92 168.31,171.93 168.6,171.63 168.6,170.36 168.41,170.17 167.84,170.17 167.59,170.42 167.59,170.87 167.54,170.91 167.54,170.92 167.47,171.02 167.37,171.09 167.36,171.09 167.33,171.12 167.32,171.12 165.93,171.12 165.77,171.29 165.77,171.43 165.74,171.43 165.74,171.57 165.76,171.57 165.76,172.33 165.74,172.33 165.74,172.88 165.74,173.03 165.87,173.16 166.32,173.16
+3VS on BOTTOM (solid shape): outline of 104 points within 117.31,11.07 126.08,25.48
+3VS on IN3 (solid shape): 167.27,183.06 167.27,181.92 167.08,181.73 162.95,181.73 162.7,181.98 162.7,183 162.89,183.19 167.14,183.19
+3VS on IN3 (solid shape): outline of 214 points within 164.98,162.23 167.33,168.65
+3VS on IN3 (solid shape): outline of 251 points within 164.47,171.06 167.33,176.08
+3VS on IN4 (solid shape): outline of 1217 points within 173.87,35.02 180.37,64.63
+3VS on IN6 (solid shape): outline of 147 points within 182.19,68.13 189.81,71.3
+3VS on BOTTOM: 161.43,165.91 161.77,166.25 161.77,166.85 161.77,166.85 161.77,167.45 161.88,167.57 163.08,167.57 163.37,167.86 164.79,167.86 164.86,167.93 166,167.93 166.72,168.65 166.72,168.65 167.12,169.04 168.54,169.04 168.59,168.99 168.59,168.25 167.27,166.93 167.27,166.42 166.47,165.63 165.84,165.63 165.84,165.63 165.74,165.63 165.61,165.5 164.76,165.5 164.67,165.59 164.67,165.6 164.67,165.71 164.51,165.87 164.45,165.97 164.34,166.04 164.26,166.12 163.18,166.12 162.79,165.73 162.79,165.35 162.68,165.25 162.25,165.25 162.21,165.21 161.89,164.89 161.52,164.89 161.43,164.99
+3VS on IN5: outline of 112 points within 47.25,18.6 327.29,167.69 ; 3 cut-outs
+3VS_DP on TOP (solid shape): 242.3,166.56 242.3,165.05 242.2,164.95 239.77,164.95 239.65,165.07 239.65,166.1 239.72,166.17 240.65,166.17 241.12,166.64 242.23,166.64
+3VS_DP on BOTTOM (solid shape): 237.98,173.38 237.98,172.14 239.85,170.27 239.85,166.42 240.1,166.17 240.7,166.17 241.13,166.6 241.5,166.6 241.76,166.34 241.76,165.31 240.8,164.34 239.58,164.34 238.46,165.47 238.46,169.93 237.77,170.62 237.77,171.3 237.72,171.36 237.73,171.37 237.73,172.72 237.54,172.91 237.54,173.36 237.66,173.47 237.88,173.47
+3VS_SSD on TOP (solid shape): 278.65,25.07 278.65,21.9 278.33,21.58 276.36,21.58 276.01,21.93 276.01,25.23 276.3,25.52 278.2,25.52
+3VS_SSD on TOP (solid shape): 334.23,33.75 334.23,30.29 333.99,30.06 332.67,30.06 332.51,30.22 332.51,31.2 332.01,31.7 331.44,31.7 331.26,31.88 331.26,33.42 331.81,33.96 334.02,33.96
+3VS_SSD on TOP (solid shape): outline of 107 points within 235.7,6.12 263.03,16.55
+3VS_SSD on BOTTOM (solid shape): 334.89,32.41 334.89,30.29 334.57,29.97 332.75,29.97 332.49,30.22 332.49,32.59 332.75,32.84 334.46,32.84
+3VS_SSD on BOTTOM (solid shape): 232.07,9.29 232.1,9.29 232.13,9.29 232.53,9.29 232.71,9.22 232.9,9.26 233.04,9.22 233.18,9.25 233.25,9.23 233.31,9.22 233.38,9.23 233.45,9.25 234.12,8.58 234.19,8.58 234.2,8.57 234.78,8.4 235.36,8.58 236.86,8.58 237.02,8.42 237.02,8.1 236.93,8.02 236.93,6.48 236.79,6.34 232.29,6.34 231.64,6.99 231.64,9.24 231.69,9.29
+3VS_SSD on BOTTOM (solid shape): outline of 120 points within 332.37,45.52 336.43,50.6
+3VS_SSD on BOTTOM (solid shape): outline of 186 points within 276.68,7.64 284.48,26.22
+3VS_SSD on BOTTOM (solid shape): outline of 485 points within 249.63,6.09 263.51,22.85
+3VS_SSD on IN1 (solid shape): outline of 559 points within 260.56,15.94 278.9,23.76
+3VS_SSD on IN2 (solid shape): 334.44,31.06 334.44,27.46 334.24,27.26 332.85,27.26 332.33,27.77 332.33,31.06 332.63,31.36 334.14,31.36
+3VS_SSD on IN2 (solid shape): outline of 1852 points within 280.15,6.11 326.36,12.17
+3VS_SSD on IN3 (solid shape): outline of 134 points within 276.23,7.42 281.76,23.87
+3VS_SSD on IN3 (solid shape): outline of 169 points within 332.02,29.14 335.51,47.65
+3VS_TBT on TOP (solid shape): 178.19,176.65 178.19,175.31 177.94,175.06 177.94,174.57 177.93,174.57 177.93,174.21 177.57,173.85 177.57,173.37 177.46,173.38 177.36,173.36 177.17,173.36 177.03,173.22 177.03,173.21 176.48,172.65 176.48,172.27 176.94,171.8 176.94,171.34 176.96,171.31 176.96,171.09 176.9,171.03 176.79,171.03 176.66,171.15 176.66,171.33 176.53,171.46 176.34,171.46 176.28,171.52 176.28,171.79 175.96,172.12 175.96,172.78 175.96,172.9 176.17,173.11 176.17,174.1 176.41,174.34 176.41,176.66 176.6,176.85 177.99,176.85
+3VS_TBT on BOTTOM (solid shape): 177.88,175.8 177.88,174.72 177.75,174.6 177.48,174.6 176.35,173.47 176.35,173.14 176.42,172.89 176.59,172.69 176.55,172.5 176.62,172.32 176.62,171.76 176.46,171.61 175.5,171.61 175.47,171.63 175.47,172.32 175.55,172.39 175.85,172.39 175.93,172.47 175.93,173.08 175.77,173.24 175.77,173.27 175.76,173.44 175.68,173.58 175.68,174.78 175.68,174.86 175.68,174.87 175.7,175 175.68,175.12 175.68,175.13 175.68,175.19 175.83,175.34 177.17,175.34 177.28,175.44 177.28,175.77 177.3,175.79 177.3,175.85 177.48,176.03 177.65,176.03
+3VS_TBT on IN2 (solid shape): outline of 1097 points within 171.65,157.28 182.31,171.75
+3VS_TBT on IN6 (solid shape): outline of 701 points within 176.22,168.43 183.63,175.89
+3VS_TOUCH on TOP (solid shape): 194.18,9.5 194.18,6.41 194.03,6.26 193.38,6.26 193.32,6.32 193.32,7.03 192.66,7.69 192.66,8.61 193.25,9.2 193.25,9.49 193.35,9.59 194.09,9.59
+5V_HDD on TOP (solid shape): 130.25,13.31 130.25,12.02 129.73,12.02 129.73,11.26 130.25,11.26 130.25,10.82 129.73,10.82 129.73,10.06 130.25,10.06 130.25,9.57 130.22,9.54 128.6,9.54 128.43,9.7 128.43,10.85 127.67,11.61 125.26,11.61 125.19,11.68 125.19,13.41 125.46,13.68 129.88,13.68
+5V_HDD on BOTTOM (solid shape): 128.95,13.32 128.95,11.07 128.67,10.78 126.54,10.78 126.29,11.03 126.29,13.25 126.61,13.57 128.7,13.57
+5V_PVDD on TOP (solid shape): 33.94,42.95 33.94,41.21 34.49,40.66 34.76,40.66 34.95,40.47 34.95,39.69 34.93,39.67 33.98,39.67 33.91,39.6 33.91,39.48 33.77,39.33 32.88,39.33 32.87,39.35 32.84,39.43 32.87,39.5 33.01,39.88 32.72,40.17 32.68,40.18 32.68,41.45 32.61,41.52 31.47,41.52 31.45,41.51 31.19,41.77 28.96,41.77 28.65,42.09 28.65,42.98 28.81,43.14 31.09,43.14 31.5,43.54 33.34,43.54
+5V_PVDD on BOTTOM (solid shape): 29.79,42.41 29.79,41.2 29.6,41.01 28.39,41.01 28.14,40.76 28.14,39.93 28.08,39.87 27.25,39.87 27.19,39.93 27.19,41.65 27.31,41.77 28.08,41.77 28.33,42.03 28.33,42.22 28.58,42.47 29.47,42.47 29.73,42.47
+5V_TOBII on TOP (solid shape): 155.58,168.08 155.58,167 156.16,166.42 156.16,164.82 154.14,162.81 148.97,162.81 147.47,164.3 147.47,165.41 147.7,165.64 148.22,165.64 148.75,165.1 148.75,164.57 149.55,163.78 149.55,163.77 150.45,163.77 150.5,163.82 151.62,163.82 151.76,163.96 152.81,163.96 152.82,163.95 153.14,163.95 153.15,163.96 153.19,163.96 154.77,165.55 155.09,165.55 155.38,165.84 155.48,166.22 155.19,166.48 155.17,166.48 155.14,166.52 155.14,168.14 155.2,168.2 155.46,168.2
+5V_USB_PWR1 on TOP (solid shape): 22.11,47.62 22.11,47.3 22.04,47.23 22.04,46.16 21.98,46.09 21.79,46.09 21.43,46.45 20.8,46.45 20.46,46.79 20.46,47.62 20.58,47.74 21.98,47.74
+5V_USB_PWR1 on BOTTOM (solid shape): outline of 282 points within 15.94,40.25 22.17,47.68
+5V_USB_PWR2 on TOP (solid shape): 327.41,13.56 327.41,12.55 327.24,12.39 326.35,12.39 326.24,12.5 325.07,12.5 324.95,12.62 324.95,13.72 325.04,13.82 327.15,13.82
+5V_USB_PWR2 on TOP (solid shape): 320.99,23.75 320.99,23 321.17,22.83 322.31,22.83 322.63,22.51 322.63,22.11 322.47,21.96 322.41,21.96 322.39,21.94 322.39,21.92 322.25,21.78 322.08,21.62 322.08,21.24 321.94,21.1 321.58,21.1 321.43,20.95 320.13,20.95 319.47,21.6 319.47,23.75 319.62,23.9 320.84,23.9
+5V_USB_PWR2 on IN1 (solid shape): outline of 352 points within 319.45,11.27 327.73,24.24
+5V_USBC_VBUS on BOTTOM (solid shape): 11.44,65.08 11.44,63.81 11.25,63.62 10.55,63.62 10.11,63.17 8.07,63.17 8.01,63.24 8.01,63.74 8.87,64.6 10.2,64.6 10.87,65.27 11.25,65.27
+5V_USBC_VBUS on BOTTOM (solid shape): 24.58,49.62 24.56,49.58 24.53,49.46 24.58,49.33 24.58,49.32 24.58,49.27 24.77,49.08 25.41,49.08 25.54,48.95 25.54,48.44 25.41,48.31 24.58,48.31 24.46,48.19 24.3,48.19 24.23,48.19 23.93,48.19 23.8,48.27 23.64,48.28 23.61,48.27 23.45,48.43 23.45,48.48 23.45,48.54 23.44,48.6 23.44,49.84 23.5,49.9 24.29,49.9
+5V_USBC_VBUS on BOTTOM (solid shape): 11.03,60.16 11.06,60.16 11.56,59.65 11.57,59.64 11.77,59.47 12.03,59.49 12.04,59.49 12.52,59.49 12.84,59.17 12.84,57.52 13.03,57.33 13.03,55.81 13.6,55.24 13.6,53.71 13.47,53.58 10.74,53.58 10.68,53.65 10.68,56.63 10.84,56.79 10.84,58.51 10.7,58.64 10.7,58.65 10.69,58.65 10.55,58.79 10.31,58.79 10.1,58.79 9.98,58.92 9.98,59.3 9.85,59.43 9.79,59.47 9.74,59.5 9.66,59.59 8.64,59.59 7.85,60.38 7.85,60.66 8.07,60.89 10.3,60.89
+5V_USBC_VBUS on IN2 (solid shape): outline of 1515 points within 6.41,48.12 26.36,64.06
+5VALW on TOP (solid shape): 223.15,169.18 223.15,167.15 222.71,166.71 221.35,166.71 221.24,166.83 221.24,169.12 221.49,169.38 222.94,169.38
+5VALW on TOP (solid shape): 318.91,24.76 318.91,22.7 318.77,22.56 318.02,22.56 317.12,23.47 317.12,24.51 317.43,24.83 318.83,24.83
+5VALW on TOP (solid shape): 224.86,29.33 224.86,28.63 224.74,28.5 224.1,28.5 223.66,28.06 223.47,28.06 223.34,28.18 223.34,29.33 223.47,29.45 224.74,29.45
+5VALW on TOP (solid shape): 22.02,44.1 22.02,41.99 21.98,41.95 21.22,41.95 21.11,41.84 19.88,41.84 19.82,41.9 19.82,42.41 19.95,42.54 20.2,42.54 21.83,44.16 21.95,44.16
+5VALW on TOP (solid shape): 34.62,53.58 34.62,53.11 34.61,53.1 34.58,52.95 34.61,52.8 34.62,52.79 34.62,52.57 35.06,52.12 35.06,52 34.93,51.87 34.3,51.87 34.17,52 34.17,52.12 33.92,52.38 33.92,53.71 33.98,53.78 34.43,53.78
+5VALW on TOP (solid shape): 29.92,49.2 29.92,48.92 30.68,48.92 30.68,48.95 30.82,48.95 30.83,48.93 30.83,48.92 30.84,48.92 30.94,48.82 31.06,48.82 31.12,48.76 31.12,47.36 30.93,47.17 29.35,47.17 29.23,47.28 29.23,47.39 29.13,47.39 28.96,47.55 28.52,47.55 28.52,48.25 28.96,48.7 28.96,49.33 29.09,49.46 29.66,49.46
+5VALW on TOP (solid shape): 39.98,49.09 39.98,48.41 39.43,48.41 39.43,47.71 39.49,47.71 39.49,47.65 39.51,47.65 39.51,47.62 39.98,47.62 39.98,47.21 39.43,47.21 39.43,46.51 39.49,46.51 39.49,46.45 39.51,46.45 39.51,46.42 39.92,46.42 39.92,43.13 39.49,43.13 39.49,42.43 39.92,42.43 39.92,41.93 39.49,41.93 39.49,41.23 39.92,41.23 39.92,40.65 39.7,40.43 38.25,40.43 36.83,41.86 36.83,42.24 36.24,42.83 36.24,43.57 36.13,43.68 36.13,44.52 36.44,44.83 36.44,45.17 36.44,46.26 36.83,46.64 36.83,47.47 38.6,49.24 39.83,49.24
+5VALW on TOP (solid shape): outline of 2151 points within 142.31,148.59 210.01,167.76
+5VALW on BOTTOM (solid shape): 62.96,19.59 62.96,18.48 63.99,17.45 63.99,16.58 63.93,16.51 60.54,16.51 59.4,17.66 59.4,19.27 59.54,19.42 60.19,19.42 60.36,19.24 60.36,18.72 60.58,18.49 60.9,18.49 61.39,18.99 61.64,18.99 61.79,19.14 61.79,19.64 61.9,19.74 62.81,19.74
+5VALW on BOTTOM (solid shape): 31.21,49.14 31.21,47.23 31.05,47.07 31.05,46.9 30.3,46.16 29.16,46.16 28.77,46.54 28.77,46.93 28.78,46.97 28.77,47.04 28.76,47.06 28.7,47.15 28.62,47.21 28.61,47.21 28.52,47.3 27.89,47.3 27.82,47.36 27.82,49.01 27.89,49.08 28.58,49.08 28.9,49.39 29.09,49.39 29.31,49.62 30.74,49.62
+5VALW on BOTTOM (solid shape): 205.62,163.38 205.62,161.41 205.81,161.22 206.49,161.22 206.85,160.87 207.2,161.22 207.78,161.22 207.91,161.09 207.91,161.08 208.7,160.28 208.7,156.19 208.52,156.01 206.97,156.01 206.78,156.2 206.7,156.58 206.32,156.66 205.47,157.52 205.47,157.88 205.39,157.95 205.39,157.97 205.37,158.04 205.33,158.12 205.1,158.27 204.83,158.2 203.67,158.2 203.5,158.37 203.5,160.99 203.14,161.35 203.14,161.37 203.07,161.48 202.97,161.56 202.94,161.57 202.94,163.4 203.02,163.49 203.22,163.49 203.44,163.27 203.45,163.27 203.6,163.12 203.6,163.11 203.65,163.06 204.1,163.06 204.34,163.3 204.34,163.54 204.4,163.6 205.39,163.6
+5VALW on BOTTOM (solid shape): outline of 405 points within 100.62,48.56 109.15,68.67
+5VALW on IN1 (solid shape): outline of 818 points within 312.7,10.9 322.21,24.91
+5VALW on IN1 (solid shape): outline of 3873 points within 147.08,156.11 210.09,185.16
+5VALW on IN2 (solid shape): outline of 4365 points within 142.44,154.87 208.83,184.72
+5VALW on IN3 (solid shape): outline of 1281 points within 116.19,147.51 146.07,167.76
+5VALW on IN4 (solid shape): outline of 3509 points within 36.1,43.16 149.76,181.78
+5VALW on IN6 (solid shape): outline of 499 points within 223.34,22.51 227.95,34.34
+5VALW on IN5: 113.44,147.56 113.44,164.88 122,164.88 122.71,164.17 123.36,163.74 124.13,163.58 140.12,163.58 141.55,164.17 142.14,165.6 142.14,175.38 147.01,175.38 147.01,182.24 173.43,182.24 173.43,175.82 156.47,175.82 156.47,167.42 150.53,161.47 146.84,161.47 132.94,147.56
+5VALW on IN5: outline of 124 points within 16.01,2.82 334.15,69.9
+5VALWP on TOP (solid shape): 41.56,48.85 42.62,48.85 43.28,48.19 43.28,40.59 43,40.3 40.49,40.3 40.19,40.61 40.19,46.55 39.64,46.55 39.64,47 40.19,47 40.19,47.75 39.64,47.75 39.64,48.2 40.19,48.2 40.19,48.86 40.23,48.9 41.51,48.9
+5VALWP on BOTTOM (solid shape): outline of 127 points within 30.68,40.12 47.48,46.85
+5VS on TOP (solid shape): 94.85,11.08 94.85,9.01 94.4,8.55 90.61,8.55 90.27,8.89 90.27,11.32 90.66,11.71 94.22,11.71
+5VS on TOP (solid shape): 108.09,22.98 108.09,21.83 107.9,21.64 106.82,21.64 105.8,22.66 105.8,23.74 105.99,23.93 107.13,23.93
+5VS on TOP (solid shape): 108.12,65.52 108.12,62.47 107.88,62.23 107.35,62.23 105.94,60.82 104.94,60.82 104.81,60.95 104.81,61.57 104.95,61.71 105.23,61.71 105.46,61.94 105.46,62.04 105.46,62.04 105.47,62.15 105.46,62.25 105.46,62.26 105.46,63.2 106.35,64.09 106.35,65.85 106.56,66.07 106.58,66.07 106.66,66.08 106.74,66.11 107.54,66.11
+5VS on TOP (solid shape): 229.63,8.52 229.61,8.28 229.73,8.08 229.73,8.06 230.03,7.76 230.03,7.1 228.62,5.7 228.47,5.7 227.02,4.25 204.16,4.25 202.71,5.69 202.71,7.49 202.83,7.6 206.46,7.6 206.76,7.3 207.51,7.3 207.63,7.19 207.63,6.4 208.09,5.95 225.69,5.95 228.35,8.62 229.54,8.62
+5VS on TOP (solid shape): 290.76,80.06 290.94,80.01 291.13,80.06 291.41,80.06 292.01,79.47 292.01,78.11 292.12,78 292.12,77.99 292.18,77.91 292.26,77.86 292.26,77.85 293.18,76.94 293.18,76 293.02,75.85 291.54,75.85 290.67,74.98 289.78,74.98 289.47,75.3 289.47,76.1 290.29,76.93 290.29,79.78 290.57,80.06
+5VS on TOP (solid shape): outline of 552 points within 129.85,2.62 162.39,15.17
+5VS on BOTTOM (solid shape): 45.16,51.62 45.16,50.66 44.65,50.16 44.65,49.01 44.59,48.95 42.74,48.95 42.36,49.33 42.36,51.68 42.55,51.87 44.9,51.87
+5VS on BOTTOM (solid shape): 226,171.84 226,170.35 225.62,169.96 224.67,169.96 224.33,170.3 224.33,171.8 224.43,171.9 225.94,171.9
+5VS on BOTTOM (solid shape): 35.76,53.14 35.76,50.41 35.63,50.28 33.16,50.28 33.09,50.35 33.09,50.79 33.16,50.85 33.85,50.85 34.19,51.19 34.19,53.16 34.39,53.36 35.53,53.36
+5VS on BOTTOM (solid shape): 149.81,5.45 149.81,5.07 149.17,4.44 149.17,1.39 148.73,0.94 146.77,0.94 146.68,1.04 146.68,2.4 146.31,2.76 146.31,4.91 146.44,5.04 147.07,5.04 147.68,5.64 149.61,5.64
+5VS on BOTTOM (solid shape): 163.3,11.96 163.3,8.96 162.73,8.39 162.73,6.41 162.6,6.29 162.16,6.29 161.97,6.48 161.97,8.42 162.19,8.65 162.19,10.46 162.03,10.62 158.59,10.62 158.12,10.15 155.96,10.15 155.84,10.28 155.84,11.93 156.22,12.31 162.95,12.31
+5VS on BOTTOM (solid shape): 58.48,14.54 58.5,14.54 58.5,14.53 59,14.53 59,14.54 59.02,14.54 59.02,15.06 59.26,15.06 59.28,15.05 59.28,14.54 59.3,14.54 59.3,14.53 59.72,14.53 61.06,13.2 62.38,13.2 62.59,12.99 62.59,10.98 62.28,10.66 60.62,10.66 60.57,10.66 57.98,10.66 57.58,11.06 57.58,12.89 56.93,13.54 56.93,14.39 57.07,14.53 58.2,14.53 58.2,14.54 58.22,14.54 58.22,15.06 58.48,15.06
+5VS on BOTTOM (solid shape): outline of 202 points within 274.48,22.43 285.12,34.44
+5VS on IN1 (solid shape): 224.71,153.95 224.71,153.01 224.48,152.78 223.53,152.78 222.65,153.66 222.65,154.35 222.86,154.55 224.11,154.55
+5VS on IN1 (solid shape): 292.99,77.83 292.99,76.91 292.44,76.37 291.54,76.37 291.11,76.8 291.11,77.96 291.26,78.11 292.71,78.11
+5VS on IN1 (solid shape): 225.68,170.89 225.68,169.98 225.62,169.93 223.87,169.93 223.61,170.2 223.61,170.89 223.83,171.12 225.45,171.12
+5VS on IN1 (solid shape): 300.1,65.05 300.76,63.44 302.37,62.78 305.67,62.78 305.75,62.73 305.76,62.64 306.09,62.14 306.42,62.64 306.43,62.73 306.51,62.78 308.24,62.78 308.24,61.72 308.07,61.56 305.53,61.56 305.31,61.78 305.27,61.78 305.26,61.79 304.97,61.92 304.7,61.78 302.18,61.78 301.91,61.9 301.63,61.78 301.43,61.78 301.13,61.95 300.82,61.78 300.11,61.78 299.01,62.88 298.98,62.95 299,63.02 299.07,63.33 298.87,63.57 298.84,63.58 298.84,65.21 298.97,65.33 300.1,65.33
+5VS on IN1 (solid shape): outline of 683 points within 58.81,8.06 94.37,13.33
+5VS on IN3 (solid shape): 284.57,24.59 284.57,21.07 284.37,20.87 283.09,20.87 282.96,21 282.96,24.77 283.09,24.91 284.25,24.91
+5VS on IN3 (solid shape): 283.9,9.11 283.9,7.06 283.63,6.79 281.9,6.79 281.69,7 281.69,7.42 282.23,7.97 282.23,8.47 282.22,8.49 282.22,8.98 282.55,9.31 283.7,9.31
+5VS on IN4 (solid shape): 109.04,62.86 109.04,61.14 108.66,60.76 106.12,60.76 105.8,61.08 105.8,63.05 105.93,63.17 108.72,63.17
+5VS on IN4 (solid shape): outline of 85 points within 106.75,22.6 109.36,28.18
+5VS on IN4 (solid shape): outline of 3983 points within 30.37,7.92 96.74,53.9
+5VS on IN5: 134.79,1.02 134.79,3.8 134.2,5.23 132.77,5.82 97.49,5.82 96.89,7.23 95.47,7.82 90.69,7.82 90.69,10.93 93.21,13.45 104.3,13.45 108.17,9.58 163.31,9.58 169.21,15.48 182.72,15.48 188.63,9.58 250.11,9.58 259.19,18.66 265.14,18.66 274.22,9.58 332.79,9.58 334.65,11.44 334.65,47.02 332.35,49.33 322.12,49.33 312.98,58.47 307.2,58.47 307.09,58.58 307.09,63.03 321.4,63.03 321.4,54.6 321.99,53.17 323.42,52.58 337.4,52.58 337.4,5.82 231.78,5.82 231.01,5.66 230.36,5.23 228.95,3.82 183.84,3.82 182.43,5.23 181.78,5.66 181.01,5.82 178.4,5.82 177.53,5.62 176.83,5.06 175.43,3.32 156.07,3.32 154.64,2.73 154.05,1.3 154.05,1.02 ; 1 cut-out
+5VS_TP_LED on TOP (solid shape): 197.75,12.63 197.75,11.67 197.49,11.42 196.67,11.42 196.48,11.61 196.48,12.63 196.73,12.88 197.49,12.88
+5VS_TP_LED on TOP (solid shape): 202.64,9.01 203.97,9.01 204.16,8.82 204.16,7.99 204.03,7.86 201.62,7.86 201.49,7.99 201.49,8.69 200.61,9.58 200.61,9.83 200.92,10.15 201.49,10.15
+5VS_TP_LED on BOTTOM (solid shape): 197.41,13.33 197.41,12.31 197.62,12.1 197.62,11.48 197.42,11.28 196.42,11.28 196.17,11.54 196.17,13.5 196.26,13.59 197.15,13.59
+5VS_TP_LED on IN3 (solid shape): 196.73,12.12 197.56,12.12 197.68,11.99 197.68,11.61 197.56,11.48 196.69,11.48 196.58,11.6 196.17,11.6 196.07,11.7 196.06,11.77 196.03,11.84 196.03,12.44 196.41,12.44
+AVDD09 on BOTTOM (solid shape): 22.87,57.94 22.87,56.7 22.74,56.58 20.61,56.58 20.52,56.67 20.52,57.24 20.53,57.26 20.68,57.34 20.77,57.49 20.78,57.5 20.96,57.69 20.96,57.94 21.03,58 22.81,58
+AVDD09 on BOTTOM (solid shape): 18.3,50.22 18.3,49.44 18.21,48.92 18.74,48.89 18.87,48.89 19.31,49.33 19.82,49.33 19.96,49.19 19.97,49.17 20.06,49 20.23,48.91 20.25,48.9 20.27,48.89 21.22,48.89 21.34,49.01 21.42,48.94 21.68,48.39 22.05,48.87 22.05,48.95 22.11,49 22.34,49.34 22.11,49.67 22.1,49.68 22.04,49.73 22.04,50.22 22.11,50.28 22.61,50.28 23.19,49.71 23.19,48.97 23.16,48.89 23.09,48.86 22.77,48.65 22.83,48.27 22.85,48.21 22.83,48.15 22.77,48.04 22.75,47.91 22.73,47.84 22.65,47.81 22.06,47.81 22.05,47.81 21.9,47.84 21.75,47.81 21.74,47.81 21.48,47.81 21.47,47.81 21.32,47.84 21.17,47.81 21.16,47.81 20.84,47.81 20.83,47.81 20.68,47.84 20.53,47.81 20.52,47.81 17.85,47.81 17.6,48.06 17.6,49.04 17,49.63 16.7,49.63 16.57,49.76 16.57,50.19 16.66,50.28 18.23,50.28
+AVDD09 on IN4 (solid shape): 22.87,57.71 22.87,56.75 22.72,56.59 21.83,56.59 21.54,56.3 21.54,51.74 21.09,51.3 20.33,51.3 18.52,49.49 18.5,49.5 18.24,49.39 18.13,49.12 18.13,49.1 18.04,49.01 17.79,49.01 17.41,49.39 17.41,50.16 18.29,51.04 18.3,51.04 18.42,51.12 18.5,51.24 18.5,51.25 19.54,52.29 19.61,52.32 19.69,52.29 20.19,52.29 20.19,52.79 20.16,52.87 20.19,52.94 20.2,52.95 20.2,53.5 20.29,53.74 20.2,53.97 20.2,56.44 21.59,57.83 22.75,57.83
+AVDD09 on IN2: 17.41,47.82 17.61,47.62 22.59,47.62 23.08,48.11 23.08,49.52 22.2,50.4 17.61,50.4 17.41,50.19
+AVDDL on TOP (solid shape): 272.98,167.62 272.98,166.96 272.83,166.8 272.2,166.8 272.2,166.8 272.07,166.8 272.01,166.74 272.01,166.08 271.94,166.02 269.45,166.02 269.43,166.03 269.43,166.63 269.52,166.71 269.77,166.71 270.34,167.29 270.47,167.29 270.9,167.71 272.89,167.71
+AVDDL on IN2 (solid shape): outline of 345 points within 270.23,158.59 276.56,167.27
+DVDD09 on BOTTOM (solid shape): 15.31,51.62 15.31,51.11 15.5,50.92 15.63,50.92 15.76,50.79 15.76,50.16 15.69,50.09 14.68,50.09 14.61,50.16 14.61,50.35 14.67,50.53 14.62,50.71 14.61,50.72 14.61,50.85 14.49,50.98 14.23,50.98 14.04,51.17 14.04,51.49 14.26,51.71 14.28,51.7 14.37,51.71 14.45,51.74 14.46,51.74 15.19,51.74
+PVDD on TOP (solid shape): 39.82,9.01 39.82,8.56 39.76,8.5 38.43,8.5 38.17,8.75 37.28,8.75 37.16,8.88 37.16,9.07 37.22,9.13 39.7,9.13
+PVDD on TOP (solid shape): 36.84,8.44 36.84,7.86 36.9,7.8 37.22,7.8 38.05,6.98 38.24,6.98 38.3,6.91 38.3,6.59 38.24,6.53 38.05,6.53 37.09,7.48 36.71,7.48 36.54,7.66 36.54,8.45 36.6,8.51 36.76,8.51
+PVDD on TOP (solid shape): 30.95,9.06 30.95,9.05 31.49,8.51 31.49,8.51 31.55,8.45 31.55,7.47 30.99,6.91 29.87,6.91 29.48,6.51 29.48,6.21 29.46,6.18 28.81,6.18 28.77,6.22 28.77,7.17 28.96,7.36 28.96,8.06 29.03,8.12 29.51,8.12 29.8,8.42 29.8,8.82 30.12,9.13 30.88,9.13
+PVDD on BOTTOM (solid shape): outline of 90 points within 27.76,4.55 38.68,12.47
+V18R on TOP (solid shape): 309.42,22.11 309.09,22.11 308.93,22.27 306.3,22.27 306.23,22.34 306.23,22.46 306.35,22.58 308.78,22.58 309.04,22.84 309.42,22.84
+VCC_CORE on TOP (solid shape): outline of 2725 points within 146.39,102.41 179.4,137.53
+VCC_CORE on BOTTOM (solid shape): outline of 183 points within 148.15,102.87 154.09,104.57
+VCC_CORE on BOTTOM (solid shape): outline of 394 points within 154.68,102.87 168.23,104.57
+VCC_CORE on BOTTOM (solid shape): outline of 2240 points within 147.84,115.3 179.99,139.17
+VCC_CORE on IN1 (solid shape): outline of 5785 points within 145.73,102.68 179.9,137.53
+VCC_CORE on IN2 (solid shape): outline of 4899 points within 145.73,102.71 168.25,126.23
+VCC_CORE on IN3 (solid shape): outline of 3941 points within 145.8,103.01 167.5,125.58
+VCC_CORE on IN4 (solid shape): outline of 4143 points within 145.8,102.98 167.5,125.57
+VCC_CORE on IN6 (solid shape): outline of 3947 points within 145.32,105.45 166.14,126.03
+VCC_CORE on IN5: 167.18,103.09 153.58,103.15 153.37,103.15 145.83,103.15 145.83,108.13 146.87,109.17 146.87,116.18 148.6,117.91 148.6,121.61 150.12,123.14 150.12,132.87 147.9,135.1 147.9,138.42 154.91,138.42 158.08,135.25 179.16,135.25 179.84,134.57 179.84,126.91 178.57,125.63 165.82,125.63 164.78,124.59 164.78,117.47 164.73,117.42 164.73,112.28 166.3,110.7 166.3,104.89 167.46,103.73 167.46,103.16 167.39,103.09
+VCCGT on TOP (solid shape): outline of 2092 points within 132.06,103.13 149.72,137.9
+VCCGT on BOTTOM (solid shape): outline of 94 points within 138.8,102.96 146.77,104.76
+VCCGT on BOTTOM (solid shape): outline of 2215 points within 131.8,103.64 149.71,137.98
+VCCGT on IN1 (solid shape): outline of 3284 points within 132.18,103.29 149.68,137.85
+VCCGT on IN2 (solid shape): outline of 3747 points within 133.1,103.18 151.65,126.24
+VCCGT on IN3 (solid shape): outline of 2735 points within 132.98,103.11 151.71,126.55
