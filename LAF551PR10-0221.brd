# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FB_C_CMD14: length 27.4
  BOTTOM w0.102: 226.41,75.19 229.77,78.55 229.77,81.84 229.62,81.98 229.62,82.91 229.82,83.1 229.82,83.37 230.17,83.72 UG9.C17
  BOTTOM w0.185: UG5.K10 222.41,61.51 221.82,62.09 221.82,67.56 223.21,68.95 224.8,68.95 226.41,70.57 226.41,75.19
FB_C_CMD15: length 28.4
  BOTTOM w0.102: UG9.B17 230.17,83.1 229.82,82.75 229.82,82.36 230.22,81.96 230.22,79.23 230.19,79.2 230.19,78.27 227.19,75.27
  BOTTOM w0.185: UG5.L12 223.78,61.9 222.45,61.9 222.2,62.16 222.2,67.47 223.29,68.57 225.75,68.57 227.19,70 227.19,75.27
FB_C_CMD16: length 33
  BOTTOM w0.102: UG9.B24 235.07,83.05 235.42,82.7 235.42,78.94
  BOTTOM w0.185: UG6.L3 243.59,59.51 244.99,59.51 245.13,59.36 245.59,59.36 247.23,61.01 247.23,68.37 244.75,70.86 243.51,70.86 235.42,78.94
FB_C_CMD17: length 31.8
  TOP w0.102: RG52.2 243.65,60.25 v2(243.59,60.31)
  BOTTOM w0.102: UG6.J3 243.37,60.53 243.37,60.53 v2(243.59,60.31) ; UG9.A24 235.07,78.77
  BOTTOM w0.185: 235.07,78.77 236.39,77.45 236.39,77.2 243.32,70.28 244.56,70.28 246.69,68.15 246.69,61.25 245.73,60.29 243.61,60.29 v2(243.59,60.31)
FB_C_CMD18: length 31.9
  TOP w0.102: RG57.1 244.5,61.22 v2(244.39,61.11)
  BOTTOM w0.102: UG9.D23 234.72,84.3 234.72,78.11 ; v2(244.39,61.11) 244.13,60.86 UG6.J2
  BOTTOM w0.185: 234.72,78.11 243.63,69.21 244.87,69.21 246.15,67.92 246.15,61.67 245.7,61.21 245.29,61.21 245.19,61.11 v2(244.39,61.11)
FB_C_CMD19: length 28.3
  BOTTOM w0.102: 245.37,62.26 245.34,62.26 ; UG9.A23 234.45,82.47 234.45,77.61
  BOTTOM w0.142: 245.34,62.26 244.99,61.91 243.59,61.91 UG6.G3 ; 245.61,62.92 245.61,62.5 245.37,62.26
  BOTTOM w0.185: 234.45,77.61 243.58,68.49 244.82,68.49 245.61,67.7 245.61,62.92
FB_C_CMD20: length 25.5
  BOTTOM w0.102: UG9.B23 234.37,83.1 234.01,82.74 234.01,82.22 234.2,82.03 234.2,77.1
  BOTTOM w0.185: UG6.H5 241.18,61.91 241.18,67.63 241.71,68.16 241.71,69.59 234.2,77.1
FB_C_CMD21: length 27.4
  BOTTOM w0.102: UG9.C23 234.02,83.6 234.02,83.1 233.82,82.9 233.82,76.72
  BOTTOM w0.185: UG6.H4 241.99,61.11 241.44,61.11 240.89,61.65 240.89,67.75 240.94,67.79 240.94,69.6 233.82,76.72
FB_C_CMD22: length 27.3
  BOTTOM w0.102: UG9.C21 232.97,83.8 233.32,83.45 233.32,83.05 233.56,82.81 233.56,82.1 233.5,82.03 233.5,76
  BOTTOM w0.185: UG6.J5 241.19,60.71 240.61,61.29 240.61,67.87 240.64,67.9 240.64,69.13 238.91,70.86 238.64,70.86 235.7,73.79 235.02,74.48 233.5,76
FB_C_CMD23: length 28.2
  BOTTOM w0.102: 233.18,75.55 233.18,82.12 233.28,82.22 233.28,82.28 233.33,82.32 233.33,82.69 232.97,83.05 UG9.B21
  BOTTOM w0.185: UG6.J4 241.99,60.31 240.89,60.31 240.32,60.88 240.32,67.99 240.34,68.01 240.34,68.68 238.66,70.36 238.37,70.36 233.18,75.55
FB_C_CMD24: length 27
  BOTTOM w0.102: UG9.A21 232.91,82.55 232.91,75.06
  BOTTOM w0.185: UG6.K5 240.79,59.91 240.03,60.66 240.03,68.11 240.04,68.11 240.04,68.28 238.42,69.9 238.31,69.9 238.24,69.97 238,69.97 232.91,75.06
FB_C_CMD25: length 31.1
  BOTTOM w0.102: 232.41,74.79 232.41,81.1 232.62,81.31 232.62,84.3 UG9.D20 ; 242.39,59.91 UG6.K4
  BOTTOM w0.185: 242.39,59.91 241.99,59.51 240.64,59.51 239.74,60.41 239.74,68.13 238.29,69.58 238.23,69.58 238.12,69.68 237.52,69.68 232.41,74.79
FB_C_CMD26: length 30.1
  BOTTOM w0.102: UG9.A20 232.27,81.46 232.06,81.25 232.06,75.94 231.72,75.6
  BOTTOM w0.185: UG6.L12 236.39,59.51 238.49,59.51 239.44,60.46 239.44,67.96 238.01,69.39 237.04,69.39 231.72,74.72 231.72,75.6
FB_C_CMD27: length 29.2
  BOTTOM w0.102: UG9.B20 232.27,83.1 231.95,82.78 231.95,82.69 231.94,82.69 231.94,82.42 231.95,82.41 231.95,81.57 231.73,81.34 231.73,76.31 230.99,75.57
  BOTTOM w0.185: UG6.K10 238.39,59.91 239.15,60.68 239.15,67.84 237.89,69.11 236.56,69.11 234.76,70.91 230.99,74.68 230.99,75.57
FB_C_CMD28: length 30.8
  BOTTOM w0.102: 230.58,75.86 231.43,76.71 231.43,79.15 231.43,79.15 231.43,81.6 231.71,81.87 231.71,82.89 231.92,83.1 231.92,83.6 UG9.C20
  BOTTOM w0.185: UG6.K11 237.19,60.31 238.34,60.31 238.87,60.84 238.87,67.72 237.77,68.82 235.88,68.82 230.58,74.12 230.58,75.86
FB_C_CMD29: length 30.3
  BOTTOM w0.102: 236.79,61.51 UG6.H11 ; UG9.C18 230.87,83.8 231.22,83.45 231.22,83.05 231.45,82.82 231.45,82.15 231.15,81.84 231.15,77.13 230.01,75.99
  BOTTOM w0.185: 236.79,61.51 237.19,61.11 237.79,61.11 237.89,61.21 238.29,61.21 238.58,61.5 238.58,67.6 237.65,68.53 235.4,68.53 230.01,73.93 230.01,75.99
FB_C_CMD30: length 29.7
  BOTTOM w0.102: UG9.B18 230.87,83.05 231.22,82.7 231.22,82.37 230.88,82.03 230.88,77.56 228.73,75.41
  BOTTOM w0.185: UG6.H10 237.93,61.51 238.29,61.88 238.29,67.48 237.53,68.25 235.19,68.25 234.58,68.86 234.29,68.86 232.23,70.92 230.89,70.92 228.73,73.08 228.73,75.41
FB_C_CMD31: length 30.6
  BOTTOM w0.102: 227.96,75.34 230.54,77.92 230.54,82.22 UG9.A18
  BOTTOM w0.185: 227.96,75.34 227.96,73.08 230.66,70.38 232,70.38 234.13,68.25 234.72,68.25 235.01,67.96 237.41,67.96 238.01,67.36 238.01,62.18 237.74,61.91 236.39,61.91 UG6.G12
FB_C_D0: length 20.3
  IN6 w0.102: 221.62,79.75 221.62,81.7 221.93,82.01 221.93,83.37 v2(222.81,84.24)
  IN6 w0.13: 221.62,79.75 219.32,77.44 219.32,74.39 217.09,72.16 217.09,68.06 v2(217.18,67.97)
  BOTTOM w0.102: UG5.U4 217.52,67.38 217.52,67.38 217.18,67.72 v2(217.18,67.97) ; v2(222.81,84.24) 222.76,84.24 UG9.C6
FB_C_D1: length 20.5
  IN6 w0.102: v2(221.23,80.91) 221.23,80.37
  IN6 w0.13: 221.23,80.37 218.64,77.78 218.64,74.67 216.53,72.55 216.53,68.61 215.79,67.87 v2(215.79,67.51)
  BOTTOM w0.102: v2(221.23,80.91) 222.13,81.81 222.13,84.31 UG9.D6 ; UG5.U2 216,67.3 216,67.3 v2(215.79,67.51)
FB_C_D2: length 19.6
  IN6 w0.102: 222.97,79.75 223.13,79.75 223.49,80.11 223.49,81.33 223.1,81.73 v2(222.81,81.73)
  IN6 w0.13: 222.97,79.75 220.48,77.25 220.48,73.96 218.21,71.7 218.21,67.53 v2(217.39,66.71)
  BOTTOM w0.102: UG9.A6 222.47,82.07 v2(222.81,81.73) ; UG5.T4 217.62,66.47 v2(217.39,66.71)
FB_C_D3: length 20.7
  IN6 w0.102: v2(222.77,82.95) 222.33,82.51 222.33,81.74 222.09,81.5 222.09,79.52
  IN6 w0.13: 222.09,79.52 219.88,77.3 219.88,74.15 217.65,71.93 217.65,67.59 217.17,67.11 216.19,67.11 v2(215.79,66.71)
  BOTTOM w0.102: v2(215.79,66.71) 216,66.5 UG5.T2 ; UG9.B6 v2(222.77,82.95)
FB_C_D4: length 26.2
  IN6 w0.102: 219.92,80.33 219.92,82.1 v2(220.77,82.95)
  IN6 w0.13: v2(217.39,63.51) 216.99,63.91 214.69,63.91 213.76,64.84 213.76,71.5 217.45,75.19 217.45,77.86 219.92,80.33
  BOTTOM w0.102: v2(220.77,82.95) UG9.B4 ; UG5.N4 217.62,63.75 v2(217.39,63.51)
FB_C_D5: length 22.6
  IN6 w0.102: v2(220.44,81.4) 220.35,81.31 220.35,80.19 218.01,77.85
  IN6 w0.13: v2(215.79,64.31) 215.39,64.71 214.75,64.71 214.32,65.14 214.32,71.27 218.01,74.96 218.01,77.85
  BOTTOM w0.102: v2(215.79,64.31) UG5.N2 ; v2(220.44,81.4) 221.03,81.98 221.03,82.51 UG9.A4
FB_C_D6: length 29.4
  IN6 w0.13: v2(219.12,81.4) 216.32,78.6 216.32,75.65 211.68,71.01 211.68,65.16 214.64,62.21 216.89,62.21 v2(217.39,62.71)
  BOTTOM w0.102: UG9.B3 220.02,82.9 220.02,82.3 v2(219.12,81.4) ; UG5.M4 217.61,62.93 v2(217.39,62.71)
FB_C_D7: length 27.4
  IN6 w0.102: 219.52,81.22 219.52,82.1 220.27,82.85 220.27,83.15 v2(220.77,83.65)
  IN6 w0.13: v2(215.79,63.51) 215.39,63.11 214.53,63.11 212.25,65.39 212.25,70.78 216.89,75.42 216.89,78.25 219.52,80.88 219.52,81.22
  BOTTOM w0.102: UG9.C4 v2(220.77,83.65) ; v2(215.79,63.51) UG5.M2
FB_C_D8: length 18.9
  IN1 w0.13: v2(223.79,67.51) 224,67.72 224,78.02 225.19,79.21 225.19,82.05 224.47,82.77 224.47,83.95 v2(224.87,84.35)
  BOTTOM w0.102: UG5.U11 223.56,67.28 v2(223.79,67.51) ; UG9.D9 v2(224.87,84.35)
FB_C_D9: length 17.7
  IN1 w0.13: v2(225.39,67.51) 225.39,78.56 225.86,79.03 225.86,82.66 v2(224.87,83.65)
  BOTTOM w0.102: UG9.C9 v2(224.87,83.65) ; UG5.U13 225.15,67.27 225.15,67.27 v2(225.39,67.51)
FB_C_D10: length 20.5
  IN1 w0.13: v2(223.79,66.71) 223.39,67.11 223.39,78.35 224.22,79.18 224.22,81.9 224.06,82.06 224.06,84.26 v2(225,85.2)
  BOTTOM w0.102: v2(223.79,66.71) 223.79,66.71 UG5.T11 ; v2(225,85.2) 224.72,85.2 UG9.E9
FB_C_D11: length 17.8
  IN2 w0.117: v2(224.64,81.88) 225.07,81.45 225.07,69.77 224.99,69.69 224.99,67.11 v2(225.39,66.71)
  BOTTOM w0.102: UG9.B9 224.22,82.9 224.22,82.3 v2(224.64,81.88) ; v2(225.39,66.71) UG5.T13
FB_C_D12: length 22.2
  IN1 w0.13: v2(222.5,80.87) 221.9,80.26 221.9,79.77 221.2,79.07 221.2,65.99 222.48,64.71 223.19,64.71 223.59,64.31 v2(223.79,64.31)
  BOTTOM w0.102: v2(222.5,80.87) 222.53,80.87 223.51,81.84 223.51,82.89 UG9.B8 ; UG5.N11 v2(223.79,64.31)
FB_C_D13: length 22.4
  IN1 w0.13: v2(223.08,80.22) 223.08,80.02 221.76,78.7 221.76,66.44 222.69,65.51 223.19,65.51 223.39,65.31 223.39,64.91 223.59,64.71 224.99,64.71 v2(225.39,64.31)
  BOTTOM w0.102: v2(225.39,64.31) 225.15,64.07 UG5.N13 ; UG9.A8 223.87,80.87 223.22,80.22 v2(223.08,80.22)
FB_C_D14: length 27.3
  IN1 w0.13: v2(223.79,63.51) UG5.M11 222.23,63.11 220.08,65.26 220.08,80.48 220.61,81.01 221.46,81.86 221.64,81.86 221.86,82.08 221.86,82.42 221.85,82.43 221.85,82.77 221.86,82.78 221.86,83.12 221.85,83.13 221.85,83.47 221.86,83.48 221.86,83.82 221.85,83.83 221.85,84.77 221.86,84.78 221.86,85.12 221.85,85.13 221.85,85.43 v2(222.17,85.75)
  BOTTOM w0.102: UG5.M11 v2(223.79,63.51) ; UG9.F6 v2(222.17,85.75)
FB_C_D15: length 27.5
  IN1 w0.13: v2(225.39,63.51) 224.99,63.91 222.36,63.91 220.64,65.63 220.64,79.72 222.36,81.44 222.36,85.24 v2(222.77,85.65)
  BOTTOM w0.102: v2(225.39,63.51) 225.18,63.3 UG5.M13 ; v2(222.77,85.65) UG9.E6
FB_C_D16: length 43.2
  IN1 w0.13: v2(231.27,86.45) 231.58,86.14 232.24,86.14 232.4,85.98 232.4,85.21 232.21,85.02 232.21,82.76 231,81.55 231,75.62 231.15,75.47 231.15,56.09 227.66,52.61 224.21,52.61 223.88,52.94 223.88,53.11 223.28,53.71 223.19,53.71 v2(222.99,53.91)
  BOTTOM w0.102: UG5.A11 223.39,54.31 v2(222.99,53.91) ; UG9.F18 v2(231.27,86.45)
FB_C_D17: length 38.3
  IN1 w0.13: v2(225.39,53.91) 226.21,53.91 226.39,53.73 227.19,53.73 229.94,56.48 229.94,71.9 229.42,72.42 229.42,81.7 230.73,83.01 230.73,86.61 v2(231.17,87.05)
  BOTTOM w0.102: v2(225.39,53.91) UG5.A13 ; UG9.G18 v2(231.17,87.05)
FB_C_D18: length 40.4
  IN1 w0.13: v2(222.99,54.71) 223.39,54.31 223.96,54.31 224.19,54.08 224.19,53.65 224.31,53.53 224.47,53.53 224.83,53.17 227.43,53.17 230.51,56.25 230.51,74.73 230.39,74.86 230.39,81.79 231.26,82.66 231.26,82.99 231.87,83.6 231.87,84.35 v2(231.17,85.05)
  BOTTOM w0.102: v2(231.17,85.05) UG9.E18 ; v2(222.99,54.71) 223.2,54.93 UG5.B11
FB_C_D19: length 39.7
  IN1 w0.13: v2(224.59,54.71) 224.98,54.32 225.22,54.32 225.22,54.31 225.55,54.31 225.55,54.32 226.02,54.32 226.02,54.31 226.35,54.31 226.35,54.32 226.59,54.32 226.61,54.29 226.96,54.29 229.37,56.7 229.37,71.68 228.86,72.19 228.86,82.06 230.28,83.48 230.28,86.86 v2(231.34,87.93)
  BOTTOM w0.102: UG9.H18 v2(231.34,87.93) ; UG5.B13 224.8,54.92 v2(224.59,54.71)
FB_C_D20: length 33.9
  IN1 w0.13: v2(223.79,57.11) 224.19,56.71 227.69,56.71 228.8,57.82 228.8,71.46 228.3,71.96 228.3,82.49 229.13,83.32 229.13,84 v2(229.31,84.18)
  BOTTOM w0.102: UG9.D15 228.79,84.65 229.26,84.18 v2(229.31,84.18) ; v2(223.79,57.11) UG5.E11
FB_C_D21: length 33.2
  IN1 w0.13: v2(229.27,85.58) 228.85,85.16 228.85,84.53 228.67,84.35 228.67,83.44 227.74,82.51 227.74,71.47 228.23,70.98 228.23,58.59 227.15,57.51 UG5.E13 v2(224.59,57.91)
  BOTTOM w0.102: UG5.E13 224.81,57.69 v2(224.59,57.91) ; v2(229.27,85.58) 229,85.58 UG9.E15
FB_C_D22: length 33.1
  IN1 w0.13: v2(229.77,86.45) 229.43,86.11 229.15,86.11 228.47,85.43 228.47,84.79 228.19,84.51 228.19,83.54 227.18,82.53 227.18,78.95 226.95,78.72 226.95,60.72 226.33,60.1 226.32,60.1 226.09,59.87 226.09,59.87 225.79,59.57 225.79,58.56 225.78,58.55 225.78,58.55 225.55,58.31 224.19,58.31 v2(223.79,57.91)
  BOTTOM w0.102: UG9.G17 230.12,86.75 229.82,86.45 v2(229.77,86.45) ; UG5.F11 v2(223.79,57.91)
FB_C_D23: length 32.5
  IN1 w0.13: v2(225.39,58.71) 225.39,59.9 226.59,61.1 226.59,67.67 226.39,67.87 226.39,78.92 226.56,79.09 226.56,82.46 227.64,83.54 227.64,84.55 228.07,84.98 228.07,86 228.22,86.15 228.22,86.81 228.86,87.45 229.57,87.45 v2(229.87,87.75)
  BOTTOM w0.102: UG5.F13 225.16,58.48 225.16,58.49 v2(225.39,58.71) ; UG9.H17 v2(229.87,87.75)
FB_C_D24: length 41
  IN6 w0.102: 227.91,78.1 227.91,82.46 228.17,82.72 228.17,83.82 228.3,83.95 228.3,87.69 229.06,88.45 v2(229.07,88.45)
  IN6 w0.13: 227.91,78.1 224.8,74.99 224.8,70.28 222.95,68.43 222.43,67.91 222.43,61.12 222.52,61.03 222.52,60.46 221.62,59.56 221.62,57.01 220.61,56 220.61,54.92 219.59,53.9 218.1,53.9 v2(218.09,53.91)
  BOTTOM w0.102: UG5.A4 217.79,54.22 v2(218.09,53.91) ; UG9.J15 v2(229.07,88.45)
FB_C_D25: length 43
  IN6 w0.089: v2(229.22,87.9) 229.21,87.9
  IN6 w0.102: 229.21,87.9 228.51,87.2 228.51,82.1 228.33,81.92 228.33,77.63
  IN6 w0.13: v2(216.59,53.91) 216.98,53.51 219.97,53.51 221.37,54.92 221.37,55.43 222.51,56.57 222.51,59.57 223.18,60.23 223.18,61.37 223.39,61.58 223.39,67.98 225.43,70.02 225.43,74.73 228.33,77.63
  BOTTOM w0.102: UG9.H15 v2(229.22,87.9) ; v2(216.59,53.91) 216.38,54.12 UG5.A2
FB_C_D26: length 36.4
  IN6 w0.102: v2(227.64,85.61) 227.9,85.35 227.9,84.6 227.59,84.29 227.59,83.53 226.83,82.77 226.83,79.14
  IN6 w0.13: 226.83,79.14 223.47,75.78 223.47,70.83 221.13,68.49 221.13,61.58 220.54,60.99 220.54,57.91 219.46,56.83 219.46,55.44 219.38,55.35 219.38,55.35 219.15,55.11 219.14,55.11 219.14,55.11 218.59,55.11 v2(218.19,54.71)
  BOTTOM w0.102: UG9.E14 227.81,85.61 v2(227.64,85.61) ; v2(218.19,54.71) 217.96,54.94 217.96,54.94 UG5.B4
FB_C_D27: length 39.6
  IN6 w0.102: v2(227.77,86.35) 228.11,86.01 228.11,84.51 227.86,84.27 227.86,83.17 227.47,82.78 227.47,78.58
  IN6 w0.13: v2(216.59,54.71) 217.43,54.71 217.84,54.3 217.92,54.3 217.93,54.3 218.26,54.3 218.26,54.3 219.16,54.3 219.97,55.11 219.97,56.38 221.07,57.48 221.07,60.62 221.75,61.3 221.75,68.16 223.61,70.02 224.15,70.56 224.15,75.26 227.47,78.58
  BOTTOM w0.102: v2(216.59,54.71) 216.37,54.93 216.36,54.93 UG5.B2 ; UG9.F14 v2(227.77,86.35)
FB_C_D28: length 36.7
  IN6 w0.102: v2(225.67,87.75) 226.58,86.84 226.58,83.57 226.37,83.36 226.37,79.55 226,79.18 225.97,79.18
  IN6 w0.13: v2(217.39,57.91) 217.79,57.51 219.22,57.51 219.93,58.22 219.93,61.13 220.46,61.66 220.46,68.72 222.83,71.09 222.83,76.04 225.97,79.18
  BOTTOM w0.102: UG9.H11 v2(225.67,87.75) ; UG5.E4 v2(217.39,57.91)
FB_C_D29: length 37.3
  IN6 w0.102: 225.75,79.86 225.75,83.29 226.22,83.76 226.22,84.74 226.27,84.79 226.27,86.3 225.82,86.75 225.17,86.75 v2(225.12,86.7)
  IN6 w0.13: 225.75,79.86 222.19,76.3 222.19,71.35 220.04,69.2 219.93,69.09 219.93,62.02 219.53,61.62 219.53,58.54 219.3,58.31 216.19,58.31 v2(215.79,57.91)
  BOTTOM w0.102: UG9.G11 225.17,86.75 v2(225.12,86.7) ; UG5.E2 215.79,57.91 v2(215.79,57.91)
FB_C_D30: length 31.4
  IN6 w0.102: 225.12,80.09 225.12,82.41 225.36,82.66 225.36,83.4 225.89,83.93 225.89,84.83 225.98,84.92 225.98,85.44 v2(225.67,85.75)
  IN6 w0.13: v2(218.19,58.71) 218.67,59.19 218.67,61.52 219.33,62.18 219.33,70.66 221.63,72.96 221.63,76.6 225.12,80.09
  BOTTOM w0.102: UG9.F11 v2(225.67,85.75) ; v2(218.19,58.71) UG5.F4
FB_C_D31: length 31.9
  IN6 w0.102: 224.27,80.07 224.27,84.38 224.69,84.8 225.27,84.8 v2(225.57,85.1)
  IN6 w0.13: 224.27,80.07 221.05,76.86 221.05,73.4 218.77,71.12 218.77,62.52 218.01,61.76 218.01,59.51 217.61,59.11 216.99,59.11 v2(216.59,58.71)
  BOTTOM w0.102: UG9.E11 225.72,85.1 v2(225.57,85.1) ; UG5.F2 216.35,58.48 v2(216.59,58.71)
FB_C_D32: length 24.5
  IN1 w0.102: v2(238.27,88.45) 238.86,87.86 238.86,86.06 238.72,85.91 238.72,84.61
  IN1 w0.13: 238.72,84.61 238.57,84.46 238.57,82.89 238.96,82.49 238.96,74.36 243.3,70.02 243.3,68.02 v2(242.79,67.51)
  BOTTOM w0.102: v2(242.79,67.51) 242.79,67.51 UG6.A4 ; UG9.J29 v2(238.27,88.45)
FB_C_D33: length 21.8
  IN1 w0.102: 239.19,84.89 239.19,85.37 v2(239.57,85.75)
  IN1 w0.13: 239.19,84.89 239.27,84.81 239.27,83.63 240.04,82.86 240.04,76.09 244.67,71.46 244.67,67.8 v2(244.39,67.51)
  BOTTOM w0.102: v2(239.57,85.75) UG9.F30 ; UG6.A2 244.15,67.28 v2(244.39,67.51)
FB_C_D34: length 23.7
  IN1 w0.102: 238.5,84.88 238.5,86.07 238.6,86.17 238.6,86.82 v2(238.27,87.15)
  IN1 w0.13: v2(242.79,66.71) 242.32,67.17 242.32,70.2 238.13,74.4 238.13,83.6 238.25,83.72 238.25,84.63 238.5,84.88
  BOTTOM w0.102: UG6.B4 242.79,66.71 v2(242.79,66.71) ; UG9.H29 v2(238.27,87.15)
FB_C_D35: length 23.9
  IN1 w0.102: v2(239.57,87.05) 239.2,86.68 239.2,85.98 238.96,85.74 238.96,84.41
  IN1 w0.13: v2(244.39,66.71) 243.91,67.18 243.91,71.36 239.44,75.84 239.44,82.69 238.92,83.21 238.92,84.37 238.96,84.41
  BOTTOM w0.102: v2(244.39,66.71) 244.13,66.45 UG6.B2 ; UG9.G30 v2(239.57,87.05)
FB_C_D36: length 26.8
  IN1 w0.13: v2(240.62,78.05) 242.26,76.41 242.26,75.46 246.86,70.86 246.86,64.84 245.94,63.91 243.19,63.91 v2(242.79,63.51)
  BOTTOM w0.102: v2(240.62,78.05) 240.16,78.51 240.16,78.88 239.87,79.17 239.58,79.46 239.58,81.37 239.54,81.42 239.54,82.36 239.6,82.42 239.6,82.72 239.27,83.05 UG9.B30 ; UG6.E4 v2(242.79,63.51)
FB_C_D37: length 22.8
  IN1 w0.13: v2(244.39,64.31) 244.79,64.71 245.54,64.71 246.1,65.27 246.1,70.83 240.52,76.41 v2(240.52,76.91)
  BOTTOM w0.102: v2(240.52,76.91) 240.22,77.21 240.22,77.68 239.65,78.25 239.65,78.67 239.27,79.05 UG9.A30 ; UG6.E2 244.18,64.11 v2(244.39,64.31)
FB_C_D38: length 35.2
  IN1 w0.102: v2(239.57,87.75) 239.8,87.52 240.59,87.52 240.8,87.3 ; 240.8,85.58 240.61,85.39 240.61,82.68
  IN1 w0.13: 240.61,82.68 241.02,82.27 241.02,79.6 241.35,79.27 241.41,79.27 244.33,76.34 244.33,74.98 247.98,71.33 247.98,63.6 246.61,62.22 243.28,62.22 v2(242.79,62.71) ; 240.8,85.58 240.8,87.3
  BOTTOM w0.102: UG6.F4 v2(242.79,62.71) ; UG9.H30 v2(239.57,87.75)
FB_C_D39: length 27.7
  IN1 w0.13: v2(244.39,63.51) 244.79,63.11 246.66,63.11 247.42,63.87 247.42,71.09 243.21,75.3 243.21,76.19 241.06,78.34 241.06,78.96 240.82,79.2 v2(240.63,79.2)
  BOTTOM w0.102: UG9.C30 239.27,83.75 239.62,83.4 239.62,83.05 239.81,82.86 239.81,81.55 239.91,81.45 239.91,79.91 240.62,79.2 v2(240.63,79.2) ; UG6.F2 244.18,63.3 v2(244.39,63.51)
FB_C_D40: length 19.2
  IN6 w0.102: 236,81.98 236.12,82.1 236.12,82.2 236.13,82.21 236.13,82.21 236.36,82.44 236.92,82.44 237.36,82.88 237.36,84.24 v2(237.47,84.35)
  IN6 w0.13: 236,81.98 236,76.14 236.29,75.85 236.29,71.49 236.69,71.09 236.69,67.81 v2(236.39,67.51)
  BOTTOM w0.102: UG6.A11 v2(236.39,67.51) ; UG9.D27 v2(237.47,84.35)
FB_C_D41: length 23.4
  IN6 w0.102: 234.57,82.6 234.54,82.63 235.1,83.2 235.61,83.2 236.57,84.15 236.57,88.05 236.18,88.44 v2(236.13,88.44)
  IN6 w0.13: 234.57,82.6 234.57,75.89 234.61,75.85 234.61,75.85 234.61,67.69 v2(234.79,67.51)
  BOTTOM w0.102: UG6.A13 235.02,67.27 v2(234.79,67.51) ; UG9.J26 236.18,88.44 v2(236.13,88.44)
FB_C_D42: length 21.9
  IN6 w0.102: 235.58,82.2 236.23,82.84 236.5,82.84 237.04,83.39 237.04,85.92 v2(237.47,86.35)
  IN6 w0.13: v2(236.39,66.71) 235.99,67.1 235.99,70.55 235.73,70.81 235.73,75.85 235.58,76 235.58,82.2
  BOTTOM w0.102: v2(236.39,66.71) 236.62,66.48 UG6.B11 ; UG9.F27 v2(237.47,86.35)
FB_C_D43: length 22.5
  IN6 w0.102: v2(237.47,87.05) 236.79,86.37 236.79,83.97 236.72,83.9 236.72,83.8 235.05,82.13
  IN6 w0.13: v2(234.79,66.71) 235.17,67.09 235.17,67.33 235.18,67.35 235.18,67.67 235.17,67.69 235.17,75.62 235.17,75.62 235.17,75.85 235.05,75.97 235.05,82.13
  BOTTOM w0.102: v2(234.79,66.71) UG6.B13 ; UG9.G27 v2(237.47,87.05)
FB_C_D44: length 23.3
  IN6 w0.102: 238.24,75.62 237.76,76.1 237.76,79 237.74,79.02 237.74,79.52 v2(238.52,80.3)
  IN6 w0.13: v2(236.39,64.31) 236.79,64.71 237.81,64.71 238.95,65.85 238.95,72.99 238.83,73.12 238.24,73.7 238.24,75.62
  BOTTOM w0.102: v2(238.52,80.3) 237.8,81.02 237.8,82.77 237.52,83.05 237.52,83.45 237.17,83.8 UG9.C27 ; v2(236.39,64.31) UG6.E11
FB_C_D45: length 25.4
  IN6 w0.102: v2(238.52,79.7) 238.12,79.3 238.12,76.33 238.83,75.62
  IN6 w0.13: 238.83,75.62 238.83,74.66 238.84,74.65 238.84,73.89 239.39,73.35 239.66,73.08 239.66,65.52 238.05,63.91 235.38,63.91 234.98,63.51 v2(234.79,63.51)
  BOTTOM w0.102: v2(234.79,63.51) 235.02,63.74 235.02,63.75 UG6.E13 ; UG9.B27 237.17,83.05 237.52,82.7 237.52,80.7 v2(238.52,79.7)
FB_C_D46: length 24.1
  IN6 w0.102: 239.4,75.62 238.61,76.41 238.61,78.51 v2(238.57,78.55)
  IN6 w0.13: v2(236.39,63.51) 236.4,63.51 236.8,63.11 238.2,63.11 240.22,65.13 240.22,72.85 240.22,73.31 239.95,73.58 239.4,74.13 239.4,75.62
  BOTTOM w0.102: v2(238.57,78.55) 237.17,79.95 UG9.A27 ; v2(236.39,63.51) UG6.F11
FB_C_D47: length 29.6
  IN6 w0.102: 237.68,75.62 237.33,75.97 237.33,80.06 237.97,80.7 237.97,82.18 238.64,82.86 238.64,85.1 v2(238.13,85.61)
  IN6 w0.13: 237.68,75.62 237.68,73.47 238.39,72.76 238.39,66.22 237.68,65.51 236.11,65.51 235.99,65.39 235.99,64.85 235.85,64.71 234.6,64.71 234.26,64.37 234.26,63.24 v2(234.79,62.71)
  BOTTOM w0.102: UG9.G29 238.57,86.51 238.2,86.14 238.2,85.68 v2(238.13,85.61) ; v2(234.79,62.71) 235.04,62.96 UG6.F13
FB_C_D48: length 43.7
  IN6 w0.102: v2(231.97,87.75) 231.82,87.75 231.57,87.5 230.82,87.5 230.27,86.95 230.27,84.81 230.09,84.63
  IN6 w0.13: 230.09,84.63 230.09,76.1 228.82,74.83 228.82,57.66 233.98,52.5 235.75,52.5 236.4,53.15 236.4,53.9 v2(236.39,53.91)
  BOTTOM w0.102: UG9.H20 v2(231.97,87.75) ; UG6.U11 236.62,54.14 v2(236.39,53.91)
FB_C_D49: length 34.3
  IN6 w0.102: 231.02,84.2 v2(231.17,84.35)
  IN6 w0.13: 231.02,84.2 231.02,75.41 229.95,74.33 229.95,58.18 232.04,56.09 232.05,56.09 233.59,54.55 233.59,54.55 233.82,54.31 233.83,54.31 233.84,54.31 234.39,54.31 v2(234.79,53.91)
  BOTTOM w0.102: UG6.U13 v2(234.79,53.91) ; UG9.D18 v2(231.17,84.35)
FB_C_D50: length 40.7
  IN6 w0.102: 230.53,84.48 230.68,84.63 230.68,85.66 231.07,86.05 231.48,86.05 231.85,86.42 v2(231.85,86.53)
  IN6 w0.13: v2(236.39,54.71) 235.99,54.31 235.99,53.66 235.85,53.52 235.75,53.52 235.74,53.51 233.82,53.51 233.82,53.52 233.78,53.52 229.38,57.92 229.38,74.59 230.53,75.74 230.53,84.48
  BOTTOM w0.102: v2(231.85,86.53) 232.05,86.53 UG9.G20 ; UG6.T11 236.6,54.93 v2(236.39,54.71)
FB_C_D51: length 35.3
  IN6 w0.102: 231.66,83.45 231.86,83.65 231.86,85.08 v2(231.72,85.22)
  IN6 w0.13: v2(235.59,54.71) 235.55,54.71 235.15,55.11 233.81,55.11 230.51,58.42 230.51,74.1 231.66,75.25 231.66,83.45
  BOTTOM w0.102: v2(235.59,54.71) 235.36,54.94 235.36,54.94 UG6.T13 ; UG9.E20 232.07,85.15 231.79,85.15 v2(231.72,85.22)
FB_C_D52: length 36
  IN6 w0.102: 232.31,85.33 233.06,86.08 233.54,86.08 v2(233.97,85.65)
  IN6 w0.13: v2(236.39,57.11) 235.99,57.5 233.03,57.5 231.07,59.47 231.07,73.87 232.31,75.11 232.31,85.33
  BOTTOM w0.102: UG6.N11 v2(236.39,57.11) ; UG9.F23 v2(233.97,85.65)
FB_C_D53: length 30.8
  IN6 w0.102: 232.87,84.65 v2(233.27,85.05)
  IN6 w0.13: v2(234.79,57.91) 234.72,57.84 233.82,57.84 231.63,60.03 231.63,73.63 232.87,74.87 232.87,84.65
  BOTTOM w0.102: v2(234.79,57.91) 234.79,57.91 UG6.N13 ; UG9.E21 v2(233.27,85.05)
FB_C_D54: length 31.5
  IN6 w0.102: 233.48,82.81 233.96,83.28 233.96,84.06 233.67,84.35 v2(233.27,84.35)
  IN6 w0.13: 233.48,82.81 233.48,74.69 232.19,73.4 232.19,60.24 234.12,58.31 235.99,58.31 v2(236.39,57.91)
  BOTTOM w0.102: UG9.D21 v2(233.27,84.35) ; v2(236.39,57.91) 236.59,58.11 236.59,58.11 UG6.M11
FB_C_D55: length 28.7
  IN6 w0.102: v2(233.97,85.1) 234.34,84.73 234.34,82.82 234.05,82.53
  IN6 w0.13: v2(234.79,58.71) 233.24,60.25 233.24,73.66 234.05,74.46 234.05,82.53
  BOTTOM w0.102: v2(233.97,85.1) 234.12,85.1 UG9.E23 ; v2(234.79,58.71) 234.99,58.51 234.99,58.51 UG6.M13
FB_C_D56: length 40
  IN1 w0.13: v2(242.79,54.71) 242.39,54.31 240.96,54.31 238.75,56.52 238.75,58.52 237.69,59.58 237.69,67.83 232.99,72.52 232.99,80.87 234.5,82.38 234.5,86.18 v2(235.37,87.05)
  BOTTOM w0.102: v2(242.79,54.71) 242.39,54.31 UG6.U4 ; UG9.G24 v2(235.37,87.05)
FB_C_D57: length 40.9
  IN1 w0.13: v2(236.17,87.75) 237.06,86.86 237.06,83.86 237.5,83.42 237.5,74.24 241.5,70.23 241.5,62.36 242.35,61.51 244.61,61.51 244.86,61.25 244.86,59.74 245.59,59.01 245.63,58.97 245.63,54.54 245.4,54.31 244.79,54.31 v2(244.39,54.71)
  BOTTOM w0.102: UG9.H26 v2(236.17,87.75) ; v2(244.39,54.71) 244.13,54.45 244.13,54.45 UG6.U2
FB_C_D58: length 37.2
  IN1 w0.13: v2(241.99,54.71) 241.59,55.11 240.91,55.11 239.5,56.51 239.5,58.66 238.64,59.53 238.64,67.67 233.59,72.72 233.59,80.74 234.95,82.1 234.95,85.93 v2(235.37,86.35)
  BOTTOM w0.102: UG9.F24 v2(235.37,86.35) ; v2(241.99,54.71) 242.39,55.11 UG6.T4
FB_C_D59: length 36.6
  IN1 w0.13: v2(244.39,55.51) 244.79,55.91 244.79,58.94 244.06,59.67 244.06,60.43 243.78,60.7 242.13,60.7 242.02,60.81 241.08,61.76 241.08,69.86 236.94,74 236.94,83.5 236.77,83.67 236.77,85.85 v2(236.17,86.45)
  BOTTOM w0.102: UG6.T2 244.15,55.27 v2(244.39,55.51) ; v2(236.17,86.45) UG9.G26
FB_C_D60: length 35.2
  IN1 w0.13: v2(242.79,57.91) 242.3,57.42 241.03,57.42 240.32,58.13 240.32,58.7 239.12,59.9 239.12,68.08 234.17,73.03 234.17,80.61 235.49,81.93 235.49,82.98 236.44,83.92 236.44,85.48 v2(236.17,85.75)
  BOTTOM w0.102: UG6.N4 242.55,57.67 v2(242.79,57.91) ; UG9.F26 v2(236.17,85.75)
FB_C_D61: length 32.9
  IN1 w0.13: v2(243.59,57.91) 243.19,58.31 241.66,58.31 241.51,58.45 241.51,58.88 239.54,60.85 239.54,68.56 234.8,73.3 234.8,78 234.81,78.01 234.81,79.79 v2(236.52,81.5)
  BOTTOM w0.102: UG9.D26 236.82,84.3 236.82,82.35 236.91,82.26 236.91,81.89 v2(236.52,81.5) ; UG6.N2 v2(243.59,57.91)
FB_C_D62: length 29
  IN1 w0.13: v2(236.52,80.75) 235.41,79.64 235.41,73.73 240.23,68.91 240.23,61.08 242.6,58.71 v2(242.79,58.71)
  BOTTOM w0.102: v2(236.52,80.75) 236.12,81.15 236.12,82.68 236.47,83.03 UG9.B26 ; UG6.M4 242.64,58.56 242.64,58.57 v2(242.79,58.71)
FB_C_D63: length 31.3
  IN1 w0.102: v2(244.39,57.91) 243.99,58.31 243.99,58.99
  IN1 w0.13: 243.99,58.99 243.07,59.91 242.1,59.91 240.65,61.35 240.65,69.4 236.07,73.98 236.07,75.62 236.1,75.65 236.1,79.13 v2(236.52,79.55)
  BOTTOM w0.102: UG6.M2 v2(244.39,57.91) ; UG9.C26 236.12,83.6 236.12,83.07 235.89,82.84 235.89,80.18 v2(236.52,79.55)
FB_C_DBI0: length 23.5
  IN2 w0.117: v2(221.47,82.25) 221.37,82.35 220.13,82.35 219.59,81.81 219.59,76.25 213.92,70.58 213.92,66.05 214.46,65.51 215.39,65.51 v2(215.79,65.11)
  BOTTOM w0.102: v2(215.79,65.11) UG5.P2 ; UG9.A5 v2(221.47,82.25)
FB_C_DBI1: length 22.6
  IN1 w0.13: v2(223.5,83.7) 223.54,83.66 223.54,82 223.72,81.82 223.72,79.67 222.46,78.41 222.46,66.61 222.76,66.31 224.78,66.31 224.99,66.1 224.99,65.51 v2(225.39,65.11)
  BOTTOM w0.102: v2(223.5,83.7) 223.62,83.7 UG9.C8 ; UG5.P13 v2(225.39,65.11)
FB_C_DBI2: length 40
  IN2 w0.117: v2(231.17,88.45) 230.7,87.98 230.7,80.12 229.54,78.95 229.54,70.95 230.25,70.23 230.25,58.15 227.2,55.1 225.2,55.1 224.99,55.31 224.99,55.91 v2(224.59,56.31)
  BOTTOM w0.102: UG9.J18 v2(231.17,88.45) ; UG5.D13 224.8,56.52 224.8,56.52 v2(224.59,56.31)
FB_C_DBI3: length 40.3
  IN2 w0.117: v2(226.97,86.35) 226.58,85.96 226.58,83.3 226.92,82.96 226.92,69.75 228.21,68.46 228.21,61.77 227.07,60.62 226.75,60.62 225.23,59.1 222.16,59.1 219.76,56.7 217.55,56.7 217.55,56.7 217.23,56.7 217.22,56.7 217,56.7 v2(216.59,57.11)
  BOTTOM w0.102: v2(216.59,57.11) UG5.D2 ; UG9.F12 v2(226.97,86.35)
FB_C_DBI4: length 25.4
  IN2 w0.117: v2(241.42,76.16) 242.67,74.91 242.67,72.31 246.49,68.49 246.49,65.94 246.06,65.51 244.79,65.51 v2(244.39,65.11)
  BOTTOM w0.102: UG9.D29 238.92,84.3 238.92,82.4 238.96,82.36 238.96,78.73 239.01,78.68 239.01,78.07 239.79,77.29 239.79,77.06 240.69,76.16 v2(241.42,76.16) ; UG6.D2 244.17,64.89 v2(244.39,65.11)
FB_C_DBI5: length 24.3
  IN6 w0.102: v2(237.47,85.05) 238.19,84.33 238.19,83.1 237.41,82.32 237.41,81.12 236.99,80.7 236.99,75.62
  IN6 w0.13: v2(234.79,65.11) 235.19,65.51 235.19,66.09 235.41,66.31 237.39,66.31 237.63,66.55 237.63,71.13 236.99,71.77 236.99,75.62
  BOTTOM w0.102: v2(237.47,85.05) UG9.E27 ; UG6.D13 v2(234.79,65.11)
FB_C_DBI6: length 37.2
  IN2 w0.117: v2(231.97,85.75) 232.14,85.58 232.14,80.72 230.64,79.22 230.64,70.8 230.93,70.51 230.93,56.35 231.97,55.3 232.8,55.3 232.99,55.11 235.03,55.11 235.18,55.25 235.18,55.96 v2(235.56,56.34)
  BOTTOM w0.102: UG6.P13 235.19,56.71 v2(235.56,56.34) ; UG9.F20 v2(231.97,85.75)
FB_C_DBI7: length 36.2
  IN2 w0.117: v2(244.39,57.11) 243.99,57.51 243.34,57.51 243.19,57.66 243.19,58.08 242.96,58.31 242.62,58.31 242.39,58.54 242.39,58.92 242.18,59.13 240.65,59.13 238.27,61.51 235.59,61.51 235.18,61.92 235.18,69.56 236.04,70.42 236.04,75.6 236.01,75.62 v2(236.01,84.21)
  BOTTOM w0.102: v2(236.01,84.21) 236.12,84.32 236.12,84.77 236.47,85.12 UG9.E26 ; UG6.P2 244.13,56.86 v2(244.39,57.11)
FB_C_EDC0: length 24.9
  IN2 w0.117: v2(216.58,65.91) 216.19,66.31 214.84,66.31 214.83,66.32 214.83,66.32 214.6,66.55 214.6,70.05 220.35,75.81 220.35,80.64 221.07,81.35 221.13,81.35 221.93,82.15 221.93,84.49 v2(221.47,84.95)
  BOTTOM w0.102: UG5.R2 216.58,65.91 v2(216.58,65.91) ; UG9.D5 v2(221.47,84.95)
FB_C_EDC1: length 32.8
  IN2 w0.117: v2(224.59,65.91) 224.19,66.31 222.63,66.31 220.88,64.56 217.75,64.56 217.61,64.7 217.55,64.7 217.55,64.7 217.23,64.7 217.22,64.7 217.18,64.7 216.99,64.89 216.99,67.11 217.66,67.78 217.66,71.95 221.33,75.62 221.33,80.38 222.36,81.41 222.36,84.39 222.62,84.65 223.28,84.65 223.54,84.92 223.54,84.92 v2(223.57,84.95)
  BOTTOM w0.102: v2(224.59,65.91) 224.99,65.51 UG5.R13 ; UG9.D8 v2(223.57,84.95)
FB_C_EDC2: length 40.4
  IN2 w0.117: v2(225.39,55.51) 225.79,55.91 227.02,55.91 227.08,55.97 227.08,55.98 227.93,56.83 227.93,57 227.29,57.65 227.27,57.66 227.27,57.67 227.27,57.69 227.27,57.84 227.39,57.96 227.56,57.96 228.24,57.27 228.42,57.27 228.54,57.39 228.54,57.57 227.85,58.25 227.85,58.43 227.97,58.55 228.14,58.55 228.83,57.86 229,57.86 229.25,58.1 229.25,58.71 229.05,58.91 228.11,58.91 227.99,59.04 227.99,59.21 228.11,59.33 229.19,59.33 229.56,59.7 229.56,69.58 228.73,70.41 228.73,79.31 230.01,80.59 230.01,84.91 v2(229.87,85.05)
  BOTTOM w0.102: v2(229.87,85.05) UG9.E17 ; UG5.C13 v2(225.39,55.51)
FB_C_EDC3: length 41.6
  IN2 w0.117: v2(226.97,85.05) 227.78,84.24 227.78,69.84 228.89,68.74 228.89,61.49 226.7,59.3 226.23,59.3 225.8,58.87 225.8,58.87 225.78,58.84 225.78,57.67 225.62,57.52 225.54,57.52 225.53,57.51 222.71,57.51 222.31,57.11 221.26,57.11 220.06,55.91 216.19,55.91 v2(215.79,56.31)
  BOTTOM w0.102: v2(215.79,56.31) 216,56.09 UG5.C2 ; UG9.E12 v2(226.97,85.05)
FB_C_EDC4: length 24.9
  IN2 w0.117: v2(243.59,65.91) 243.99,66.31 245.51,66.31 245.82,66.62 245.82,68 241.99,71.82 241.99,73.6 240.1,75.49 240.1,82.82 239.18,83.74 239.18,84.66 v2(239.57,85.05)
  BOTTOM w0.102: UG6.C2 v2(243.59,65.91) ; v2(239.57,85.05) UG9.E30
FB_C_EDC5: length 21.1
  IN2 w0.117: v2(238.57,81.5) 237.91,80.84 237.91,65.94 237.48,65.51 235.99,65.51 v2(235.59,65.91)
  BOTTOM w0.102: UG9.B29 238.57,83.1 238.17,82.7 238.17,81.9 v2(238.57,81.5) ; v2(235.59,65.91) UG6.C13
FB_C_EDC6: length 35.3
  IN2 w0.117: v2(234.79,55.51) 234.39,55.91 233.04,55.91 231.6,57.35 231.6,79.22 232.82,80.44 232.82,86.6 v2(233.27,87.05)
  BOTTOM w0.102: UG9.G21 v2(233.27,87.05) ; v2(234.79,55.51) 235.02,55.74 UG6.R13
FB_C_EDC7: length 36.8
  IN2 w0.117: v2(243.59,56.31) 243.19,56.71 242.54,56.71 241.78,57.47 240.98,57.47 238.35,60.1 238.09,60.1 237.48,60.71 234.5,60.71 234.32,60.89 234.32,70.13 235.03,70.83 235.03,84.66 v2(235.39,85.03)
  BOTTOM w0.102: v2(243.59,56.31) 243.81,56.09 UG6.R2 ; v2(235.39,85.03) UG9.E24
FB_C_WCK01: length 26
  IN2 w0.089: v2(223.57,86.35) 223.74,86.52 223.94,86.52 224.09,86.36 224.09,74.48 218.89,69.28 218.89,66.03 218.39,65.52 217.81,65.52 217.4,65.11 v2(217.39,65.11)
  BOTTOM w0.102: UG9.F8 v2(223.57,86.35)
  BOTTOM w0.119: UG5.P4 217.39,65.1 v2(217.39,65.11)
FB_C_WCK23: length 38
  IN2 w0.089: v2(226.97,87.75) 226.8,87.58 226.58,87.58 226.08,87.08 226.08,68.7 226.57,68.21 226.57,61.71 224.55,59.68 221.37,59.68 219.18,57.48 218.85,57.48 218.47,57.1 v2(218.17,57.1)
  BOTTOM w0.102: UG9.H12 v2(226.97,87.75)
  BOTTOM w0.119: v2(218.17,57.1) UG5.D4
FB_C_WCK45: length 29.6
  IN2 w0.089: v2(242.79,64.31) 242.41,63.94 241.82,63.94 241.15,64.6 241.15,72.41 238.95,74.61 238.95,82.25 238.02,83.18 237.56,83.18 236.68,84.05 236.68,88.07 236.91,88.3 237.31,88.3 v2(237.47,88.45)
  BOTTOM w0.102: UG9.J27 v2(237.47,88.45)
  BOTTOM w0.119: UG6.D4 v2(242.79,64.31)
FB_C_WCK67: length 39.1
  IN2 w0.089: v2(241.99,56.31) 241.59,55.92 240.35,55.92 238.54,57.72 238.54,58.71 238.05,59.2 234.61,59.2 234.6,59.2 234.55,59.2 233.18,60.58 233.18,77.39 233.94,78.16 233.94,84.26 234.5,84.81 234.5,86 234.34,86.16 234.34,86.18 v2(234.07,86.45)
  BOTTOM w0.102: UG9.G23 v2(234.07,86.45)
  BOTTOM w0.119: UG6.P4 v2(241.99,56.31)
FB_C_WCK#01: length 26.1
  IN2 w0.089: v2(218.19,65.11) 218.37,65.29 218.48,65.29 219.08,65.9 219.08,69.21 224.28,74.4 224.28,86.44 224.01,86.71 223.63,86.71 v2(223.42,86.91)
  BOTTOM w0.102: v2(223.42,86.91) 223.58,86.75 UG9.G8
  BOTTOM w0.119: v2(218.19,65.11) 218.41,64.89 UG5.P5
FB_C_WCK#23: length 37.9
  IN2 w0.089: v2(226.97,87.05) 227.06,87.14 227.06,87.27 226.94,87.39 226.64,87.39 226.26,87.01 226.26,68.77 226.75,68.28 226.75,61.63 224.62,59.5 221.45,59.5 219.24,57.29 219.09,57.29 219.01,57.21 v2(219.01,57.11)
  BOTTOM w0.102: UG9.G12 226.85,86.75 226.97,86.87 v2(226.97,87.05)
  BOTTOM w0.119: v2(219.01,57.11) 218.93,57.19 218.78,57.19 218.56,56.98 218.56,56.94 218.52,56.9 218.52,56.77 UG5.D5
FB_C_WCK#45: length 29.7
  IN2 w0.089: v2(237.47,87.75) 237.1,88.12 236.98,88.12 236.86,88 236.86,84.12 237.63,83.36 238.1,83.36 239.13,82.33 239.13,74.69 241.33,72.48 241.33,64.73 241.75,64.31 v2(241.99,64.31)
  BOTTOM w0.102: UG9.H27 236.94,87.45 236.84,87.55 236.84,87.71 236.94,87.81 237.41,87.81 v2(237.47,87.75)
  BOTTOM w0.119: UG6.D5 241.59,64.98 241.69,65.07 241.9,65.07 242.01,64.97 242.01,64.33 v2(241.99,64.31)
FB_C_WCK#67: length 39.1
  IN2 w0.089: v2(234.07,87.15) 234.53,86.69 234.53,86.24 234.69,86.08 234.69,84.75 234.12,84.18 234.12,78.08 233.37,77.33 233.37,60.64 234.62,59.39 238.19,59.39 238.77,58.8 238.77,57.82 240.48,56.1 240.98,56.1 241.02,56.14 v2(241.19,56.31)
  BOTTOM w0.102: UG9.H23 234.42,87.4 234.42,87.16 234.36,87.1 234.12,87.1 v2(234.07,87.15)
  BOTTOM w0.119: v2(241.19,56.31) 241.51,56.31 241.59,56.39 UG6.P5
FB_D_CLK0: length 35.7
  IN1 w0.102: 223.38,96.33 223.47,96.33 223.66,96.13 223.67,96.13 223.82,95.98 223.82,95.9 v2(224.17,95.55)
  IN1 w0.107: 223.38,96.33 222.72,96.33 222.63,96.33 222.44,96.52 219.41,96.52 218.8,95.91 216.71,95.91 216.25,95.45 212.84,95.45 206.09,88.7 200.69,88.7 200.55,88.84 200.55,89.16 200.66,89.26 200.99,89.26 v2(201.23,89.5) 200.73,89.5 200.39,89.85 200.39,89.99 200.1,90.29 199.7,90.29 199.04,90.95 199.04,92.13 199.21,92.29 199.21,92.43 v2(199.43,92.65)
  BOTTOM w0.102: UG9.Y8 v2(224.17,95.55)
  BOTTOM w0.119: v2(199.43,92.65) 199.43,92.95 199.33,93.05 UG7.J12 ; RG160.1 200.74,89.09 200.74,89.38 200.86,89.5 v2(201.23,89.5)
FB_D_CLK1: length 36
  IN6 w0.107: v2(199.43,81.65) 199.21,81.87 199.21,82.03 199.04,82.2 199.04,83.06 199.91,83.93 200.89,83.93 201.32,84.36 201.88,84.36 202.1,84.57 v2(202.13,84.6) 201.97,84.76 201.69,84.76 201.59,84.87 201.59,85.02 201.77,85.2 204.3,85.2 204.41,85.1 204.41,84.78 204.63,84.56 205.11,84.56 205.33,84.78 205.33,85.1 205.44,85.2 207.65,85.2 214.45,92 218.53,92 218.78,92.24 218.78,92.24 218.82,92.28 221.74,92.28 221.97,92.05 223.39,92.05 223.5,92.05 223.68,92.05 224.29,92.65 v2(224.29,92.78)
  BOTTOM w0.102: v2(224.29,92.78) 224.29,92.58 224.07,92.35 UG9.R8
  BOTTOM w0.119: UG8.J12 199.29,81.25 199.43,81.39 v2(199.43,81.65) ; v2(202.13,84.6) 201.68,84.6 201.56,84.72 201.56,85.05 RG164.1
FB_D_CLK#0: length 35.6
  IN1 w0.102: v2(223.49,95.5) 223.62,95.63 223.62,95.9 223.38,96.13
  IN1 w0.107: v2(199.43,93.45) 199.01,93.04 199.01,92.63 199.01,92.37 198.85,92.21 198.85,90.87 199.62,90.09 200.02,90.09 200.2,89.91 200.2,89.77 v2(199.93,89.5) 200.36,89.08 200.36,88.76 200.61,88.51 206.17,88.51 212.92,95.25 216.33,95.25 216.79,95.71 218.72,95.71 218.88,95.71 219.49,96.33 222.36,96.33 222.55,96.13 222.8,96.13 223.38,96.13
  BOTTOM w0.102: UG9.Y7 223.49,95.53 v2(223.49,95.5)
  BOTTOM w0.119: v2(199.43,93.45) 199.19,93.69 UG7.J11 ; RG531.1 200.52,89.13 200.52,89.3 200.32,89.5 v2(199.93,89.5)
FB_D_CLK#1: length 36.1
  IN6 w0.107: v2(199.43,80.85) 199.43,81.11 199.01,81.53 199.01,81.95 198.85,82.12 198.85,83.15 199.83,84.13 200.81,84.13 200.96,84.28 200.96,84.47 v2(200.83,84.6) 201.29,84.6 201.39,84.71 201.39,85.1 201.69,85.4 204.38,85.4 204.6,85.18 204.6,84.86 204.71,84.76 205.03,84.76 205.14,84.86 205.14,85.18 205.36,85.4 207.57,85.4 214.37,92.2 218.45,92.2 218.69,92.44 218.7,92.44 218.74,92.48 221.82,92.48 222.05,92.24 223.39,92.24 223.6,92.24 223.83,92.47 223.83,92.62 223.71,92.74 223.56,92.74 v2(223.47,92.65)
  BOTTOM w0.102: UG9.R7 v2(223.47,92.65)
  BOTTOM w0.119: v2(200.83,84.6) 201.24,84.6 201.35,84.72 201.35,85.02 201.04,85.33 201.04,85.35 RG532.1 ; UG8.J11 199.43,80.85 v2(199.43,80.85)
FB_D_CMD0: length 30.5
  BOTTOM w0.102: 211.69,99.94 212.76,98.87 218.69,98.87 218.81,98.99 219.18,98.99 219.52,98.65 UG9.AD2
  BOTTOM w0.185: 211.69,99.94 211.69,103.14 210.3,104.53 198.59,104.53 197.53,103.47 197.53,102.32 197.81,102.04 197.81,100.64 UG7.G3
FB_D_CMD1: length 28.3
  TOP w0.102: RG451.2 198.71,100.74 v2(198.63,100.65)
  BOTTOM w0.102: v2(198.63,100.65) 198.86,100.42 UG7.J3 ; UG9.AD1 212.55,98.65 211.37,99.83 211.37,102.69
  BOTTOM w0.185: v2(198.63,100.65) 198.63,102.42 198.58,102.47 198.58,102.78 199.78,103.99 210.08,103.99 211.37,102.69
FB_D_CMD2: length 27.9
  TOP w0.102: v2(199.42,101.45) 199.51,101.54 RG453.1
  BOTTOM w0.102: UG9.AD4 220.72,98.3 212.58,98.3 211.06,99.83 211.06,101.92 ; UG7.J2 v2(199.42,101.45)
  BOTTOM w0.185: 211.06,101.92 209.53,103.44 200.16,103.44 199.48,102.76 199.48,102.45 199.45,102.42 199.45,102.28 199.42,102.25 v2(199.42,101.45)
FB_D_CMD3: length 24.1
  BOTTOM w0.102: UG9.AC1 212.62,97.95 210.82,99.75
  BOTTOM w0.185: UG7.L3 200.22,100.66 200.22,102.3 200.38,102.45 200.38,102.65 200.63,102.9 208.98,102.9 210.74,101.14 210.74,99.83 210.82,99.75
FB_D_CMD4: length 21.8
  BOTTOM w0.102: 211.84,97.65 212.35,97.65 212.48,97.53 219.05,97.53 219.47,97.95 UG9.AC2
  BOTTOM w0.185: UG7.K5 200.21,98.27 204.24,98.27 204.51,98.27 204.51,98.27 206.04,98.27 207.58,99.81 209.69,99.81 211.84,97.65
FB_D_CMD5: length 23.7
  BOTTOM w0.102: 210.82,97.78 211.2,97.4 212.18,97.4 212.25,97.34 219.21,97.34 219.47,97.6 219.79,97.6 220.14,97.95 UG9.AC3
  BOTTOM w0.185: UG7.K4 199.41,99.04 199.41,98.53 199.96,97.98 204.36,97.98 204.63,97.98 206.52,97.98 207.59,99.05 209.55,99.05 210.82,97.78
FB_D_CMD6: length 23
  BOTTOM w0.102: UG9.AA3 220.02,96.9 219.52,96.9 219.32,97.1 212.18,97.1 212.15,97.13 210.82,97.13
  BOTTOM w0.185: UG7.J5 199.03,98.31 199.64,97.7 204.48,97.7 204.75,97.7 204.75,97.7 206.65,97.7 206.65,97.7 206.94,97.7 207.65,98.42 209.11,98.42 210.4,97.13 210.82,97.13
FB_D_CMD7: length 23.5
  BOTTOM w0.102: UG9.AA2 219.52,96.55 219.18,96.89 212.28,96.89 211.75,96.36
  BOTTOM w0.185: UG7.J4 198.64,99.06 198.64,98.29 199.52,97.41 204.6,97.41 204.86,97.41 206.53,97.41 208.15,97.41 209.2,96.36 211.75,96.36
FB_D_CMD8: length 22.6
  BOTTOM w0.102: 211.95,95.59 212.85,96.49 218.91,96.49 UG9.AA1
  BOTTOM w0.185: UG7.H5 198.23,98.29 199.4,97.12 204.71,97.12 204.72,97.12 204.98,97.12 204.98,97.12 206.41,97.12 206.41,97.12 207.67,97.12 209.2,95.59 211.95,95.59
FB_D_CMD9: length 26.7
  BOTTOM w0.102: UG9.AA4 220.72,96.2 213.3,96.2 211.92,94.82
  BOTTOM w0.185: 211.92,94.82 209.04,94.82 207.02,96.84 206.29,96.84 205.1,96.84 204.83,96.84 199.28,96.84 197.81,98.3 197.81,99.04 UG7.H4
FB_D_CMD10: length 25.9
  BOTTOM w0.102: UG9.Y1 213.48,95.85 211.68,94.05
  BOTTOM w0.185: UG7.G12 197.83,93.45 197.83,95.43 198.94,96.55 204.95,96.55 205.22,96.55 205.22,96.55 206.17,96.55 206.17,96.55 206.54,96.55 209.03,94.05 211.68,94.05
FB_D_CMD11: length 24.9
  BOTTOM w0.102: UG9.Y2 219.47,95.85 219.12,95.5 213.58,95.5 211.36,93.28 210.82,93.28
  BOTTOM w0.185: UG7.H10 198.23,95.43 199.06,96.26 205.07,96.26 205.34,96.26 205.34,96.26 206.06,96.26 209.04,93.28 210.82,93.28
FB_D_CMD12: length 27
  BOTTOM w0.102: 210.82,92.51 210.97,92.51 213.68,95.23 219.2,95.23 219.47,95.5 220.02,95.5 UG9.Y3
  BOTTOM w0.185: 210.82,92.51 208.65,92.51 207.75,93.41 207.75,94.16 205.94,95.98 205.46,95.98 205.46,95.97 205.19,95.97 199.18,95.97 198.63,95.42 198.63,94.25 UG7.H11
FB_D_CMD13: length 26.7
  BOTTOM w0.102: 210.82,91.74 213.89,94.81 213.89,94.83 214.06,94.99 219.33,94.99 219.52,94.8 220.02,94.8 UG9.V3
  BOTTOM w0.185: 210.82,91.74 208.01,91.74 207.47,92.28 207.47,94.04 205.82,95.69 205.58,95.69 205.31,95.69 200.23,95.69 199.46,94.92 199.46,94.22 UG7.K11
FB_D_CMD14: length 25.3
  BOTTOM w0.102: UG9.V2 219.52,94.45 219.17,94.8 214.31,94.8 211.22,91.71 211.22,91.37 210.82,90.97
  BOTTOM w0.185: UG7.K10 199.83,94.88 200.35,95.4 205.43,95.4 205.7,95.4 207.18,93.92 207.18,91.79 208.01,90.97 210.82,90.97
FB_D_CMD15: length 26.7
  BOTTOM w0.102: UG9.V1 214.6,94.45 211.53,91.38 211.53,90.9 210.82,90.2
  BOTTOM w0.185: 210.82,90.2 207.3,90.2 206.89,90.61 206.89,93.8 205.58,95.11 200.57,95.11 200.22,94.77 200.22,93.46 UG7.L12
FB_D_CMD16: length 40.6
  BOTTOM w0.102: UG9.L3 220.02,89.2 219.47,89.2 219.22,88.95 216.38,88.95 215.27,87.85 215.27,76.64
  BOTTOM w0.185: UG8.L3 197.81,73.67 197.81,72.24 197.73,72.15 197.73,71.65 199.37,70.01 208.65,70.01 215.27,76.64
FB_D_CMD17: length 38.9
  TOP w0.102: v2(198.63,73.65) 198.62,73.66 RG452.2
  BOTTOM w0.102: 215.03,77.53 215.03,88.01 216.23,89.21 219.13,89.21 219.47,89.55 UG9.L2 ; v2(198.63,73.65) 198.89,73.92 198.89,73.92 199.02,74.05 UG8.J3
  BOTTOM w0.185: 215.03,77.53 208.04,70.55 199.7,70.55 198.63,71.62 198.63,71.65 198.63,71.65 v2(198.63,73.65)
FB_D_CMD18: length 35.8
  TOP w0.102: RG450.1 199.57,72.71 v2(199.43,72.85)
  BOTTOM w0.102: UG9.L1 216.12,89.55 214.78,88.21 214.78,78.94 ; 212.54,75.93 212.54,75.93 ; 199.46,72.82 v2(199.43,72.85) 199.43,72.85 UG8.J2
  BOTTOM w0.185: 212.54,75.93 207.7,71.09 199.99,71.09 199.53,71.55 199.53,72.13 199.46,72.19 199.46,72.3 199.46,72.3 199.46,72.6 199.46,72.61 199.46,72.82 ; 214.78,78.94 212.54,76.69 212.54,75.93
FB_D_CMD19: length 36.2
  BOTTOM w0.102: UG9.M4 220.74,89.92 216.11,89.92 214.54,88.35 214.54,79.52
  BOTTOM w0.185: 214.54,79.52 211.95,76.93 211.95,76.53 207.05,71.63 200.78,71.63 200.41,72 200.41,72.15 200.26,72.3 200.26,73.69 UG8.G3
FB_D_CMD20: length 30.6
  BOTTOM w0.102: 214.29,79.96 214.29,88.48 216.06,90.25 UG9.M1
  BOTTOM w0.185: UG8.H5 200.24,76.06 205.88,76.06 206.42,75.52 209.85,75.52 214.29,79.96
FB_D_CMD21: length 32.5
  BOTTOM w0.102: 214.05,80.81 214.05,88.62 216.04,90.61 219.16,90.61 219.52,90.25 UG9.M2
  BOTTOM w0.185: 214.05,80.81 209.3,76.06 206.77,76.06 206.48,76.35 199.96,76.35 199.4,75.79 199.4,75.28 UG8.H4
FB_D_CMD22: length 32.2
  BOTTOM w0.102: 213.77,81.62 213.77,88.66 215.97,90.86 219.26,90.86 219.52,90.6 220.02,90.6 UG9.M3
  BOTTOM w0.185: 213.77,81.62 208.79,76.64 199.61,76.64 199.03,76.05 UG8.J5
FB_D_CMD23: length 33.6
  BOTTOM w0.102: UG9.P3 220.17,91.65 219.82,91.3 219.47,91.3 219.27,91.1 215.57,91.1 213.5,89.03 213.5,82.44
  BOTTOM w0.185: UG8.J4 198.64,75.24 198.64,76.36 199.2,76.92 207.98,76.92 213.5,82.44
FB_D_CMD24: length 32
  BOTTOM w0.102: UG9.P2 219.47,91.65 219.12,91.3 215.4,91.3 213.24,89.13 213.24,83.27
  BOTTOM w0.185: UG8.K5 198.23,76.45 198.98,77.21 207.18,77.21 213.24,83.27
FB_D_CMD25: length 32.5
  BOTTOM w0.102: UG9.P1 215.34,91.65 212.9,89.21 212.9,83.79
  BOTTOM w0.185: 212.9,83.79 208.33,79.21 208.33,79.2 206.64,77.52 206.63,77.52 206.62,77.5 198.73,77.5 197.81,76.59 197.81,75.27 UG8.K4
FB_D_CMD26: length 35.4
  BOTTOM w0.102: UG9.R4 220.72,92 215.21,92 212.59,89.38 212.59,86.15
  BOTTOM w0.185: 212.59,86.15 210.82,84.37 210.82,83.03 208.29,80.5 208.29,79.68 206.41,77.8 198.97,77.8 197.83,78.94 197.83,80.85 UG8.L12
FB_D_CMD27: length 30.8
  BOTTOM w0.102: 212.33,87.21 212.33,89.6 215.08,92.35 UG9.R1
  BOTTOM w0.185: UG8.K10 198.23,78.95 199.09,78.09 206.18,78.09 207.78,79.69 207.78,81.08 209.62,82.93 209.62,84.5 212.33,87.21
FB_D_CMD28: length 32.2
  BOTTOM w0.102: UG9.R2 219.52,92.35 219.17,92.7 214.92,92.7 212.07,89.85 212.07,88.03
  BOTTOM w0.185: UG8.K11 198.64,80.04 198.64,78.95 199.21,78.38 206.06,78.38 207.49,79.81 207.49,81.88 208.94,83.33 208.94,84.91 212.07,88.03
FB_D_CMD29: length 32
  BOTTOM w0.102: UG9.R3 220.02,92.7 219.52,92.7 219.22,93 214.82,93 211.67,89.86 211.67,88.84
  BOTTOM w0.185: UG8.H11 199.46,80.09 199.46,79.81 199.46,79.5 199.53,79.44 199.53,78.98 199.85,78.66 205.94,78.66 207.2,79.93 207.2,82.69 208.17,83.65 208.17,85.34 211.67,88.84
FB_D_CMD30: length 30.5
  BOTTOM w0.102: 211.41,89.24 211.41,90.03 214.78,93.4 218.29,93.4 218.49,93.19 219.26,93.19 219.47,93.4 219.78,93.4 220.13,93.75 UG9.U3
  BOTTOM w0.185: 211.41,89.24 210.82,88.65 210.72,88.65 207.34,85.27 207.34,83.6 206.91,83.18 206.91,80.05 205.82,78.95 200.29,78.95 199.94,79.3 199.94,79.54 UG8.H10
FB_D_CMD31: length 31.3
  BOTTOM w0.102: 211.15,89.75 211.15,90.15 211.79,90.79 211.79,91.32 214.19,93.73 218.36,93.73 218.67,93.42 219.14,93.42 219.47,93.75 UG9.U2
  BOTTOM w0.185: UG8.G12 200.22,80.85 200.22,79.42 200.41,79.24 205.62,79.24 206.63,80.24 206.63,85.33 210.72,89.42 210.82,89.42 211.15,89.75
FB_D_D0: length 20.4
  IN1 w0.13: v2(223.57,103.15) 222.73,102.31 220.64,102.31 220.11,101.78 216.86,101.78 216.61,101.53 209.11,101.53 207.34,99.75 206.52,99.75 v2(205.83,99.05)
  BOTTOM w0.102: v2(205.83,99.05) 205.43,99.45 UG7.U4 ; UG9.AK8 v2(223.57,103.15)
FB_D_D1: length 17.4
  IN1 w0.13: v2(205.83,101.45) 208.21,103.83 218.18,103.83 219.04,102.97 220.38,102.97 v2(220.67,103.25)
  BOTTOM w0.102: UG9.AK4 v2(220.67,103.25) ; UG7.U2 v2(205.83,101.45)
FB_D_D2: length 16.8
  IN1 w0.13: v2(217.39,102.88) 217.39,102.78 216.83,102.21 208.91,102.21 206.89,100.19 205.37,100.19 v2(205.03,99.85)
  BOTTOM w0.102: UG9.AK2 219.5,102.85 219.1,103.25 217.77,103.25 v2(217.39,102.88) ; UG7.T4 v2(205.03,99.85)
FB_D_D3: length 17.7
  IN1 w0.13: v2(216.27,102.85) 215.85,103.27 213.65,103.27 213.31,102.92 208.15,102.92 206.28,101.05 205.43,101.05 v2(205.03,101.45)
  BOTTOM w0.102: v2(216.27,102.85) 216.92,103.5 218.56,103.5 218.58,103.48 218.64,103.48 218.65,103.47 219.25,103.47 219.54,103.18 219.8,103.18 220.13,102.85 UG9.AK3 ; UG7.T2 v2(205.03,101.45)
FB_D_D4: length 24.5
  IN1 w0.13: v2(201.83,99.85) 202.22,100.25 202.22,101.81 202.62,102.21 202.62,102.72 204.61,104.7 218.45,104.7 219.22,103.93 220.69,103.93 v2(221.47,103.15)
  BOTTOM w0.102: v2(201.83,99.85) 202.23,99.45 UG7.N4 ; UG9.AK5 v2(221.47,103.15)
FB_D_D5: length 23.3
  IN2 w0.117: v2(217.97,102.85) 217.97,103.07 216.43,104.61 213.2,104.61 212.84,104.25 204.66,104.25 203.42,103 203.42,102.63 203.42,102.62 203.42,102.29 203.42,102.28 203.42,102.24 v2(202.63,101.45)
  BOTTOM w0.102: UG7.N2 v2(202.63,101.45) ; v2(217.97,102.85) 218.37,102.45 218.77,102.45 218.82,102.5 222.12,102.5 UG9.AK6
FB_D_D6: length 30.9
  IN1 w0.102: 224.37,104.38 224.55,104.2 224.55,103.47 v2(224.87,103.15)
  IN1 w0.13: v2(201.03,99.85) 200.43,100.45 200.43,102.62 200.46,102.65 203.07,105.26 218.84,105.26 219.72,104.38 224.37,104.38
  BOTTOM w0.102: v2(201.03,99.85) 201.07,99.85 201.43,99.5 UG7.M4 ; UG9.AK9 v2(224.87,103.15)
FB_D_D7: length 25.4
  IN2 w0.117: v2(222.87,103.15) 222.48,102.76 221.31,102.76 221.05,103.02 221.05,103.43 220.53,103.95 219.78,103.95 218.58,105.15 212.97,105.15 212.77,104.96 204.53,104.96 204.09,104.51 204.09,104.51 202.62,103.05 202.62,102.29 202.23,101.89 202.23,101.85 v2(201.83,101.45)
  BOTTOM w0.102: UG7.M2 v2(201.83,101.45) ; UG9.AK7 v2(222.87,103.15)
FB_D_D8: length 19.9
  IN6 w0.102: v2(217.92,100.05) 217.66,100.05 217.22,99.61
  IN6 w0.13: 217.22,99.61 210.18,99.61 206.32,95.75 206.32,93.95 v2(205.83,93.45)
  BOTTOM w0.102: v2(217.92,100.05) 218.32,100.45 218.67,100.45 218.72,100.4 220.72,100.4 UG9.AG4 ; UG7.U11 205.59,93.69 v2(205.83,93.45)
FB_D_D9: length 23.8
  IN6 w0.089: v2(224.87,99.75) 224.87,99.69 224.49,99.31 223.92,99.31
  IN6 w0.102: 217.46,97.92 218.2,98.67 221.27,98.67 221.46,98.48 223.08,98.48 223.92,99.31
  IN6 w0.13: v2(205.83,91.85) 206.68,91.85 207.65,92.83 207.65,93.39 212.19,97.92 217.46,97.92
  BOTTOM w0.102: UG9.AF9 v2(224.87,99.75) ; UG7.U13 205.62,92.06 v2(205.83,91.85)
FB_D_D10: length 23.2
  IN6 w0.102: 217.25,99.05 217.72,99.51 218.69,99.51 219.71,100.53 222.25,100.53 v2(222.77,101.05)
  IN6 w0.13: 217.25,99.05 210.41,99.05 206.7,95.33 206.7,93.65 206.1,93.05 205.43,93.05 v2(205.03,93.45)
  BOTTOM w0.102: UG9.AG6 v2(222.77,101.05) ; UG7.T11 204.81,93.67 204.81,93.67 v2(205.03,93.45)
FB_D_D11: length 26
  IN6 w0.102: v2(224.29,101.17) 223.27,100.15 220.11,100.15 219.04,99.09 217.89,99.09 217.77,98.96 217.29,98.49
  IN6 w0.13: 217.29,98.49 211.96,98.49 207.15,93.68 207.15,92.76 206.64,92.25 205.43,92.25 v2(205.03,91.85)
  BOTTOM w0.102: v2(205.03,91.85) UG7.T13 ; UG9.AG7 223.49,100.42 224,100.42 224.21,100.63 224.21,101.09 v2(224.29,101.17)
FB_D_D12: length 23
  IN6 w0.102: 219.35,101.21 219.99,101.85 v2(220.77,101.85)
  IN6 w0.13: v2(202.63,93.45) 202.63,93.64 203.03,94.04 203.03,94.49 204.19,95.65 204.64,95.65 210.19,101.21 219.35,101.21
  BOTTOM w0.102: UG7.N11 v2(202.63,93.45) ; v2(220.77,101.85) UG9.AJ4
FB_D_D13: length 26.5
  IN6 w0.102: 219.33,101.86 219.76,102.29 221.03,102.29 v2(221.47,101.85)
  IN6 w0.13: 219.33,101.86 210.05,101.86 204.57,96.38 204.1,96.38 202.23,94.51 202.23,92.25 v2(202.63,91.85)
  BOTTOM w0.102: v2(202.63,91.85) 202.4,92.08 202.4,92.08 UG7.N13 ; UG9.AJ5 v2(221.47,101.85)
FB_D_D14: length 27.4
  IN6 w0.102: 219.23,102.42 219.56,102.75 221.17,102.75 221.45,102.47 222.15,102.47 v2(222.77,101.85)
  IN6 w0.13: v2(201.83,93.45) 201.44,93.84 201.44,94.08 201.43,94.09 201.43,94.42 201.44,94.42 201.44,94.55 203.97,97.08 204.48,97.08 209.82,102.42 219.23,102.42
  BOTTOM w0.102: UG7.M11 v2(201.83,93.45) ; UG9.AJ6 v2(222.77,101.85)
FB_D_D15: length 26.2
  IN6 w0.102: v2(221.47,101.05) 221.25,100.83 218.83,100.83 218.65,100.65
  IN6 w0.13: v2(201.83,91.85) 202.23,91.45 202.83,91.45 203.03,91.65 203.03,93.6 203.03,93.6 203.03,93.62 203.26,93.85 203.28,93.85 203.28,93.85 203.63,93.85 203.83,94.05 203.83,94.46 204.35,94.99 204.77,94.99 210.43,100.65 218.65,100.65
  BOTTOM w0.102: UG9.AG5 v2(221.47,101.05) ; v2(201.83,91.85) 201.62,92.07 UG7.M13
FB_D_D16: length 43.2
  IN6 w0.102: v2(222.91,95.41) 222.46,94.96 222.46,94.68 221.63,93.85 220.03,93.85 219.13,92.95
  IN6 w0.13: v2(192.23,94.25) 191.27,93.3 191.27,89.55 194.21,86.61 194.54,86.28 207.49,86.28 207.82,86.61 214.17,92.95 219.13,92.95
  BOTTOM w0.102: UG7.A11 192.43,94.05 v2(192.23,94.25) ; UG9.Y6 v2(222.91,95.41)
