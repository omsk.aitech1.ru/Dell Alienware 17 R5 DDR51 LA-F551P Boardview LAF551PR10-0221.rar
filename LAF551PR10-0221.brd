# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP1_AUXP: length 67.1
  IN6 w0.089: v2(188.92,152.07) 188.98,152.01 189.3,152.01 189.43,152.13 189.69,152.13 190.1,151.72 190.1,151.13 192.26,148.97 192.26,143.08 193.05,142.29 193.05,139.88 192.55,139.38 192.55,135.95 193.06,135.44 193.06,130.2 183.14,120.29 181.33,120.29 180.79,119.75 178.08,119.75 176.56,118.23 175.39,118.23 172.03,114.86 171.27,114.86 170.7,114.29 v2(170.7,114.23)
  BOTTOM w0.089: v2(170.7,114.23) 171.03,114.56 UC1.D27
  BOTTOM w0.107: v2(188.92,152.07) 189.05,151.95 189.05,151.48 188.94,151.37 188.67,151.37 188.28,151.77 187.36,151.77 186.41,152.72 179.57,152.72 179.02,153.27 179.02,153.99 179.13,154.11 179.28,154.11 179.39,154.21 CT25.1
CPU_DP1_AUXP_C: length 11.8
  TOP w0.094: UT1.Y11 180.25,162.6 180.11,162.6 179.92,162.79 179.92,162.92 v2(180,163.01)
  BOTTOM w0.099: RT78.1 179.41,155.06 CT25.2 ; v2(180,163.01) 180,163.11
  BOTTOM w0.107: 180,163.11 179.93,163.18 179.78,163.18 179.41,162.82 179.41,161.58 179.27,161.44 179.27,160.24 179.37,160.14 179.37,159.59 179.4,159.56 179.4,158.99 179.37,158.96 179.37,158.45 179.37,158.45 179.37,158.38 180.54,157.22 v4(180.54,156.75) 180.54,156.16 180.33,155.95 179.46,155.95 179.17,155.66 179.17,155.29 CT25.2
CPU_DP1_HPD: length 188.7
  TOP w0.089: 210.7,38.52 v2(210.24,38.52)
  TOP w0.102: 175.08,161.85 175.44,162.21 176.15,162.21 UT1.AA2
  TOP w0.107: 175.08,161.85 175.08,161.47 174.69,161.09 v2(174.69,161.04) 174.68,161.04 174.24,160.59 173.11,160.59 RT38.1 ; 210.7,38.52 211.35,39.17 212.15,39.17 212.6,38.73 213.62,38.73 214.13,39.23 214.13,40.5 214.58,40.95 216.1,40.95 218.09,42.94 218.09,43.92 217.19,44.82 214.77,44.82 213.88,43.93 v2(213.88,43.6)
  IN1 w0.089: 213.88,43.88 v2(213.88,43.6)
  IN1 w0.102: 213.88,43.88 214.51,44.52 214.51,45.52 213.97,46.06 213.97,47.39 212.92,48.43 212.92,50.13 208.04,55.01 207.72,55.33 207.72,59.67 203.2,64.18 196.8,64.18 196.64,64.35 v2(196.57,64.35)
  IN2 w0.102: v2(196.57,64.35) 195.57,64.35 193.42,62.2 190.99,62.2 185.2,67.99 182.5,67.99 179.15,71.34 179.15,81.3 181.4,83.56 181.4,84.83 185.02,88.45 185.02,93.49 180.6,97.91 180.6,104.96 182.84,107.2 182.84,121.66 190.67,129.49 190.67,148.14 183.43,155.38 177.73,155.38 177.3,154.94 177.29,154.94 177.27,154.92 174.12,154.92 173.07,155.97 173.07,158.58 173.29,158.79 173.29,159.68 174.65,161.04 v2(174.69,161.04)
  BOTTOM w0.122: v2(210.24,38.52) 210.41,38.7 UH1.AT6
CPU_DP1_N0: length 64.7
  TOP w0.089: CT7.1 177.79,159.02 177.79,158.84 v2(177.99,158.63)
  IN6 w0.089: v2(166.81,123.02) 168.82,123.02 169.86,124.06 175,124.06 175.33,124.39 181.71,124.39 181.71,124.39 181.85,124.39 188.26,130.8 188.26,144.6 187.97,144.89 187.97,147.77 182.13,153.61 182.13,155.46 181.45,156.13 181.45,157.71 181.56,157.81 181.56,158.6 181.13,159.03 179.62,159.03 178.63,158.04 178.02,158.04 177.85,158.22 177.85,158.49 v2(177.99,158.63)
  BOTTOM w0.076: v2(166.81,123.02) 166.81,123.1 167.14,123.43 167.28,123.43 167.36,123.35 167.36,122.62 167.51,122.46 167.51,121.09 167.44,121.01 167.27,121.01 167.19,121.09 167.19,121.33 UC1.K37
CPU_DP1_N0_C: length 2.7
  TOP w0.099: CT7.2 177.75,160.05 177.75,160.27 178.56,161.08 178.76,161.08 178.91,161.23 178.91,161.53 178.84,161.6 178.76,161.6 UT1.AC7
CPU_DP1_N1: length 79.4
  TOP w0.107: v2(177.13,156.99) 177.3,157.15 177.3,157.82 177.53,158.04 178.57,158.04 178.74,158.22 178.74,159.05 CT9.1
  IN6 w0.089: v2(167.64,119.1) 168.43,119.1 168.64,119.3 168.64,121.27 168.77,121.4 173.97,121.4 174.77,122.19 182.35,122.19 190.17,130.01 190.17,143.11 190.36,143.3 190.36,148.08 184.6,153.84 184.6,156.61 184.58,156.62 184.58,157.01 184.86,157.29 184.88,157.29 185.02,157.43 186.45,157.43 186.74,157.72 186.74,159.39 186.12,160 177.31,160 176.22,158.91 176.22,157.9 v2(177.13,156.99)
  BOTTOM w0.076: v2(167.64,119.1) 167.7,119.1 UC1.J34
CPU_DP1_N1_C: length 2.6
  TOP w0.099: CT9.2 178.94,160.19 178.94,160.83 179.37,161.25 179.37,161.32 179.37,161.66 179.43,161.73 179.5,161.73 179.6,161.63 UT1.AC9
CPU_DP1_N2: length 58.2
  TOP w0.107: CT23.1 179.89,159.04 179.89,158.74 179.44,158.28 179.44,157.86 179.19,157.62 179.19,157.18 v2(178.97,156.96)
  IN6 w0.089: v2(168.42,124.74) 168.42,124.7 168.64,124.49 168.97,124.49 169.19,124.7 169.19,125.48 170.17,126.46 180.39,126.46 186.83,132.9 186.83,144.01 186.53,144.3 186.53,147.17 181.19,152.52 179.78,152.52 179.26,153.03 179.26,155.95 179.39,156.08 179.39,156.56 178.99,156.96 v2(178.97,156.96)
  BOTTOM w0.076: v2(168.42,124.74) 168.55,124.62 168.87,124.62 169.05,124.44 169.05,123.39 168.91,123.26 168.91,121.66 169.08,121.48 169.08,121.25 169.08,120.99 UC1.H36
CPU_DP1_N2_C: length 2.4
  TOP w0.099: UT1.AC11 180.52,161.61 180.46,161.68 180.39,161.68 180.3,161.59 180.3,161.32 180.34,161.27 180.34,161.19 180.18,161.03 180.18,160.48 180.09,160.38 180.09,160.19 CT23.2
CPU_DP1_N3: length 57.9
  TOP w0.107: v2(180.34,158.14) 180.54,158.34 180.54,158.47 181,158.93 181,159.08 CT24.1
  IN6 w0.089: v2(167.31,124.6) 168.1,123.82 168.86,123.82 169.69,124.64 170.04,124.64 171.1,125.7 181.2,125.7 187.46,131.96 187.46,144.27 187.17,144.56 187.17,147.44 181.33,153.28 181.33,155.05 180.65,155.73 180.65,157.84 180.52,157.97 180.52,158 180.38,158.14 v2(180.34,158.14)
  BOTTOM w0.076: UC1.J38 168.37,122.01 168.45,122.09 168.45,122.31 168.37,122.38 168.3,122.38 168.17,122.52 168.17,123.07 168.29,123.2 168.29,123.82 167.83,124.29 167.63,124.29 v2(167.31,124.6)
CPU_DP1_N3_C: length 2.4
  TOP w0.099: UT1.AC13 181.44,161.65 181.36,161.73 181.3,161.73 181.21,161.63 181.21,161.28 181.24,161.25 181.24,161.09 181.17,161.02 181.17,160.13 CT24.2
CPU_DP1_P0: length 64.8
  TOP w0.089: CT6.1 177.61,159.04 177.61,158.84 v2(177.41,158.63)
  IN6 w0.089: v2(177.41,158.63) 177.68,158.36 177.68,158.15 177.96,157.88 178.7,157.88 179.69,158.87 181.06,158.87 181.39,158.53 181.39,157.88 181.29,157.78 181.29,156.06 181.96,155.39 181.96,153.54 187.8,147.7 187.8,144.82 188.1,144.53 188.1,130.86 181.78,124.55 175.26,124.55 174.93,124.22 169.79,124.22 168.75,123.18 167.16,123.18 166.81,123.53 v2(166.81,123.6)
  BOTTOM w0.076: v2(166.81,123.6) 167.35,123.6 167.53,123.42 167.53,122.69 167.69,122.54 167.69,121.02 167.5,120.83 UC1.K36
CPU_DP1_P0_C: length 2.7
  TOP w0.099: UT1.AB7 178.59,161.89 178.45,161.75 178.45,161.24 177.56,160.35 177.56,159.95 CT6.2
CPU_DP1_P1: length 79.4
  TOP w0.107: v2(177.72,156.99) 177.51,157.2 177.51,157.73 177.61,157.84 178.65,157.84 178.95,158.14 178.95,159.04 CT8.1
  IN6 w0.089: v2(167.64,119.75) 167.64,119.61 167.98,119.26 168.36,119.26 168.47,119.37 168.47,121.34 168.7,121.56 173.9,121.56 174.7,122.36 182.28,122.36 190,130.07 190,143.18 190.19,143.37 190.19,148.01 184.43,153.77 184.43,156.54 184.42,156.55 184.42,157.08 184.79,157.45 184.81,157.45 184.96,157.6 186.38,157.6 186.57,157.79 186.57,159.32 186.06,159.84 177.38,159.84 176.39,158.84 176.39,157.96 176.97,157.39 177.58,157.39 177.72,157.24 v2(177.72,156.99)
  BOTTOM w0.076: v2(167.64,119.75) 167.7,119.75 UC1.J35
CPU_DP1_P1_C: length 2.6
  TOP w0.099: UT1.AB9 179.6,161.92 179.82,161.7 179.82,161.69 179.83,161.69 179.83,161.35 179.69,161.22 179.61,161.22 179.14,160.75 CT8.2
CPU_DP1_P2: length 58.1
  TOP w0.107: v2(179.56,156.96) 179.4,157.12 179.4,157.53 179.64,157.78 179.64,158.2 180.09,158.66 180.09,159.04 CT10.1
  IN6 w0.089: v2(168.42,124.2) 168.55,124.32 169.04,124.32 169.35,124.63 169.35,125.4 170.25,126.3 180.45,126.3 186.99,132.84 186.99,144.07 186.7,144.37 186.7,147.24 181.26,152.68 179.85,152.68 179.43,153.1 179.43,155.88 179.56,156.01 v2(179.56,156.96)
  BOTTOM w0.076: UC1.H37 168.81,121.08 168.73,121.01 168.6,121.01 168.47,121.13 168.47,121.43 168.69,121.64 168.74,121.69 168.74,123.33 168.87,123.46 168.87,124.37 168.8,124.44 168.61,124.44 168.42,124.25 v2(168.42,124.2)
CPU_DP1_P2_C: length 2.5
  TOP w0.099: UT1.AB11 180.52,161.94 180.75,161.71 180.75,161.32 180.37,160.95 180.37,160.4 180.28,160.3 CT10.2
CPU_DP1_P3: length 57.9
  TOP w0.107: v2(180.92,158.14) 180.78,158.28 180.78,158.43 181.2,158.85 181.2,159 CT11.1
  IN6 w0.089: v2(167.3,124.03) 167.63,124.03 168.03,123.64 168.92,123.64 169.76,124.48 170.11,124.48 171.17,125.54 181.27,125.54 187.63,131.89 187.63,144.34 187.33,144.63 187.33,147.51 181.49,153.35 181.49,155.12 180.82,155.79 180.82,158.03 v2(180.92,158.14)
  BOTTOM w0.076: UC1.J37 167.99,121.39 167.99,123.15 168.12,123.27 168.12,123.75 167.76,124.11 167.39,124.11 v2(167.3,124.03)
CPU_DP1_P3_C: length 2.4
  TOP w0.099: CT11.2 181.36,159.87 181.36,160.94 181.43,161.01 181.43,161.11 181.67,161.35 181.67,161.75 UT1.AB13
CPU_DP2_AUXN: length 67
  IN6 w0.089: v2(170.06,113.47) 170.28,113.68 172.48,113.68 173.22,114.42 173.22,115.29 175.67,117.74 177.05,117.74 178.42,119.12 181.06,119.12 181.29,119.35 183.11,119.35 193.69,129.94 193.69,137.8 193.68,137.8 193.68,148.44 190.74,151.39 190.74,151.98 189.31,153.41 188.56,153.41 188.14,152.98 188.01,152.98 v2(187.91,153.09)
  BOTTOM w0.089: v2(170.06,113.47) 170.38,113.79 UC1.E26
  BOTTOM w0.107: CT36.1 181.94,154.43 181.63,154.12 181.63,153.76 181.86,153.53 186.57,153.53 187.65,152.46 187.91,152.46 188.07,152.61 188.07,152.73 188.15,152.82 188.15,152.97 188.03,153.09 v2(187.91,153.09)
CPU_DP2_AUXN_C: length 10.5
  TOP w0.089: UT1.W12 v2(180.65,163.66)
  BOTTOM w0.099: CT36.2 182.56,155.07 RT77.1
  BOTTOM w0.107: v2(180.65,163.66) 181.3,163.01 181.3,161.92 181.41,161.81 181.41,160.48 181.11,160.18 v4(181.11,159.6) 181.11,158.87 181.62,158.36 181.62,156.03 181.8,155.85 181.8,155.21 CT36.2
CPU_DP2_AUXP: length 67
  IN6 w0.089: v2(169.43,113.47) 169.81,113.85 172.41,113.85 173.06,114.49 173.06,115.36 175.6,117.9 176.98,117.9 178.35,119.28 180.99,119.28 181.22,119.52 183.04,119.52 193.53,130 193.53,137.73 193.52,137.74 193.52,148.37 190.57,151.32 190.57,151.91 189.24,153.24 188.63,153.24 188.47,153.09 v2(188.47,152.5)
  BOTTOM w0.089: UC1.F26 169.73,113.77 v2(169.43,113.47)
  BOTTOM w0.107: CT35.1 181.43,154.41 181.43,153.67 181.77,153.33 186.49,153.33 187.56,152.25 187.99,152.25 188.24,152.5 v2(188.47,152.5)
CPU_DP2_AUXP_C: length 10.4
  TOP w0.089: v2(180.65,163.01) 180.72,163.07 181.01,163.07 181.13,162.96 181.13,162.83 UT1.Y12
  BOTTOM w0.099: RT79.1 181.34,155.06 CT35.2
  BOTTOM w0.107: CT35.2 181.6,155.31 181.6,155.77 181.42,155.94 181.42,158.28 180.91,158.78 180.91,159.29 180.88,159.32 180.88,159.89 180.91,159.92 180.91,160.27 181.21,160.57 181.21,161.72 181.1,161.83 181.1,162.92 180.91,163.11 180.76,163.11 v2(180.65,163.01)
CPU_DP2_HPD: length 182.3
  TOP w0.089: 217.9,43.79 217.9,43.01 216.18,41.29 214.6,41.29 213.94,40.63 213.94,39.31 213.55,38.91 212.67,38.91 212.23,39.36 211.27,39.36 210.88,38.97 210.17,38.97 209.87,38.67 209.87,36.98 v2(210.27,36.58) ; v2(214.45,43.62) 214.45,43.88
  TOP w0.102: 214.45,43.88 214.45,44.04 ; v2(178.7,163.01) UT1.Y6
  TOP w0.107: 214.45,44.04 214.94,44.53 217.15,44.53 217.9,43.79
  IN1 w0.089: v2(214.45,43.62) 214.71,43.88
  IN1 w0.102: v2(196.54,64.95) 196.67,64.95 197.19,64.43 203.28,64.43 207.97,59.74 207.97,55.4 208,55.38 208.13,55.24 213.15,50.22 213.15,48.52 214.19,47.48 214.19,46.16 214.83,45.52 214.83,44.01 214.79,43.97 214.79,43.96 214.71,43.88
  IN2 w0.102: v2(178.43,155.82) 178.55,155.69 183.8,155.69 190.9,148.59 190.9,129.35 183.13,121.59 183.13,107.13 180.88,104.87 180.88,97.96 185.25,93.58 185.25,88.35 181.63,84.73 181.63,83.46 179.38,81.21 179.38,74.33 179.49,74.21 180.22,73.48 180.22,70.59 182.56,68.25 185.3,68.25 189.05,64.51 190.66,64.51 192.02,63.15 192.02,62.99 192.26,62.76 192.39,62.62 193.52,62.62 195.85,64.95 v2(196.54,64.95)
  BOTTOM w0.102: v2(178.7,163.01) 178.72,162.98 178.72,162.08 RT39.1 178.72,161.95 178.58,161.81 v1(178.58,160.76) 178.58,157.86 178.43,157.71 v2(178.43,155.82)
  BOTTOM w0.107: UH1.AN10 v2(210.27,36.58)
CPU_DP2_N0: length 65.9
  TOP w0.107: CT28.1 182,158.13 181.91,158.05 181.91,156.91 182.7,156.12 185.55,156.12 185.92,155.75 186.52,155.75 187.12,156.35 187.12,156.66 v2(187.32,156.86)
  IN6 w0.089: v2(169.31,118.29) 170.86,118.29 171.4,118.82 172.7,118.82 173.05,119.17 174.24,119.17 175.99,120.92 182.88,120.92 191.44,129.48 191.44,142.59 191.63,142.78 191.63,148.7 186.99,153.34 186.99,156.53 v2(187.32,156.86)
  BOTTOM w0.076: UC1.H33 168.83,118.76 v2(169.31,118.29)
CPU_DP2_N0_C: length 2.4
  TOP w0.099: UT1.AC15 182.36,161.61 182.29,161.68 182.2,161.68 182.13,161.6 182.13,161.34 182.31,161.16 182.31,160.74 182.31,160.64 182.31,160.47 182.25,160.41 182.25,160.06 CT28.2
CPU_DP2_N1: length 57.7
  TOP w0.089: CT30.1 183.35,159.02 183.35,158.8 183.33,158.78 v2(183.16,158.61)
  IN6 w0.089: v2(183.16,158.61) 183.4,158.38 183.4,157.8 183.78,157.42 183.78,156.1 183.78,156.1 183.78,155.58 183.78,153.52 189.56,147.75 189.56,143.64 189.37,143.44 189.37,130.34 182.02,122.99 173.07,122.99 172.42,122.34 171.22,122.34 170.37,123.19 170.37,123.26 170.01,123.62 v2(170.01,123.69)
  BOTTOM w0.076: UC1.G38 169.16,122.01 169.08,122.09 169.08,122.36 169.15,122.43 169.36,122.43 169.41,122.48 169.41,123.42 169.57,123.57 169.89,123.57 v2(170.01,123.69)
CPU_DP2_N1_C: length 2.4
  TOP w0.099: CT30.2 183.33,160.01 183.33,160.37 183.28,160.42 183.28,161.19 183.25,161.22 183.19,161.22 183.05,161.35 183.05,161.37 183.05,161.59 183.13,161.66 183.21,161.66 183.28,161.59 UT1.AC17
CPU_DP2_N2: length 59.1
  TOP w0.099: 185.24,157 v2(185.05,156.82)
  TOP w0.107: 185.24,157 185.24,157.4 184.49,158.15 184.49,159.02 CT32.1
  IN6 w0.089: v2(185.05,156.82) 185.07,156.82 185.47,156.41 185.47,153.63 190.83,148.27 190.83,143.11 190.64,142.92 190.64,129.81 182.55,121.72 175.04,121.72 173.89,120.58 173.11,120.58 172,119.47 170.93,119.47 170.7,119.24 169.79,119.24 169.55,119.48 169.55,119.67 169.7,119.82 169.93,119.82 v2(169.99,119.76)
  BOTTOM w0.076: UC1.F35 169.9,119.76 v2(169.99,119.76)
CPU_DP2_N2_C: length 2.4
  TOP w0.099: UT1.AC19 184.2,161.56 184.1,161.66 184.03,161.66 183.97,161.59 183.97,161.31 184.11,161.16 184.17,161.16 184.24,161.1 184.24,160.87 184.48,160.63 184.48,160.01 CT32.2
CPU_DP2_N3: length 59.9
  TOP w0.089: CT34.1 185.66,158.99 185.66,158.75 v2(185.48,158.57)
  IN6 w0.089: v2(171.21,123.05) 171.21,123.12 171.56,123.47 181.83,123.47 188.9,130.53 188.9,144.86 188.6,145.16 188.6,148.03 183.31,153.33 183.31,155.29 182.09,156.51 182.09,157.45 182.19,157.55 182.19,158.62 182.71,159.14 185.62,159.14 185.75,159.01 185.75,158.81 185.51,158.57 v2(185.48,158.57)
  BOTTOM w0.076: v2(171.21,123.05) 171.13,123.05 170.57,122.48 170.57,121.88 170.79,121.67 170.79,121.35 170.38,120.95 UC1.E36
CPU_DP2_N3_C: length 2.5
  TOP w0.099: CT34.2 185.61,160 185.61,160.52 185.24,160.9 185.24,161.09 185.18,161.15 184.96,161.15 184.89,161.22 184.89,161.54 184.96,161.61 185.03,161.61 185.12,161.52 UT1.AC21
CPU_DP2_P0: length 65.9
  TOP w0.107: v2(186.5,156.86) 186.51,156.86 186.63,156.98 186.81,156.98 186.91,156.88 186.91,156.43 186.43,155.95 186.01,155.95 185.63,156.33 182.78,156.33 182.11,157 182.11,157.96 182.2,158.05 182.2,158.79 182.31,158.89 182.47,158.89 182.57,158.99 CT27.1
  IN6 w0.089: v2(186.5,156.86) 186.83,156.54 186.83,153.27 191.46,148.63 191.46,142.85 191.27,142.65 191.27,129.55 182.81,121.09 175.92,121.09 174.17,119.33 172.98,119.33 172.63,118.99 171.33,118.99 170.8,118.45 169.65,118.45 169.31,118.8 v2(169.31,118.92)
  BOTTOM w0.076: v2(169.31,118.92) 169.29,118.92 UC1.H34
CPU_DP2_P0_C: length 2.4
  TOP w0.099: UT1.AB15 182.37,161.98 182.59,161.67 182.59,161.29 182.51,161.21 182.51,160.74 182.51,160.74 182.51,160.58 182.51,160.39 182.44,160.32 182.44,159.93 CT27.2
CPU_DP2_P1: length 57.7
  TOP w0.089: v2(183.74,158.62) 183.52,158.84 183.52,159.04 183.71,159.22 CT29.1
  IN6 w0.089: v2(170.01,123.11) 170.22,123.11 171.15,122.18 172.49,122.18 173.14,122.83 182.09,122.83 189.53,130.27 189.53,143.38 189.72,143.57 189.72,147.81 183.94,153.59 183.94,155.51 183.94,157.49 183.56,157.87 183.56,158.43 v2(183.74,158.62)
  BOTTOM w0.076: v2(170.01,123.11) 170.01,123.2 169.83,123.38 169.66,123.38 169.6,123.33 169.6,121.83 169.59,121.81 UC1.F37
CPU_DP2_P1_C: length 2.4
  TOP w0.099: UT1.AB17 183.29,161.98 183.51,161.67 183.51,161.35 183.47,161.31 183.47,160.51 183.53,160.45 183.53,159.99 CT29.2
CPU_DP2_P2: length 59.1
  TOP w0.107: v2(185.64,156.82) 185.44,157.02 185.44,157.49 184.69,158.23 184.69,159.07 CT31.1
  IN6 w0.089: v2(169.2,119.73) 169.2,119.6 169.73,119.07 170.76,119.07 171,119.31 172.07,119.31 173.18,120.41 173.96,120.41 175.1,121.56 182.61,121.56 190.8,129.74 190.8,142.85 190.99,143.04 190.99,148.34 185.64,153.69 v2(185.64,156.82)
  BOTTOM w0.076: v2(169.2,119.73) 169.52,119.41 UC1.F34
CPU_DP2_P2_C: length 2.4
  TOP w0.099: CT31.2 184.67,160 184.67,160.71 184.43,160.95 184.43,161.75 UT1.AB19
CPU_DP2_P3: length 59.9
  TOP w0.089: v2(186.07,158.57) 185.84,158.8 185.84,159.07 CT33.1
  IN6 w0.089: v2(171.21,123.63) 181.76,123.63 188.73,130.6 188.73,144.8 188.44,145.09 188.44,147.96 183.14,153.26 183.14,155.22 181.92,156.44 181.92,157.52 182.03,157.62 182.03,158.69 182.64,159.3 185.72,159.3 185.91,159.11 185.91,158.73 v2(186.07,158.57)
  BOTTOM w0.076: UC1.E37 170.55,121.36 170.61,121.42 170.61,121.59 170.4,121.81 170.4,122.55 170.86,123.01 170.86,123.19 171.21,123.55 v2(171.21,123.63)
CPU_DP2_P3_C: length 2.5
  TOP w0.099: UT1.AB21 185.35,161.75 185.35,161.28 185.43,161.2 185.43,160.98 185.81,160.6 185.81,160 CT33.2
CPU_FAN_FB: length 217.3
  TOP w0.102: RF1.1 104.2,58.84 v2(103.84,58.48) 103.14,59.18 DF1.2
  TOP w0.107: UE5.28 294.74,26.69 295,26.95 v1(295,28.08) 295,29.55 294.42,30.13 v2(294.42,31.11)
  IN2 w0.102: v2(294.42,31.11) 293.76,31.77 292.91,31.77 287.71,36.97 283.88,36.97 279.01,41.85 274.64,41.85 269.46,47.03 255.92,47.03 255.14,47.81 245.27,47.81 244.2,48.88 243.8,49.28 242.36,49.28 241.55,50.09 238,50.09 237.18,49.28 233.39,49.28 232.77,49.9 227.57,49.9 226.3,51.17 212.78,51.17 207.03,56.92 202.78,56.92 199.59,53.73 195.93,53.73 194.97,54.69 188.29,54.69 185.73,52.14 182.06,52.14 181.62,51.69 180.14,51.69 178.98,50.53 177.16,50.53 175.9,51.8 174.96,51.8 172.92,53.84 150.23,53.84 149.87,53.48 148.51,53.48 148,53.99 109.13,53.99 104.64,58.48 v2(103.84,58.48)
CPU_FAN_PWM: length 222.7
  TOP w0.107: UE5.26 295.54,26.73 295.56,26.75 v1(295.56,30.18) 295.56,30.77 v2(295.28,31.05)
  TOP w0.254: RF2.1 104.93,63.06 v2(105.03,63.16) 105.62,63.76 JFAN1.2
  IN2 w0.102: v2(105.03,63.16) 104.64,62.78 104.64,58.92 109.34,54.22 148.09,54.22 148.61,53.7 148.97,53.7 149.74,54.47 173.75,54.47 177.47,50.76 178.89,50.76 180.05,51.92 181.53,51.92 181.97,52.37 185.64,52.37 188.19,54.92 195.07,54.92 196.02,53.96 199.5,53.96 202.69,57.15 207.12,57.15 212.87,51.4 226.39,51.4 227.66,50.13 232.86,50.13 233.48,49.51 237.09,49.51 237.9,50.32 241.64,50.32 242.46,49.51 243.9,49.51 244.43,48.97 245.37,48.03 255.24,48.03 256.02,47.25 269.55,47.25 274.73,42.07 279.1,42.07 283.98,37.2 287.8,37.2 293.01,31.99 294.51,31.99 295.28,31.22 v2(295.28,31.05)
CPU_TRIGGER: length 97
  TOP w0.114: RH192.1 176.16,111.53 176.19,111.53 178.57,109.15 178.57,103.64 180.67,101.55 180.67,98.11 181.55,97.22 183.89,97.22 187.12,94 v1(187.12,80.28) 187.12,73.63 190.31,70.44 190.31,68.72 190.94,68.09 190.94,62.43 191.18,62.19 192.28,62.19 193.59,63.5 199.02,63.5 v2(199.25,63.27)
  IN1 w0.081: v2(199.25,63.27) 199.12,63.27 198.89,63.05 198.89,62.61 200.92,60.58 200.92,56.32 197.59,52.98 197.59,52.44 197.92,52.1 198.28,52.1 200.7,49.68 200.7,48.49 203.26,45.93 204.96,45.93 207.01,43.88
  IN1 w0.089: 207.01,43.88 v2(207.46,43.42)
  BOTTOM w0.089: v2(207.46,43.42) 208,42.89 208,41.07 207.8,40.87 UH1.AK2
CPU_VCCIO_PWR_GATE#: length 8.1
  BOTTOM w0.089: 213.56,43.88 213.47,43.79 213.47,43.22 213.33,43.09 212.61,42.36 212.61,42.15 212.48,42.02 212.48,40.44 212.83,40.09 UH1.AY3
  BOTTOM w0.102: 213.56,43.88 213.67,43.98 214.73,43.98 215.05,44.3 215.51,44.3 215.97,44.76 216.21,44.76 RH180.2
CPU_XDP_TRST#: length 293.9
  TOP w0.114: RH497.2 128.79,159.01 128.79,159.76 128.6,159.94 126.37,159.94 v2(125.58,160.73) 125.27,161.04 125.27,161.62 124.83,162.06 122.77,162.06 122.1,162.73 118.78,162.73 118.34,162.3 118.34,161.44 JPCMC.28
  IN1 w0.081: v2(203.34,57.8) 203.34,57.76 202.54,56.96 202.54,56.15 201.85,55.47 201.85,48.97 203.74,47.08 205.71,47.08 208.47,44.32 208.47,43.88 ; 129.44,118.74 127.41,120.78 127.41,126.34 121.19,132.55 121.19,133.76 120.13,134.83 120.13,136.4 119.27,137.26 119.27,143.41 119.8,143.94 119.8,146.47 120.07,146.75 120.07,148.3 122.67,150.9 122.67,151.8 126.63,155.76 126.63,159.16 125.58,160.21 v2(125.58,160.73)
  IN1 w0.089: 208.47,43.88 208.35,43.76 208.35,41.46 208.86,40.95 208.86,39.21 v2(208.57,38.92) ; v2(130.58,117.6) 129.44,118.74
  IN3 w0.127: v2(130.58,117.6) 130.88,117.3 130.88,115.99 131.19,115.69 131.54,115.69 131.73,115.5 132.01,115.5 132.75,114.75 132.75,106.91 130.65,104.81 130.65,103.77 129.96,103.08 129.96,102.14 129.1,101.28 129.1,100.32 128.15,99.37 128.15,98.05 127.72,97.62 127.72,77.39 115.56,65.23 114.15,65.23 108.54,59.63 108.54,43.9 113.18,39.27 v2(113.18,38.41)
  IN6 w0.081: v2(203.34,57.8) 203.31,57.78 202.22,57.78 199.03,54.59 196.71,54.59 196.08,55.22 196.08,55.22 195.69,55.61 195.69,55.61 195.37,55.93 188.98,55.93 188.49,55.43 188.02,55.43 185.43,52.85 185.43,44.29 180.02,38.87 176.37,38.87 175.76,38.27 174.78,38.27 174.38,38.66 173.81,38.66 172.71,37.57 168.69,37.57 168.54,37.42 122.36,37.42 119.86,39.92 114.69,39.92 v2(113.18,38.41)
  BOTTOM w0.076: UC1.BP30 133.36,117.09 133,117.09 132.84,117.25 130.93,117.25 v2(130.58,117.6)
  BOTTOM w0.122: UH1.AM4 208.9,39.71 208.57,39.38 v2(208.57,38.92)
CS1: length 3.9
  BOTTOM w0.102: PR106.2 v1(50.88,49.41)
  BOTTOM w0.203: PU100.1 53.06,49.38 52.86,49.58 51.81,49.58 51.06,50.33 PR106.2
CS2: length 3.5
  BOTTOM w0.102: PR105.2 56.59,50.01 v1(56.59,49.43)
  BOTTOM w0.203: PU100.5 54.66,49.45 54.81,49.59 55.39,49.59 PR105.2
CS_1.2V: length 7.2
  IN3 w0.254: v2(97.1,41.01) 96.27,41.01 95.67,41.61 95.67,41.98 94.23,43.42 v2(92.74,43.42)
  BOTTOM w0.203: PU201.13 92.69,43.47 v2(92.74,43.42)
  BOTTOM w0.254: PR201.2 97.35,41.27 v2(97.1,41.01)
CSCOMP_2PH: length 34.6
  TOP w0.203: PU500.31 120.75,143.5 120.69,143.56 120.14,143.56 v2(120.07,143.63)
  IN4 w0.254: v2(139.99,134.09) 139.91,134.01 138.14,134.01 131.3,140.85 129.5,140.85 128.29,139.63 125.69,139.63 125.36,139.96 120.07,139.96 119.5,140.54 119.5,143.41 119.75,143.67 120.04,143.67 v2(120.07,143.63)
  BOTTOM w0.102: v2(139.99,134.09) 139.99,133.7 v1(139.39,133.1)
  BOTTOM w0.254: PC528.1 120.35,144.25 PC526.1 ; PC526.1 120.34,143.9 v2(120.07,143.63) ; PC526.1 120.04,144.55 PR542.2 PR544.1 ; v2(139.99,134.09) 140.12,134.22 PH502.1
CSCOMP_4PH: length 34.1
  TOP w0.203: PU500.8 127.69,143.1 127.76,143.17 127.8,143.17 127.86,143.23 128.18,143.23 ; PR541.1 129.73,144.15 PC524.2 128.81,143.23 128.18,143.23 ; 128.18,143.23 v2(128.18,143.23)
  IN4 w0.254: v2(128.18,143.23) 130.8,143.23 131.17,142.85 131.17,142.71 138.85,135.03 140.85,135.03 141.23,134.65 142.36,134.65 144.44,132.58 147.93,132.58 149.27,133.91 150,133.91 v2(150.06,133.98)
  BOTTOM w0.102: v1(130.76,142.1) 130.48,142.1 130.2,142.38 130.2,143.02 129.93,143.28 PR543.1
  BOTTOM w0.254: v2(128.18,143.23) 128.23,143.28 PC524.2 PR543.1 ; PH501.1 149.92,134.12 v2(150.06,133.98)
CSN_1PH: length 79.6
  TOP w0.102: v1(126.18,132.1) 125.92,132.36 v2(125.92,132.74)
  TOP w0.254: PR503.1 v2(125.92,132.74)
  IN4 w0.254: v2(125.92,132.74) 126.45,133.27 127.34,133.27 128.33,134.26 128.33,135.29 128.71,135.68 128.71,136.35 128.38,136.68 128.38,138.05 129.17,138.84 129.64,138.84 129.64,138.84 129.95,138.84 130.03,138.76 130.44,138.76 138.02,131.18 151.05,131.18 151.64,130.58 161.64,130.58 162.25,129.98 175.42,129.98 176.03,130.58 178.95,130.58 180.2,131.83 186.11,131.83 186.8,132.52 186.8,133.03 186.8,133.35 186.31,133.84 185.85,133.84 v2(185.7,133.99)
  BOTTOM w0.254: v2(185.7,133.99) 186.27,133.99 PH500.1 185.72,135.11 183.65,135.11 183.21,134.67 PL508.3
CSN_1PH_R: length 9.3
  TOP w0.102: v2(126.02,134.95) 125.66,135.31 v1(125.61,135.31)
  TOP w0.203: v2(125.09,138.57) 125,138.66 125,138.87 124.94,138.93 PU500.48
  TOP w0.254: PR503.2 126.02,134.45 v2(126.02,134.95)
  IN3 w0.254: v2(126.02,134.95) 126.32,134.95 126.58,135.21 126.58,136.48 125.09,137.96 v2(125.09,138.57)
  BOTTOM w0.254: PC501.1 PC505.1 126.02,134.42 v2(126.02,134.95) ; v2(125.09,138.57) 124.8,138.87 PC504.1
CSNSUM: length 2.8
  BOTTOM w0.203: PR6020.2 270.97,137.34 v1(271.79,137.34) 272.23,137.79 272.23,137.98 272.53,138.27 PU6000.21
CSON_1: length 41.6
  TOP w0.102: v2(55.9,18.25) 55.41,18.25 v1(55.29,18.14)
  TOP w0.254: v2(55.9,18.25) 56.26,18.61 PC721.1 56.54,18.6 PC717.2 57.4,19.4 PR723.2
  IN3 w0.254: v2(55.9,18.25) 57.1,18.25 58.93,20.08 62.23,20.08 63.89,18.42 63.89,17.13 64.28,16.74 66.16,16.74 66.59,16.31 78.44,16.31 81.86,19.73 81.86,21.36 81.96,21.47 81.96,23.13 v2(79.51,25.58)
  BOTTOM w0.254: v2(79.51,25.58) 79.83,25.26 PR712.3
CSOP_1: length 41.7
  TOP w0.102: v2(57.82,17.01) 57.82,16.69 v1(58,16.51)
  TOP w0.254: v2(57.82,17.01) 58.31,17.5 PC716.2 PC717.1 58.37,18.65 PR722.2
  IN3 w0.254: v2(57.82,17.01) 57.5,17.33 57.5,18.11 59.08,19.69 62.08,19.69 63.51,18.26 63.51,16.97 64.12,16.36 66,16.36 66.43,15.93 78.6,15.93 82.24,19.57 82.24,21.21 82.34,21.31 82.34,23.45 v2(80.15,25.64)
  BOTTOM w0.254: PR712.2 79.83,26.03 80.15,25.71 v2(80.15,25.64)
CSP1_2PH: length 6.9
  TOP w0.203: PU500.28 120.66,144.7 120.35,145.01 120.35,146.76 120.58,146.99 v2(120.66,146.99)
  BOTTOM w0.254: v2(120.66,146.99) 120.66,147.04 120.68,147.07 120.68,148.19 PC534.2 120.51,148.36 120.51,149.11 v1(120.58,149.19) 120.62,149.23 122.03,149.23 PR595.1
CSP1_4PH: length 4.1
  TOP w0.203: PU500.11 127.67,144.3 128.07,144.71 128.23,144.71 v2(128.26,144.73) 128.51,144.98 PR557.2
  BOTTOM w0.254: PR596.2 128.36,145.65 PR557.2 128.51,144.98 v2(128.26,144.73)
CSP2_4PH: length 5
  TOP w0.203: PR587.2 128.5,146.37 127.99,146.37 v2(127.87,146.26) 127.87,144.99 127.86,144.98 127.86,144.97 127.6,144.7 PU500.12
  BOTTOM w0.102: v2(127.87,146.26) 127.87,146.38 v1(127.45,146.8)
  BOTTOM w0.254: PR598.2 PC535.2 128.41,146.26 v2(127.87,146.26)
CSP3_4PH: length 5.4
  TOP w0.203: PR581.2 128.5,147.6 128.12,147.6 v2(127.89,147.36) v1(127.42,146.89) 127.42,145.3 PU500.13
  BOTTOM w0.254: v2(127.89,147.36) 127.89,147.94 128.07,148.12 PC536.2 128.53,148.16 128.53,148.97 PR599.2
CSP4_4PH: length 13.9
  TOP w0.203: 121.24,149.25 121.24,147.53 121.5,147.27 121.5,146.28 121.74,146.04 PU500.26
  TOP w0.254: 127.85,149.63 v2(127.9,149.63) ; 127.85,149.63 128.51,148.97 PR582.2 ; 127.85,149.63 126.93,150.55 v1(126.45,150.55) 124.7,150.55 123.73,149.58 121.57,149.58 121.24,149.25
  BOTTOM w0.254: v2(127.9,149.63) 128.25,149.63 PC537.2 PR600.2
CSP_1PH: length 71.3
  TOP w0.203: v2(124.61,138.2) 124.62,138.2 124.57,138.26 124.57,139.6 PU500.47
  TOP w0.254: v2(125.13,134.95) 125.13,134.45 PR501.2 ; PR502.1 180.03,133.23 v2(180.03,132.9)
  IN3 w0.254: v2(124.61,138.2) 124.62,138.2 124.62,137.65 125.61,136.66 125.61,135.23 125.54,135.15 125.54,135.13 125.36,134.95 v2(125.13,134.95)
  IN6 w0.254: v2(125.13,134.95) 125.26,134.95 125.61,135.31 125.61,135.92 126.55,136.86 129.45,136.86 135.99,130.32 153.77,130.32 155.42,131.97 158.73,131.97 160.38,130.32 174.95,130.32 174.97,130.34 174.97,130.37 175.57,130.97 179.49,130.97 179.84,131.32 179.84,132.71 v2(180.03,132.9)
  BOTTOM w0.254: PC501.2 PC505.2 125.1,134.42 125.1,134.93 v2(125.13,134.95)
CSPSUM: length 19.4
  TOP w0.254: v2(271.5,137.82) 271.36,137.67 v1(269.59,137.67) v2(267.53,137.67) ; v2(267.53,137.67) 267.53,137.47 268.04,136.96 268.04,136.28 v2(267.53,135.77) 268.02,135.28 268.02,134.34 v2(267.53,133.86) ; v2(267.53,137.67) v2(267.53,139.51)
  BOTTOM w0.203: PR6008.1 271.39,137.82 v2(271.5,137.82) 271.57,137.82 272.42,138.67 PU6000.22
  BOTTOM w0.254: v2(267.53,133.86) PC6003.1 266.03,133.86 PR6004.2 ; v2(267.53,139.51) PC6006.1 266.04,139.51 PR6001.2 ; v2(267.53,137.67) PR6012.1 266.04,137.67 PR6002.2 ; v2(267.53,135.77) PC6004.1 266.04,135.77 PR6003.2
CSREF_2PH: length 46.2
  TOP w0.203: PU500.29 120.61,144.3 120.54,144.37 120.53,144.37 120.02,144.87 120.02,147.09 119.66,147.45 119.56,147.45 v2(119.43,147.58)
  TOP w0.254: PR588.2 v2(141.39,138.59)
  IN4 w0.254: v2(141.39,138.59) 136.15,138.59 135.12,139.61 135.12,149.86 134.44,150.55 130.18,150.55 129.49,149.85 129.49,146.32 128.71,145.55 120.94,145.55 120.07,146.41 120.07,147.4 119.92,147.55 119.46,147.55 v2(119.43,147.58)
  BOTTOM w0.254: PC527.1 120.11,146.65 120.11,147.16 v1(120,147.26) 119.79,147.48 119.56,147.48 119.54,147.5 119.53,147.5 119.43,147.6 ; 119.43,147.6 119.43,147.89 PC534.1 ; 119.43,147.6 v2(119.43,147.58)
CSREF_4PH: length 74.5
  TOP w0.203: PU500.10 127.55,143.9 127.62,143.97 127.8,143.97 127.98,144.15 v2(128.16,144.15)
  TOP w0.254: PR597.2 173.5,134.55 v1(171.84,134.55) 165.75,134.55 PR579.2 164.66,134.6 160.74,134.6 160.16,135.18 PR569.2 159.57,134.62 156.57,134.62 153.25,137.95 150.35,137.95 PR559.2 v2(149.14,138.55)
  IN3 w0.254: v2(128.16,144.15) 129.39,144.15 129.65,144.4 v2(129.65,144.86)
  IN6 w0.254: v2(129.65,144.86) 130.67,145.88 132.61,145.88 133.18,145.32 133.18,144.47 133.28,144.37 133.28,144.32 135.8,141.81 135.8,134.32 137.83,132.29 147.79,132.29 149.14,133.65 v2(149.14,138.55)
  BOTTOM w0.254: v2(129.65,144.86) 129.65,144.86 129.65,145.01 129.42,145.24 PC533.1 PC535.1 PR598.1 129.42,148.11 PC536.1 129.42,148.13 PR599.1 PC537.1 PR600.1 ; v2(128.16,144.15) 127.9,143.89 PC525.2 127.44,144.71 PR596.1
CSSN_1: length 15.8
  TOP w0.254: v2(62.18,33.01) 62.07,32.91 62.07,32.3 60.27,30.5 60.27,29.27 PR704.1
  IN3 w0.254: v2(59.57,39.61) 59.65,39.61 59.94,39.32 60.59,39.32 60.84,39.07 60.84,35.01 61.69,34.16 61.69,33.39 62.08,33.01 v2(62.18,33.01)
  BOTTOM w0.254: PR702.3 58.75,39.36 59,39.61 v2(59.57,39.61)
CSSN_2: length 5.2
  TOP w0.203: PU700.1 58.64,26.39 v2(59.05,26.8) 59.52,26.8 v1(59.88,27.16) 60.51,27.79 PR704.2
  BOTTOM w0.254: v2(59.05,26.8) 59.05,26.74 59.43,26.36 PC709.1 59.64,27.31 PC708.2
CSSN_B+: length 183.8
  TOP w0.102: PR6100.3 86.88,21.08 v1(87.31,20.65)
  TOP w0.254: v2(89.25,24.82) 87.58,24.82 86.88,24.13 PR6100.3
  IN3 w0.254: v2(183.21,103.05) 183.1,103.15 182.63,103.15 182.38,102.9 182.38,101.84 177.99,97.45 173.67,97.45 172.22,96 172.22,92.73 173.3,91.65 173.3,88.8 172.22,87.72 172.22,75.11 170.76,73.65 170.76,61.01 170,60.25 170,54.41 168.41,52.82 168.41,42.98 165.68,40.25 165.68,32.31 164.47,31.11 112.49,31.11 107.79,26.41 101.67,26.41 100.16,24.9 89.33,24.9 v2(89.25,24.82)
  BOTTOM w0.254: RG59.1 191.83,113.53 190.64,112.33 190.64,110.39 189.69,109.44 189.69,106.2 186.65,103.17 183.32,103.17 v2(183.21,103.05)
CSSN_NVVDD: length 59.5
  IN1 w0.254: v2(185.81,117.07) 182.36,120.52 v2(179.26,120.52)
  BOTTOM w0.254: PR6101.3 204.65,147.99 204.16,147.5 204.16,145.07 203.91,144.81 195.77,144.81 193.59,146.99 192.41,146.99 189.15,143.73 189.15,127.7 182.96,121.5 v1(182.57,121.5) 180.24,121.5 v2(179.26,120.52) ; RG64.1 v2(185.81,117.07)
CSSN_NVVDDS: length 167.7
  IN6 w0.254: v2(271.06,42.5) 267.19,46.38 248.23,46.38 246.39,48.23 232.35,48.23 231.29,49.29 227.71,49.29 226.61,50.38 225.05,50.38 224.56,49.89 220.86,49.89 220.61,49.63 v2(220.61,49.39)
  BOTTOM w0.254: PR6401.3 271.01,40.15 271.01,42.45 v2(271.06,42.5) ; RG138.1 188.48,123.24 184.73,119.5 184.73,117.47 186.29,115.91 186.29,107.53 182.62,103.86 182.62,102.28 182.87,102.04 183,101.91 183.64,101.91 183.89,102.15 188.65,102.15 189.18,101.62 189.18,84.8 188.66,84.29 188.66,66.63 188.39,66.37 188.39,65.9 188.71,65.59 190.44,65.59 191.64,66.79 194.67,66.79 195.43,66.03 199.75,66.03 201.53,64.25 202.87,64.25 208.59,58.53 208.59,57.8 210.42,55.97 v1(210.42,55.31) 210.42,54.71 212.19,52.94 212.19,52.55 214.97,49.77 220.35,49.77 220.61,49.52 v2(220.61,49.39)
CSSP_1: length 16.3
  TOP w0.254: PR703.1 59.89,29.29 59.89,30.69 v1(60.5,31.3) 61.69,32.5 61.69,33.21 62.08,33.59 v2(62.18,33.59)
  IN3 w0.254: v2(62.18,33.59) 62.18,34.22 61.22,35.17 61.22,39.23 60.75,39.7 60.37,39.7 v2(60.27,39.81)
  BOTTOM w0.254: PR702.2 58.75,40.38 59,40.12 59.95,40.12 v2(60.27,39.81)
CSSP_2: length 4.6
  TOP w0.203: PR703.2 59.63,27.67 59.25,27.3 58.84,27.3 v2(58.41,26.87) 58.24,26.7 PU700.2
  BOTTOM w0.254: PC707.2 58.37,26.82 v2(58.41,26.87) 58.48,26.94 PC708.1
CSSP_B+: length 181
  TOP w0.102: PR6100.2 89.28,28.47 v1(90.13,29.31)
  TOP w0.254: v2(89.25,25.45) 89.28,25.49 PR6100.2
  IN3 w0.254: v2(89.25,25.45) 89.43,25.28 100,25.28 101.51,26.79 107.63,26.79 112.33,31.49 164.32,31.49 165.3,32.47 165.3,40.41 168.03,43.14 168.03,52.98 169.62,54.57 169.62,60.41 170.38,61.17 170.38,73.81 171.84,75.27 171.84,87.87 172.92,88.95 172.92,91.49 172.75,91.66 172.75,91.71 171.88,92.59 171.88,96.14 173.53,97.8 177.79,97.8 182,102 182,103.06 182.48,103.53 183.1,103.53 v2(183.21,103.64)
  BOTTOM w0.254: v2(183.21,103.64) 183.29,103.55 186.5,103.55 189.31,106.36 189.31,109.6 190.25,110.54 190.25,112.3 190.06,112.49 190.06,112.5 RG62.1
CSSP_NVVDD: length 53.4
  IN1 w0.254: v2(185.7,119.76) 184.5,120.96 179.02,120.96 v2(178.57,120.51)
  BOTTOM w0.254: RG66.1 v2(185.7,119.76) ; PR6101.2 201.42,145.19 195.93,145.19 193.75,147.37 192.26,147.37 188.77,143.89 188.77,127.86 182.83,121.91 v1(180.49,121.91) 179.97,121.91 v2(178.57,120.51)
CSSP_NVVDDS: length 188.7
  IN6 w0.254: v2(220.04,49.14) 220.04,49.6 220.7,50.27 224.4,50.27 224.9,50.77 226.76,50.77 227.86,49.67 231.45,49.67 232.51,48.61 246.55,48.61 248.39,46.76 269.35,46.76 274.53,41.58 277.51,41.58 278.96,40.12 v2(279.03,40.12)
  BOTTOM w0.254: PR6401.2 274.75,35.1 275.52,35.87 279.47,35.87 279.92,36.31 279.92,37.33 278.96,38.29 278.96,40.05 v2(279.03,40.12) ; v2(220.04,49.14) 219.78,49.39 215.71,49.39 v1(215.68,49.37) 214.84,49.37 211.81,52.39 211.81,52.78 210.02,54.58 210.02,55.84 208.21,57.65 208.21,58.37 202.71,63.87 201.37,63.87 199.59,65.65 195.27,65.65 194.51,66.41 191.8,66.41 190.6,65.21 188.55,65.21 188.01,65.74 188.01,66.52 188.28,66.79 188.28,84.44 188.79,84.96 188.79,101.46 188.49,101.77 184.04,101.77 183.8,101.53 182.84,101.53 182.71,101.65 182.24,102.12 182.24,104.02 185.9,107.69 185.9,115.76 184.35,117.31 184.35,119.66 188.57,123.88 191.6,123.88 191.86,123.63 RG137.1
CSSUM_2PH: length 12.7
  TOP w0.203: v2(119.47,147) 119.47,146.84 119.69,146.61 119.69,144.74 120.5,143.93 120.65,143.93 120.68,143.9 PU500.30
  BOTTOM w0.254: PR549.1 121.57,150.23 120.29,150.23 v1(119.27,149.21) 118.86,148.8 118.86,147.47 119.33,147 v2(119.47,147) 119.44,146.97 119.44,146.33 PR548.2 119.49,146.31 120.34,145.46 PC526.2 120.35,145.16 PC528.2
CSSUM_4PH: length 10.5
  TOP w0.203: PU500.9 127.66,143.5 127.8,143.64 127.94,143.64 127.99,143.69 128.35,143.69 PC524.1
  TOP w0.254: v2(129.02,144.86) 129.02,144.78 128.86,144.63 PC524.1
  BOTTOM w0.102: PR572.2 130.31,149.82 v1(130.58,150.08)
  BOTTOM w0.254: v2(129.02,144.86) 128.86,144.71 PC524.1 129.7,144.2 PR547.2 130.32,144.77 PR546.2 130.33,145.23 PR550.2 130.31,146.44 PR551.2 PR572.2
CTL1: length 351.8
  TOP w0.102: v2(25.03,44.69) 24.86,44.86 UU1.6 ; UE6.7 333.67,43.33 334.21,42.79 334.21,38.43 333.5,37.72 330.98,37.72 328.6,35.33 v1(327.25,35.33) 327.13,35.33 323.57,31.77 323.57,28.79 v2(324.13,28.24)
  IN2 w0.102: v2(25.03,44.69) 25.09,44.69 26.46,46.06 27.45,46.06 27.86,46.47 30.2,46.47 31.83,48.1 32.88,48.1 33.02,48.24 33.45,48.68 33.45,48.68 33.88,49.1 33.88,50.23 34.3,50.65 36.78,50.65 37.12,50.31 45.86,50.31 46.57,49.6 57.73,49.6 58.16,49.16 63.6,49.16 64.22,49.78 65.8,49.78 67.15,48.43 83.5,48.43 83.76,48.69 91.62,48.69 92.43,49.51 94.72,49.51 95.34,48.89 96.7,48.89 97.34,48.25 99.63,48.25 100.12,48.75 123.6,48.75 124.1,48.25 144.58,48.25 145.18,48.85 154.02,48.85 154.62,48.25 172.3,48.25 172.4,48.14 173.84,48.14 174.3,47.68 175.17,47.68 175.75,47.1 175.75,42.76 176.12,42.39 177.53,42.39 178.96,43.82 180.91,43.82 181.62,44.53 184.05,44.53 187.56,48.04 190.89,48.04 191.58,47.35 192.09,47.35 193.62,48.87 194.04,48.87 195.21,50.04 200.72,50.04 203.69,47.07 207.38,47.07 208.49,48.19 214.5,48.19 215.91,46.78 224.33,46.78 224.75,46.36 237.68,46.36 239.96,44.07 266.11,44.07 275.99,34.19 279.38,34.19 283.83,29.75 290.42,29.75 294.76,25.4 301.88,25.4 305.22,25.4 306.19,26.38 307.02,26.38 309.17,28.53 310.04,28.53 311.73,30.22 320.96,30.22 322.94,28.24 v2(324.13,28.24)
CTL2: length 353.4
  TOP w0.102: UE6.8 333.61,43.83 334.44,43.01 334.44,38.52 334.44,38.33 333.27,37.16 v3(332.1,37.16) 330.75,37.16 328.44,34.85 326.97,34.85 324.14,32.02 v2(324.14,28.87) ; UU1.7 24.99,45.36 v2(25.03,45.33)
  IN2 w0.102: v2(324.14,28.87) 322.47,30.53 311.67,30.53 309.89,28.76 309.08,28.76 306.92,26.6 306.09,26.6 305.12,25.63 304.43,25.63 294.85,25.63 290.51,29.97 283.92,29.97 279.47,34.42 276.08,34.42 266.2,44.3 240.06,44.3 237.77,46.59 224.84,46.59 224.42,47.01 216,47.01 214.59,48.42 210.51,48.42 209.36,49.57 209.36,50.73 206.54,53.55 203.56,53.55 200.28,50.27 193.75,50.27 193.32,49.84 193.32,49.24 192.25,48.17 191.3,48.17 191.2,48.27 187.46,48.27 183.95,44.76 181.52,44.76 180.81,44.05 178.87,44.05 177.44,42.62 176.21,42.62 175.98,42.85 175.98,47.2 175.27,47.91 174.39,47.91 173.93,48.37 172.5,48.37 172.39,48.48 154.72,48.48 154.12,49.08 145.09,49.08 144.48,48.48 124.19,48.48 123.69,48.97 100.03,48.97 99.53,48.48 97.44,48.48 96.8,49.12 95.44,49.12 94.82,49.74 92.34,49.74 91.52,48.92 83.67,48.92 83.4,48.66 67.25,48.66 65.89,50.01 64.13,50.01 63.51,49.39 58.26,49.39 57.82,49.83 46.66,49.83 45.95,50.54 37.21,50.54 36.87,50.88 34.2,50.88 33.65,50.33 33.65,49.2 33.36,48.91 33.36,48.91 32.78,48.33 31.74,48.33 30.11,46.7 27.77,46.7 27.35,46.29 26.36,46.29 26.34,46.27 26.32,46.27 25.38,45.33 v2(25.03,45.33)
DAT_SMB: length 10.5
  TOP w0.114: v2(84.78,11.05) 84.98,11.25 84.98,11.91 84.54,12.35 82.44,12.35 81.91,12.87 81.91,13.3 PR21.1
  BOTTOM w0.114: v2(84.78,11.05) 84.98,11.25 84.98,11.64 84.78,11.84 84.57,11.84 84.32,12.1 PBATT1.6
DDR_A_ACT#: length 47.3
  IN6 w0.13: v2(144.52,93.19) 145.11,92.61 145.11,88.45 144.7,88.04 144.7,76.14 140.08,71.52 140.08,66.02 138.89,64.83 138.89,57.88 139.83,56.94 v2(139.83,56.92)
  BOTTOM w0.076: v2(144.52,93.19) 145.38,94.05 145.38,95.13 145.38,95.27 145.38,95.5 145.38,95.64 145.38,95.78 145.38,95.78 145.38,95.92 145.38,96.41 UC1.AU3
  BOTTOM w0.185: JDIMM1.114 139.94,54.43 139.2,55.17 139.2,56.27 139.83,56.9 v2(139.83,56.92)
DDR_A_ALERT#: length 53
  IN6 w0.13: v2(139.83,55.45) 139.12,54.74 137.44,54.74 136,56.18 136,65.45 137.6,67.05 137.6,72.55 142.14,77.08 142.14,90.46 144.05,92.38 144.05,94.52 144.39,94.86 v2(144.39,95.01)
  BOTTOM w0.076: v2(144.39,95.01) 144.79,95.01 144.88,95.11 145.05,95.27 145.05,95.5 145.05,95.64 145.05,95.65 145.05,96.57 145.05,97.22 145.05,97.38 UC1.AU5
  BOTTOM w0.185: JDIMM1.116 140.44,55.13 140.12,55.45 v2(139.83,55.45)
DDR_A_BA0: length 50.3
  IN6 w0.089: v2(152.29,94.22) 153.3,93.22 153.3,87.85 154.68,86.47 154.68,85.65
  IN6 w0.13: v2(150.91,55.47) 150.91,54.8 150.65,54.54 150.19,54.54 149.93,54.8 149.93,63.43 150.46,63.96 150.46,64.33 150.92,64.79 150.92,68.13 154.68,71.89 154.68,85.65
  BOTTOM w0.076: v2(152.29,94.22) 152.74,94.68 152.74,97.53 UC1.AH5
  BOTTOM w0.185: JDIMM1.150 150.94,55.44 v2(150.91,55.47)
DDR_A_BA1: length 48.4
  IN6 w0.089: 153.76,85.65 153.76,86.55 152.94,87.37 152.94,92.11 152.75,92.3 v2(152.31,92.3)
  IN6 w0.13: 153.76,85.65 153.76,72.27 149.01,67.51 149.01,67.29 149.16,67.13 149.85,67.13 150,66.98 150,66.67 149.85,66.52 149.16,66.52 149.01,66.36 149.01,66.05 149.16,65.9 149.85,65.9 150,65.74 150,65.43 149.85,65.28 149.16,65.28 149.01,65.12 149.01,60.45 v2(148.86,60.3)
  BOTTOM w0.076: v2(152.31,92.3) 152.31,92.15 152.65,91.81 152.65,91.45 152.74,91.37 153.11,91.37 153.2,91.46 153.2,92.05 153.12,92.13 152.87,92.13 152.79,92.2 152.79,92.36 152.87,92.43 153.12,92.43 153.2,92.51 153.2,92.66 153.12,92.74 152.87,92.74 152.79,92.81 152.79,92.96 152.87,93.04 153.12,93.04 153.2,93.12 UC1.AH1
  BOTTOM w0.185: JDIMM1.145 149.69,60.81 149.8,60.7 149.8,59.82 149.63,59.65 149.33,59.65 149.3,59.67 149.3,59.72 149.04,59.98 148.99,59.98 148.86,60.12 v2(148.86,60.3)
DDR_A_BG0: length 49.1
  IN6 w0.13: v2(137.62,57.23) 136.54,58.31 136.54,65.22 138.14,66.82 138.14,72.33 142.67,76.86 142.67,89.17 v2(143.07,89.56)
  BOTTOM w0.076: v2(143.07,89.56) 142.68,89.95 142.68,91.14 144.01,92.47 144.36,92.47 145.65,93.76 145.65,94.82 145.66,94.82 UC1.AU1
  BOTTOM w0.185: JDIMM1.115 140.19,60.57 139.18,59.56 139.18,57.89 138.52,57.23 v2(137.62,57.23)
DDR_A_BG1: length 46.2
  IN6 w0.13: v2(137.62,58.6) 137,59.22 137,65.03 138.6,66.63 138.6,72.13 143.22,76.76 143.22,87.12 143.46,87.36 143.46,90.44 v2(143.07,90.83)
  BOTTOM w0.076: UC1.AU2 145.66,95.78 145.93,95.5 145.93,95.5 145.93,93.81 143.07,90.94 v2(143.07,90.83)
  BOTTOM w0.185: v2(137.62,58.6) 138.17,58.6 138.69,59.12 138.69,59.76 139.67,60.74 139.68,60.74 139.69,60.75 JDIMM1.113
DDR_A_CKE0: length 49
  IN6 w0.13: v2(137.61,59.87) 137.8,59.87 137.97,60.03 137.97,61.2 137.84,61.33 137.72,61.33 137.56,61.49 137.56,61.77 137.72,61.93 137.81,61.93 137.97,62.08 137.97,62.39 137.81,62.55 137.72,62.55 137.56,62.7 137.56,64.02 137.97,64.42 137.97,65.21 139.16,66.4 139.16,71.9 143.78,76.52 143.78,88.92 143.93,89.07 144.32,89.07 144.47,89.22 144.47,89.53 144.32,89.68 143.93,89.68 143.78,89.83 143.78,90.17 144.15,90.54 v2(144.44,90.54)
  BOTTOM w0.076: UC1.AT1 146.39,91.88 146.32,91.81 145.88,91.81 145.8,91.73 145.8,91.58 145.88,91.5 146.32,91.5 146.39,91.43 146.39,91.27 146.32,91.2 145.88,91.2 145.8,91.12 145.8,90.97 145.88,90.89 146.32,90.89 146.39,90.82 146.39,90.62 146.31,90.54 145.69,90.54 145.61,90.46 145.61,89.54 145.54,89.46 145.38,89.46 145.31,89.54 145.31,90.46 145.23,90.54 v2(144.44,90.54)
  BOTTOM w0.185: v2(137.61,59.87) 137.99,59.87 138.1,59.97 138.1,60 138.69,60.6 JDIMM1.109
DDR_A_CKE1: length 47
  IN6 w0.13: v2(144.71,91.81) 144.83,91.69 144.83,88.75 144.24,88.15 144.24,76.33 139.62,71.71 139.62,66.21 138.43,65.02 138.43,55.96 138.3,55.83 v2(137.72,55.83)
  BOTTOM w0.076: v2(144.71,91.81) 146.1,93.2 146.1,95.2 146.1,95.74 UC1.AT2
  BOTTOM w0.185: JDIMM1.110 138.94,54.6 v2(137.72,55.83)
DDR_A_CLK0: length 54.1
  IN6 w0.081: 150.51,88.44 150.5,88.43 150.5,88.42 150.47,88.39 150.47,88.38 150.45,88.36 150.45,86.76 150.63,86.58 150.95,86.58 151.03,86.5 151.03,86.33 150.95,86.25 150.73,86.25 150.52,86.25 150.34,86.07 150.34,85.8 150.54,85.59 150.61,85.59 150.63,85.58 151.16,85.58 151.25,85.49 151.25,85.34 151.17,85.26 150.63,85.26 150.45,85.08 150.45,84.78 150.63,84.6 151.14,84.6 151.22,84.51 151.22,84.35 151.14,84.27 150.63,84.27 150.45,84.09 150.45,83.79 150.63,83.6 151.14,83.6 151.22,83.52 151.22,83.36 151.14,83.28 150.63,83.28 150.37,83.02 150.37,82.57 150.64,82.3 150.77,82.3 151.07,82.3 151.26,82.12 151.26,78.76 151.17,78.68 151.12,78.68 150.95,78.5 150.95,78.21 151.12,78.04 151.17,78.04 151.26,77.96 151.26,73.48 146.4,68.62 146.4,62.11 146.2,61.91 146.2,61.52 146.1,61.42 145.71,61.42 145.52,61.22 145.52,60.73 145.72,60.53 146.15,60.53 146.26,60.42 146.26,59.14 146.13,59.01 145.9,59.01 v2(145.62,59.29) ; 150.88,88.62 151,88.62 151.08,88.7
  IN6 w0.089: 150.51,88.44 150.7,88.62 150.88,88.62 ; v2(151.19,88.93) 151.19,88.82 151.08,88.7
  BOTTOM w0.076: v2(151.19,88.93) 151.66,88.46 152.64,88.46 154.02,89.84 154.02,92.77 154.21,92.97 154.21,95.12 154.28,95.18 154.28,95.67 154.18,95.76 154.06,95.76 154.05,95.76 153.89,95.76 153.82,95.69 153.82,95.5 UC1.AG1
  BOTTOM w0.107: JDIMM1.137 145.69,60.87
  BOTTOM w0.114: v2(145.62,59.29) 145.62,59.2 145.73,59.08 146.14,59.08 146.26,59.2 146.26,59.9 145.8,60.35 145.8,60.76 145.69,60.87
DDR_A_CLK1: length 51.8
  IN6 w0.081: v2(151.04,93.6) 151.3,93.34 151.55,93.34 151.77,93.12 151.77,91.49 151.42,91.15 151.42,90.1 151.73,89.79 151.73,87.95 151.74,87.94 151.74,87.5 151.73,87.49 151.73,86.65 152.08,86.3 152.08,73.01 147.25,68.18 147.25,61.29 147.1,61.13 147.1,58.73 147.11,58.72 147.11,58.47 146.93,58.3 146.62,58.3 146.53,58.22 146.53,58.06 146.62,57.98 146.93,57.98 147.11,57.8 147.11,57.51 146.93,57.34 146.62,57.34 146.53,57.25 146.53,57.09 146.62,57.01 146.93,57.01 147.11,56.84 147.11,56.54 146.93,56.37 146.62,56.37 146.53,56.29 146.53,56.13 146.62,56.05 146.93,56.05 147.11,55.87 147.11,55.48 146.93,55.31 146.46,55.31 146.27,55.5 145.99,55.5 145.88,55.6 145.74,55.6 v2(145.62,55.48)
  BOTTOM w0.076: UC1.AK2 151.42,96.03 151.17,95.79 151.12,95.79 150.96,95.63 150.96,95.5 150.96,95.08 151.66,94.39 151.66,93.56 151.48,93.37 151.27,93.37 v2(151.04,93.6)
  BOTTOM w0.107: JDIMM1.138 145.94,54.48
  BOTTOM w0.114: 145.94,54.48 146.06,54.59 146.06,55.14 146.19,55.27 146.19,55.51 146,55.7 145.84,55.7 v2(145.62,55.48)
DDR_A_CLK#0: length 54.2
  IN6 w0.081: v2(145.62,58.65) 145.82,58.85 146.2,58.85 146.42,59.07 146.42,60.49 146.2,60.71 145.77,60.71 145.67,60.8 145.67,61.16 145.78,61.26 146.16,61.26 146.38,61.48 146.38,61.86 146.55,62.04 146.55,68.56 151.41,73.42 151.41,78.02 151.24,78.19 151.19,78.19 151.11,78.28 151.11,78.44 151.19,78.52 151.24,78.52 151.41,78.69 151.41,82.18 151.14,82.46 150.7,82.46 150.53,82.63 150.53,82.96 150.69,83.12 151.21,83.12 151.38,83.3 151.38,83.59 151.21,83.76 150.69,83.76 150.61,83.85 150.61,84.02 150.69,84.11 151.21,84.11 151.38,84.29 151.38,84.58 151.21,84.75 150.69,84.75 150.61,84.84 150.61,85.01 150.69,85.1 151.23,85.1 151.41,85.28 151.41,85.57 151.23,85.75 150.63,85.75 150.51,85.87 150.51,86 150.59,86.08 150.66,86.08 151.02,86.08 151.2,86.26 151.2,86.57 151.02,86.75 150.7,86.75 150.62,86.83 150.62,88.31 150.63,88.32
  IN6 w0.089: 150.63,88.32 150.77,88.46 151.03,88.46 v2(151.19,88.3)
  BOTTOM w0.076: UC1.AG2 154,95.97 154.2,95.97 154.44,95.73 154.44,95.11 154.38,95.05 154.38,92.9 154.18,92.7 154.18,89.78 152.71,88.3 v2(151.19,88.3)
  BOTTOM w0.107: JDIMM1.139 146.19,60.9
  BOTTOM w0.114: v2(145.62,58.65) 145.8,58.84 146.24,58.84 146.5,59.1 146.5,60 146.05,60.45 146.05,60.75 146.19,60.9
DDR_A_CLK#1: length 51.8
  IN6 w0.081: v2(151.04,92.96) 151.25,93.17 151.48,93.17 151.6,93.05 151.6,91.56 151.25,91.22 151.25,90.03 151.56,89.72 151.56,87.88 151.57,87.87 151.57,87.57 151.56,87.56 151.56,86.58 151.91,86.23 151.91,85.58 151.92,85.56 151.92,73.07 147.1,68.25 147.1,61.35 146.94,61.2 146.94,58.66 146.95,58.66 146.95,58.54 146.87,58.46 146.55,58.46 146.38,58.28 146.38,57.99 146.55,57.82 146.87,57.82 146.95,57.74 146.95,57.57 146.87,57.49 146.55,57.49 146.38,57.32 146.38,57.03 146.55,56.85 146.87,56.85 146.95,56.77 146.95,56.61 146.87,56.53 146.55,56.53 146.38,56.35 146.38,56.06 146.55,55.89 146.87,55.89 146.95,55.81 146.95,55.54 146.87,55.46 146.53,55.46 146.32,55.67 146.06,55.67 v2(145.62,56.11)
  BOTTOM w0.076: UC1.AK1 151.42,95.49 151.29,95.62 151.19,95.62 151.13,95.56 151.13,95.2 151.13,95.15 151.83,94.45 151.83,93.49 151.55,93.21 151.29,93.21 v2(151.04,92.96)
  BOTTOM w0.107: JDIMM1.140 146.44,54.48
  BOTTOM w0.114: 146.44,54.48 146.31,54.62 146.31,55.04 146.44,55.17 146.44,55.61 146.11,55.95 145.78,55.95 v2(145.62,56.11)
DDR_A_CS#0: length 49.9
  IN6 w0.089: 156.15,85.65 156.15,86.16 153.85,88.47 153.85,95.6 155.91,97.66 v2(156.09,97.66)
  IN6 w0.13: 156.15,85.65 156.15,70.19 152.4,66.44 152.4,64.18 151.94,63.71 151.94,59.71 151.78,59.55 151.5,59.55 151.34,59.4 151.34,58.68 151.19,58.52 v2(150.91,58.52)
  BOTTOM w0.076: v2(156.09,97.66) 156.41,97.99 UC1.AD5
  BOTTOM w0.185: JDIMM1.149 150.69,60.7 150.4,60.4 150.4,59.58 150.39,59.57 150.39,59.56 149.49,58.66 149.49,58.35 149.93,57.9 150.29,57.9 v2(150.91,58.52)
DDR_A_CS#1: length 52.3
  IN6 w0.089: 157.07,85.65 157.07,86.46 155.58,87.94 155.1,87.94 154.2,88.84 154.2,92.78 154.36,92.93 v2(154.82,92.93)
  IN6 w0.13: 157.07,85.65 157.07,84.68 157.22,84.52 157.46,84.52 157.62,84.37 157.62,84.06 157.46,83.9 157.22,83.9 157.07,83.75 157.07,83.44 157.22,83.28 157.46,83.28 157.62,83.13 157.62,82.82 157.46,82.67 157.22,82.67 157.07,82.51 157.07,82.1 157.22,81.95 157.46,81.95 157.62,81.79 157.62,81.48 157.46,81.33 157.22,81.33 157.07,81.17 157.07,80.86 157.22,80.71 157.46,80.71 157.62,80.55 157.62,80.24 157.46,80.09 157.22,80.09 157.07,79.93 157.07,79.62 157.22,79.47 157.46,79.47 157.62,79.31 157.62,79 157.46,78.85 157.22,78.85 157.07,78.69 157.07,78.28 157.22,78.13 157.46,78.13 157.62,77.97 157.62,77.67 157.46,77.51 157.22,77.51 157.07,77.35 157.07,77.07 157.22,76.92 157.46,76.92 157.62,76.76 157.62,76.45 157.46,76.3 157.22,76.3 157.07,76.14 157.07,75.83 157.22,75.68 157.46,75.68 157.62,75.52 157.62,75.21 157.46,75.06 157.22,75.06 157.07,74.9 157.07,74.62 157.22,74.47 157.46,74.47 157.62,74.31 157.62,74 157.46,73.85 157.22,73.85 157.07,73.69 157.07,73.35 157.22,73.19 157.46,73.19 157.62,73.04 157.62,70.35 153.32,66.06 153.32,63.8 152.86,63.33 152.86,62.72 153.01,62.56 153.24,62.56 153.39,62.41 153.39,62.1 153.24,61.94 153.01,61.94 152.86,61.79 152.86,60.33 v2(152.89,60.3)
  BOTTOM w0.076: v2(154.82,92.93) 155.19,92.57 155.46,92.57 155.71,92.83 155.71,93.28 155.63,93.36 155.28,93.36 155.2,93.43 155.2,93.65 155.28,93.73 155.63,93.73 155.71,93.8 155.71,94.02 155.63,94.1 155.28,94.1 155.2,94.17 155.2,94.39 155.28,94.46 155.63,94.46 155.71,94.54 155.71,94.78 155.63,94.86 155.51,94.86 155.42,94.95 155.42,95.74 UC1.AE2
  BOTTOM w0.185: JDIMM1.157 152.69,60.49 v2(152.89,60.3)
DDR_A_D0: length 58.2
  IN6 w0.081: v2(112.68,57.07) 113.05,57.07 113.14,57.15 113.14,63.1 113.82,63.78 113.82,67.85 114.91,68.94 115.06,68.94 115.21,69.09 115.21,69.24 115.37,69.4 115.52,69.4 115.67,69.55 115.67,69.7 116.02,70.05 116.02,70.22 115.62,70.63 115.62,70.83 115.96,71.17 116.21,71.17 116.66,70.73 116.87,70.73 117.08,70.94 117.08,71.07 116.89,71.27 116.89,71.4 117.02,71.54 117.16,71.54 117.35,71.35 117.49,71.35 120.42,74.28 120.42,79.96 125.1,84.65 125.1,87.06 126.49,88.45 126.49,94.2 129.94,97.65 130.33,97.65 v2(130.46,97.52)
  BOTTOM w0.076: UC1.BR6 132.92,98.68 132.09,98.68 132.04,98.62 131.69,98.62 131.61,98.7 131.17,98.7 131.09,98.63 130.88,98.63 130.46,98.21 v2(130.46,97.52)
  BOTTOM w0.114: v2(112.68,57.07) 112.22,56.62 112.22,55.19 112.44,54.97 JDIMM1.4
DDR_A_D1: length 58.1
  IN6 w0.081: v2(131.84,98.98) 131.14,98.98 130.28,98.12 129.55,98.12 125.89,94.46 125.89,88.71 124.5,87.32 124.5,84.92 119.8,80.22 119.8,76.09 119.37,75.66 119.37,75.53 119.68,75.22 119.68,75.08 119.54,74.95 119.41,74.95 119.1,75.26 118.96,75.26 118.83,75.12 118.83,74.98 119.1,74.71 119.1,74.57 118.96,74.43 118.83,74.43 118.55,74.71 118.42,74.71 118.28,74.57 118.28,74.44 118.56,74.16 118.56,74.02 118.42,73.89 118.28,73.89 118.01,74.16 117.87,74.16 117.61,73.9 117.61,73.79 117.91,73.49 117.91,73.38 117.79,73.26 117.68,73.26 117.38,73.56 117.27,73.56 113.21,69.51 113.21,64.03 112.53,63.35 112.53,61.11 111.97,60.55 111.97,59.04 v2(112.68,58.34)
  BOTTOM w0.076: v2(131.84,98.98) UC1.BT6
  BOTTOM w0.114: JDIMM1.3 112.19,58.82 v2(112.68,58.34)
