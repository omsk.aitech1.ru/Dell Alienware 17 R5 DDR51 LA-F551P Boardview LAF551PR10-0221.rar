# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_N2: length 108.5
  IN3 w0.127: v2(210.56,21.57) 210.56,21.29 210.42,21.15 210.42,20.79 210.68,20.54 211.61,20.54 212.06,20.08 212.06,19.14 212.59,18.61 212.79,18.61 213.78,17.62 215.12,17.62 215.9,18.39 218.31,18.39 218.9,17.81 219.27,17.81 220.6,16.47 221.91,16.47 222.16,16.22 222.71,16.22 222.97,15.95 232.12,15.95 233.02,15.05 236.48,15.05 237.23,15.8 238.09,15.8 239.31,17.02 239.31,17.94 242.45,21.08 242.45,22.32 243.76,23.63 245.05,23.63 245.24,23.81 247.68,23.81 248.24,24.37 249.61,25.75 251.98,25.75 252.56,26.33 256.26,26.33 256.63,25.96 257.16,25.43 257.16,24.94 259.37,22.72 264.55,22.72 268.17,26.34 271,26.34 272.49,24.85 272.49,22.52 273.87,21.14 273.87,18.53 274.73,17.67 274.73,16.1 273.87,15.23 273.87,14.41 273.81,14.35 273.81,14.34 v2(273.71,14.24)
  IN6 w0.089: v2(210.56,21.57) 210.56,21.29 210.46,21.2 210.31,21.2 209.5,22.01 209.5,24.99 208.45,26.03 208.45,30.79 207.12,32.13 207.12,34.35 206.8,34.67 206.28,34.67 206.19,34.75 v2(206.19,34.96)
  BOTTOM w0.107: UH1.AE14 v2(206.19,34.96) ; JSSD2.53 272.69,13.06 272.87,12.88 273.47,12.88 273.88,13.3 273.88,14.06 v2(273.71,14.24)
CLK_PCIE_N3: length 155.5
  TOP w0.094: UT1.T19 v2(184.55,164.96)
  IN1 w0.089: v2(191.65,105.78) 191.08,105.78 190.95,105.91 190.95,111.71 193.83,114.59 193.83,121.12 194.76,122.06 194.76,125.4 195.6,126.23 195.6,126.51 196.03,126.95 196.03,128.26 196.39,128.61 199.3,131.53 199.3,144.61 200.73,146.04 200.73,147.82 199.4,149.15 198.89,149.15 192.22,155.82 192.22,159.17 192.22,159.8 191.5,160.52 191.5,160.52 190.79,161.23 190.79,161.23 190.55,161.47 189.21,161.47 188.17,162.51 188.17,162.55 186.34,164.38 186.3,164.38 186.12,164.57 185.03,164.57 184.82,164.77 184.74,164.77 v2(184.55,164.96)
  IN3 w0.127: v2(191.65,105.78) 191.49,105.62 191.18,105.62 190.8,105.24 190.8,104.67 189.59,103.46 189.59,88.66 188.26,87.33 188.26,67.39 189.86,65.79 189.86,64.42 190.19,64.08 190.19,62.06 189.94,61.8 189.94,60.4 189.94,60.4 189.94,57.54 191.46,56.03 191.46,55.76 197.4,49.81 197.4,47.56 197.74,47.22 197.74,46.22 197.57,46.05 197.2,45.68 197.2,43.69 197.75,43.14 198.6,43.14 198.69,43.23 199.56,43.23 199.82,42.98 199.82,41.43 200.99,40.25 203.79,40.25 204.32,39.71 204.32,37.94 204.83,37.43 205.54,37.43 205.83,37.7 205.85,37.96 205.85,38.27 205.86,38.29 v2(206.01,38.41)
  BOTTOM w0.107: UH1.AE6 v2(206.01,38.41)
CLK_PCIE_N4: length 215.6
  IN3 w0.127: v2(192.59,52.69) 192.42,52.52 192.41,52.52 192.21,52.32 192.03,52.32 191.91,52.45 191.91,53.13 190.45,54.59 190.45,56.14 189.3,57.28 189.3,60.13 189.3,60.13 189.3,62.07 189.55,62.32 189.55,63.82 189.22,64.15 189.22,64.76 187.62,66.36 187.62,87.59 188.95,88.93 188.95,104.29 191.72,107.05 192.99,107.05 193.11,107.18 195.97,107.18 196.32,107.53 197.69,107.53 197.93,107.29 201.04,107.29 206.83,113.09 206.83,117.6 208.1,118.86 208.1,119.62 207.4,120.32 207.4,121.73 208.25,122.58 208.7,122.58 209.9,123.79 210.45,123.79 211.08,124.42 211.08,124.83 211.59,125.34 211.59,128.64 212.06,129.11 212.06,131.61 209.95,133.73 209.95,144.35 209.56,144.74 209.56,148.26 209.42,148.4 209.42,148.41 209.23,148.6 209.23,150.11 210.33,151.22 210.73,151.22 211.21,151.7 211.21,153.91 211.91,154.61 216.16,154.61 217.05,155.5 223.15,155.5 223.78,156.14 233.37,156.14 234.3,157.06 236.48,157.06 237.62,155.92 241.67,155.92 242.08,156.33 261.9,156.33 267.98,162.41 267.98,164.39 268.57,164.98 268.57,166.82 268.77,167.02 268.77,167.03 v2(268.93,167.19) ; v2(204.84,42.32) 204.7,42.46 204.69,42.46 204.51,42.64 204.51,43.2 204.2,43.52 202.41,43.52 201.34,44.59 201.34,45.36 200.06,46.64 200.06,48.25 199.74,48.57 199.39,48.57 199.19,48.77 199.18,48.77 v2(199.02,48.94)
  BOTTOM w0.107: v2(192.59,52.69) 192.8,52.48 192.8,52.47 192.96,52.31 193.16,52.31 193.51,51.96 193.51,51.38 194.34,50.55 196.34,50.55 198.33,48.56 198.64,48.56 198.84,48.75 198.84,48.76 v2(199.02,48.94) ; UH1.AC2 204.55,40.5 204.61,40.57 204.61,40.89 204.54,40.96 204.54,42.02 v2(204.84,42.32) ; v2(268.93,167.19) 268.55,167.57 268.55,167.77 268.69,167.91 270.4,167.91 271.1,167.21 271.1,166.49 271,166.39 UL1.32
CLK_PCIE_N5: length 127.4
  IN6 w0.089: v2(312.68,37.52) 312.26,37.93 312.02,37.93 311.92,37.84 311.92,36.12 310.78,34.98 288.66,34.98 287.22,33.54 286.18,33.54 285.93,33.79 279.65,33.79 279.08,34.37 273.48,34.37 264.99,42.85 243,42.85 242.24,42.09 239.78,42.09 238.98,41.29 235.91,41.29 234.99,42.21 232.95,42.21 231.61,43.55 228.77,43.55 228.24,44.07 225.22,44.07 224.01,45.29 215.73,45.29 215.65,45.2 210.8,45.2 210.53,45.48 203.67,45.48 203.44,45.24 203.44,44.92 203.53,44.83 v2(204.03,44.85)
  BOTTOM w0.107: UH1.AB2 203.86,40.6 203.86,40.96 203.92,41.03 203.92,42.51 204.15,42.73 204.15,43.57 204.05,43.66 204.05,44.49 204.04,44.5 204.04,44.59 204.03,44.6 v2(204.03,44.85) ; v2(312.68,37.52) 312.3,37.9 312.13,37.9 312.03,37.79 312.03,36.26 312.18,36.11 312.19,36.11 312.32,35.97 JWLAN.41
CLK_PCIE_N7: length 63.9
  IN6 w0.089: v2(202.1,38.06) 202.16,38.06 202.45,38.35 202.45,38.47 202.26,38.66 202.26,39.4 203.05,40.2 207.12,40.2 207.61,40.69 208.99,40.69 209.52,40.16 213.62,40.16 214.53,41.08 216.54,41.08 216.76,40.85 217.06,40.85 217.29,41.08 222.11,41.08 224.26,38.93 228.53,38.93 230.3,37.16 230.3,35.2 231.47,34.03 231.47,27.9 231.78,27.59 233.49,27.59 234.06,28.15 235.18,28.15 237.22,26.11 237.22,24.27 v2(237.78,23.71)
  BOTTOM w0.107: UH1.W7 v2(202.1,38.06) ; v2(237.78,23.71) 237.78,23.43 237.94,23.27 237.94,17.22 238.46,16.7 240.34,16.7 241.02,16.02 JSSD3.53
CLK_PCIE_P1: length 157.1
  IN1 w0.089: v2(324.07,36.05) 323.66,36.47 323.66,36.58 323.38,36.86 322.67,36.86 321.15,35.34 294.31,35.34 293.85,34.88 292.12,34.88 289.09,31.84 286.5,31.84 286.23,31.58 279.57,31.58 279.34,31.81 275.44,31.81 274.76,31.13 272.62,31.13 272.43,31.32 248.87,31.32 245.25,27.7 243.25,27.7 239.5,23.95 239.5,23.05 237.8,21.36 237.66,21.36 237.1,20.79 235.77,20.79 234.59,19.61 229.11,19.61 228.94,19.78 226.75,19.78 226.16,20.37 225.49,20.37 225.14,20.73 224.16,20.73 223.22,21.67 221.48,21.67 221.07,21.26 218.62,21.26 217.85,20.49 217.85,20.01 217.67,19.83 217.26,19.83 216.87,20.21 216.87,20.62 215.78,21.71 215.78,22.28 213.58,24.48 212.81,24.48 212.79,24.49 212.36,24.49 212.34,24.48 212.23,24.48 211.63,25.07 210,25.07 209.84,25.23 209.31,25.23 208.93,25.62 208.29,25.62 207.91,26 201.76,26 201.18,26.58 201.18,29.29 200.54,29.93 199.73,29.93 199.63,30.02 199.63,30.18 v2(200.05,30.6)
  IN6 w0.089: v2(206.78,36.94) 206.99,36.94 207.2,37.15 207.2,37.37 207.11,37.46 206.7,37.46 205.62,36.38 205.62,35.89 201.75,32.01 201.75,31.99 201.19,31.43 199.85,31.43 199.63,31.21 199.63,30.95 199.99,30.6 v2(200.05,30.6)
  BOTTOM w0.107: v2(324.07,36.05) 324.07,36.05 323.9,36.22 323.9,36.6 323.99,36.69 324.79,36.69 325.07,36.41 JSSD1.55 ; UH1.AH10 206.78,36.88 v2(206.78,36.94)
CLK_PCIE_P2: length 108.7
  IN3 w0.127: v2(210.94,21.17) 210.75,21.17 210.64,21.06 210.64,20.88 210.77,20.76 211.7,20.76 212.28,20.18 212.28,19.23 212.68,18.82 212.88,18.82 213.87,17.83 215.03,17.83 215.81,18.61 218.4,18.61 218.99,18.02 219.36,18.02 220.69,16.69 222,16.69 222.25,16.44 222.8,16.44 223.06,16.17 232.21,16.17 233.12,15.27 236.39,15.27 237.14,16.02 238,16.02 239.09,17.11 239.09,18.03 242.23,21.17 242.23,22.41 243.66,23.84 244.96,23.84 245.15,24.03 247.59,24.03 248.15,24.59 249.52,25.97 251.89,25.97 252.47,26.55 256.35,26.55 256.85,26.05 257.37,25.52 257.37,25.03 259.46,22.94 264.46,22.94 268.08,26.56 271.09,26.56 272.71,24.94 272.71,22.61 274.09,21.23 274.09,18.62 274.95,17.76 274.95,16.01 274.09,15.14 274.09,14.44 v2(274.29,14.24)
  IN6 w0.089: v2(210.94,21.17) 210.68,21.17 210.53,21.03 210.24,21.03 209.33,21.94 209.33,24.92 208.29,25.96 208.29,30.72 206.96,32.06 206.96,34.28 206.74,34.5 206.28,34.5 206.19,34.41 v2(206.19,34.2)
  BOTTOM w0.107: JSSD2.55 272.7,12.56 272.83,12.68 273.55,12.68 274.09,13.21 274.09,14.04 v2(274.29,14.24) ; UH1.AE15 v2(206.19,34.2)
CLK_PCIE_P3: length 155.5
  TOP w0.089: UT1.V19 184.23,163.98
  TOP w0.094: 184.23,163.98 v2(184.55,164.31)
  IN1 w0.089: v2(191.65,105.2) 191.65,105.22 191.25,105.62 191.01,105.62 190.79,105.84 190.79,111.78 193.66,114.66 193.66,121.19 194.6,122.13 194.6,125.47 195.43,126.3 195.43,126.58 195.87,127.01 195.87,128.33 196.32,128.78 199.13,131.59 199.13,144.68 200.57,146.11 200.57,147.75 199.33,148.99 198.82,148.99 192.06,155.75 192.06,159.23 192.06,159.24 192.06,159.73 191.33,160.45 191.33,160.46 190.72,161.06 190.48,161.31 189.15,161.31 188.01,162.44 188.01,162.48 186.27,164.22 186.24,164.22 186.05,164.4 184.96,164.4 184.81,164.56 184.64,164.56 184.55,164.47 v2(184.55,164.31)
  IN3 w0.127: v2(205.24,38.47) 205.54,38.45 205.63,38.35 205.63,37.96 205.62,37.8 205.45,37.65 204.92,37.65 204.54,38.03 204.54,39.81 203.88,40.47 201.09,40.47 200.03,41.52 200.03,43.07 199.65,43.45 198.6,43.45 198.51,43.36 197.84,43.36 197.42,43.78 197.42,45.59 197.79,45.96 197.96,46.13 197.96,47.31 197.62,47.65 197.62,49.9 191.67,55.85 191.67,56.12 190.16,57.64 190.16,60.49 190.16,61.71 190.41,61.97 190.41,64.18 190.08,64.51 190.08,65.88 188.48,67.48 188.48,87.24 189.81,88.57 189.81,103.37 191.02,104.57 191.02,105.15 191.27,105.4 191.44,105.4 191.48,105.36 191.56,105.36 191.65,105.27 v2(191.65,105.2)
  BOTTOM w0.107: UH1.AE7 205.57,37.94 205.39,37.94 205.14,38.19 205.14,38.37 v2(205.24,38.47)
CLK_PCIE_P4: length 215.6
  IN3 w0.127: v2(268.35,167.19) 268.35,165.07 267.76,164.48 267.76,162.5 261.81,156.55 241.99,156.55 241.58,156.14 237.71,156.14 236.57,157.28 234.21,157.28 233.28,156.36 223.69,156.36 223.06,155.72 216.96,155.72 216.07,154.83 211.82,154.83 210.99,154.01 210.99,151.79 210.64,151.44 210.24,151.44 209.01,150.2 209.01,148.69 209.01,148.51 209.2,148.32 209.2,148.31 209.34,148.17 209.34,144.65 209.73,144.26 209.73,133.64 211.84,131.52 211.84,129.2 211.37,128.73 211.37,125.43 210.86,124.92 210.86,124.51 210.36,124.01 209.81,124.01 208.61,122.8 208.16,122.8 207.18,121.82 207.18,120.23 207.88,119.53 207.88,118.95 206.61,117.69 206.61,113.18 200.95,107.51 198.02,107.51 197.78,107.75 196.23,107.75 195.88,107.4 193.02,107.4 192.89,107.27 191.81,107.27 191.62,107.27 188.74,104.38 188.74,89.02 187.41,87.68 187.41,66.27 189,64.67 189,64.06 189.34,63.73 189.34,62.41 189.08,62.16 189.08,60.04 189.08,57.19 190.23,56.05 190.23,54.5 191.69,53.04 191.69,52.36 191.94,52.1 v2(192.59,52.1) ; v2(204.29,42.32) 204.29,43.11 204.11,43.3 202.32,43.3 201.12,44.5 201.12,45.27 199.84,46.55 199.84,48.16 199.65,48.35 v2(199.02,48.35)
  BOTTOM w0.107: v2(204.29,42.32) 204.34,42.27 204.34,40.88 204.3,40.84 204.3,40.03 UH1.AC3 ; v2(199.02,48.35) 198.25,48.35 196.25,50.35 194.26,50.35 193.3,51.3 193.3,51.88 193.08,52.1 v2(192.59,52.1) ; UL1.33 271.4,166.37 271.3,166.47 271.3,167.29 270.48,168.11 268.61,168.11 268.35,167.85 v2(268.35,167.19)
CLK_PCIE_P5: length 127.9
  IN6 w0.089: v2(312.68,38.1) 311.95,38.1 311.76,37.91 311.76,36.19 310.71,35.14 288.59,35.14 287.16,33.71 286.25,33.71 286,33.96 279.72,33.96 279.15,34.53 273.55,34.53 265.06,43.02 242.93,43.02 242.17,42.26 239.72,42.26 238.92,41.46 235.97,41.46 235.06,42.37 233.01,42.37 231.67,43.71 228.83,43.71 228.31,44.24 225.29,44.24 224.08,45.45 215.66,45.45 215.58,45.37 210.87,45.37 210.59,45.64 203.6,45.64 203.27,45.31 203.27,44.85 203.46,44.66 203.63,44.5 v2(203.63,44.42)
  BOTTOM w0.107: UH1.AB3 203.88,40.17 203.64,40.41 203.64,41.03 203.72,41.11 203.72,42.59 203.94,42.81 203.94,43.48 203.85,43.58 203.85,44.31 203.74,44.42 v2(203.63,44.42) ; JWLAN.39 311.82,37.88 312.05,38.1 312.68,38.1 v2(312.68,38.1)
CLK_PCIE_P7: length 63.9
  IN6 w0.089: v2(237.37,23.29) 237.37,23.63 237.38,23.65 237.38,23.87 237.05,24.2 237.05,26.05 235.11,27.99 234.13,27.99 233.56,27.42 231.71,27.42 231.3,27.83 231.3,33.96 230.13,35.13 230.13,37.09 228.46,38.76 224.19,38.76 222.04,40.91 217.36,40.91 217.13,40.68 216.69,40.68 216.47,40.91 214.6,40.91 213.69,40 209.45,40 208.92,40.53 207.68,40.53 207.18,40.03 203.12,40.03 202.42,39.34 202.42,38.73 202.73,38.42 v2(203.16,38.42)
  BOTTOM w0.107: v2(203.16,38.42) 203.15,38.42 203.15,38.41 202.87,38.41 UH1.W6 ; JSSD3.55 240.53,15.4 240.82,15.7 240.82,15.94 240.26,16.5 238.38,16.5 237.74,17.14 237.74,23.19 237.63,23.29 v2(237.37,23.29)
CLK_PEG_N0: length 145.9
  IN3 w0.127: v2(207.99,38.29) 207.43,38.01 207.16,38.01 206.89,38.27 206.89,38.47 205.68,39.68 205.68,39.84 203.93,41.58 201.05,41.58 200.61,42.03 200.61,43.11 199.53,44.19 198.5,44.19 198.24,44.44 198.24,45.21 198.81,45.78 198.81,47.67 198.47,48.01 198.47,50.25 192.53,56.2 192.53,57.78 191.01,59.3 191.01,60.84 191.01,60.84 191.01,61.36 192.06,62.41 192.06,63.73 190.93,64.86 190.93,66.43 189.9,67.46 189.9,68.48 189.92,68.5 189.92,69.53 189.33,70.12 189.33,86.89 190.66,88.22 190.66,103.01 191.87,104.22 191.87,104.22 191.99,104.34 192.01,104.34 192.51,104.84 192.51,105.46 192.86,105.82 196.64,105.82 197.21,105.25 201.39,105.25 202.35,106.2 206.48,106.2 209.75,109.46 209.75,114.93 211.81,116.98 211.81,121.28 211.62,121.47 211.37,121.47 v2(211.15,121.69)
  BOTTOM w0.089: UG9.BM27 236.99,118.43 236.99,121.65 236.99,121.81 235.74,123.06 235.58,123.06 226.8,123.06 226.77,123.09 226.16,123.09 226.14,123.06 223.71,123.06 221.97,121.31 218.94,121.31 218.63,121.01 216.47,121.01 215.85,120.39 213.96,120.39 212.66,121.69 v2(211.15,121.69)
  BOTTOM w0.107: v2(207.99,38.29) 207.99,38.46 UH1.AJ6
CLK_PEG_N6: length 199.3
  IN1 w0.089: v2(197.23,32.19) 197.44,32.4 197.44,32.54 196.76,33.22 196.76,33.96 196.82,34.02 196.82,34.57 193.79,37.61 192.12,37.61 191.68,38.04 190.48,38.04 189.3,39.22 189.3,39.44 189.3,41.31 186.84,43.77 186.84,56.4 186.26,56.98 186.26,60.78 186.8,61.33 186.96,61.33 187.26,61.62 187.26,62 185.17,64.09 185.17,64.21 184.24,65.14 184.24,67.13 184.24,67.75 183.29,68.69 183.29,68.83 183.3,68.83 183.3,69.32 183.3,70.37 183.42,70.5 183.42,72.34 183.74,72.66 183.74,74.22 183.65,74.31 183.17,74.31 v2(182.94,74.08)
  IN3 w0.127: v2(182.94,74.08) 182.74,74.28 182.5,74.28 182.11,74.66 182.11,75.45 181.85,75.72 181.02,75.72 180.48,76.26 180.48,86.93 178.19,89.22 178.19,93.77 180.96,96.54 182.67,96.54 183.46,97.33 183.46,101.59 183.8,101.93 183.8,105.76 185.63,107.59 185.63,108.49 186.47,109.34 186.47,110.19 188.32,112.04 188.32,112.68 188.71,113.07 188.71,113.34 192.88,117.52 192.88,119.64 194.11,120.87 194.38,120.87 196.94,123.43 199.05,123.43 200.58,124.96 200.58,128.35 201.28,129.05 202.09,129.05 202.42,128.72 203.52,128.72 204.42,129.62 204.42,130.43 204.18,130.67 204.18,135.77 204.99,136.58 204.99,142.39 203.42,143.96 203.42,144.27 198.4,149.28 192.68,149.28 188.59,153.37 188.4,153.37 188.24,153.53 181.88,153.53 181.65,153.76 176.58,153.76 176.1,154.24 173.53,154.24 173.28,154.49 171.52,154.49 170.1,155.9 170.1,156.73 v2(169.89,156.94)
  IN6 w0.089: v2(202.75,42.28) 202.75,41.32 201.2,39.77 201.2,38.15 201.77,37.58 201.77,35.75 201.32,35.3 200.92,35.3 200.63,35.59 198.82,35.59 198.47,35.24 198.47,33.4 198,32.92 197.63,32.92 197.37,32.67 197.37,32.33 v2(197.23,32.19)
  BOTTOM w0.107: UH1.W4 202.79,39.53 202.45,39.88 202.45,40.2 202.62,40.38 202.62,41.22 202.75,41.35 v2(202.75,42.28) ; v2(169.89,156.94) 170.13,156.71 170.13,156.65 169.89,156.41 UM4.3
CLK_PEG_P0: length 145.7
  IN3 w0.127: v2(211.15,121.11) 211.28,121.25 211.53,121.25 211.59,121.18 211.59,117.07 209.53,115.02 209.53,109.56 206.39,106.42 202.26,106.42 201.3,105.46 197.3,105.46 196.73,106.04 192.77,106.04 192.29,105.56 192.29,104.93 191.91,104.56 191.9,104.56 191.65,104.31 190.44,103.1 190.44,88.31 189.11,86.98 189.11,70.03 189.12,70.03 189.7,69.44 189.7,68.59 189.68,68.57 189.68,67.37 190.71,66.34 190.71,64.77 191.84,63.64 191.84,62.5 190.79,61.45 190.79,60.75 190.79,59.21 192.31,57.69 192.31,56.11 198.26,50.16 198.26,47.92 198.6,47.58 198.6,45.87 198.03,45.3 198.03,44.35 198.41,43.97 199.44,43.97 200.39,43.02 200.39,41.94 200.96,41.36 203.84,41.36 205.46,39.75 205.46,39.59 206.67,38.38 206.67,38.18 207.07,37.79 207.6,37.79 v2(207.74,37.53)
  BOTTOM w0.089: UG9.BM26 236.63,118.25 236.79,118.41 236.79,121.73 235.66,122.86 v4(226.48,122.86) 223.79,122.86 222.05,121.12 219.02,121.12 218.71,120.81 216.55,120.81 215.94,120.2 213.88,120.2 212.58,121.5 211.46,121.5 211.15,121.18 v2(211.15,121.11)
  BOTTOM w0.107: UH1.AJ7 207.74,37.79 v2(207.74,37.53)
CLK_PEG_P6: length 198.9
  IN1 w0.089: v2(197.82,32.19) 197.61,32.4 197.61,32.61 196.92,33.29 196.92,33.89 196.99,33.95 196.99,34.64 193.85,37.77 192.19,37.77 191.75,38.21 190.55,38.21 189.47,39.29 189.47,39.51 189.47,39.51 189.47,40.14 189.47,41.37 187,43.84 187,56.47 186.42,57.05 186.42,60.71 186.87,61.16 187.03,61.16 187.42,61.55 187.42,62.07 185.34,64.16 185.34,64.28 184.41,65.21 184.41,67.19 184.41,67.81 183.46,68.76 183.46,69.25 183.46,70.31 183.59,70.43 183.59,72.27 183.9,72.59 183.9,74.29 183.72,74.48 183.13,74.48 v2(182.94,74.67)
  IN3 w0.127: v2(182.94,74.67) 182.77,74.5 182.59,74.5 182.33,74.76 182.33,75.54 181.94,75.94 181.11,75.94 180.69,76.35 180.69,87.02 178.41,89.31 178.41,93.68 181.05,96.32 182.76,96.32 183.68,97.24 183.68,101.5 184.02,101.84 184.02,105.67 185.85,107.49 185.85,108.4 186.69,109.25 186.69,110.1 188.54,111.95 188.54,112.58 188.93,112.97 188.93,113.25 193.1,117.43 193.1,119.55 194.2,120.65 194.47,120.65 197.04,123.22 199.14,123.22 200.8,124.87 200.8,128.26 201.37,128.83 202,128.83 202.33,128.5 203.61,128.5 204.63,129.53 204.63,130.52 204.4,130.76 204.4,135.68 205.21,136.49 205.21,142.48 203.64,144.05 203.64,144.36 198.49,149.5 192.77,149.5 188.68,153.58 188.5,153.58 188.33,153.75 181.97,153.75 181.74,153.98 176.67,153.98 176.19,154.45 173.62,154.45 173.37,154.7 171.61,154.7 170.32,156 170.32,156.73 v2(170.54,156.94)
  IN6 w0.089: v2(203.34,42.28) 203.3,42.28 202.92,41.9 202.92,41.25 201.37,39.7 201.37,38.22 201.94,37.65 201.94,35.68 201.39,35.13 200.85,35.13 200.56,35.42 198.89,35.42 198.64,35.17 198.64,33.33 198.07,32.76 197.7,32.76 197.54,32.6 197.54,32.47 v2(197.82,32.19)
  BOTTOM w0.107: UH1.W3 202.83,40.14 202.83,41.14 202.95,41.27 202.95,41.9 v2(203.34,42.28) ; v2(170.54,156.94) 170.33,156.74 170.33,156.65 170.54,156.44 UM4.2
CLK_SMB: length 10.5
  TOP w0.114: v2(85.36,11.05) 85.23,11.18 85.23,12.01 84.64,12.59 v4(83.73,12.59) 82.54,12.59 82.15,12.97 82.15,13.3 PR19.1
  BOTTOM w0.114: PBATT1.5 85.82,12.04 85.71,11.93 85.42,11.93 85.23,11.74 85.23,11.18 v2(85.36,11.05)
CLKDET#: length 3.2
  BOTTOM w0.089: 218,25.02 216.41,25.02 215.86,24.47 UH1.BF35
  BOTTOM w0.102: 218,25.02 218.21,24.82 RH558.1
CLKREQ_PCIE#1: length 143.4
  TOP w0.089: v2(218.32,25.72) 218.32,25.75 218.26,25.81 218.26,27.1 218.16,27.2 218.16,27.71 v2(218.96,28.5)
  IN1 w0.102: v2(218.96,28.5) 219.02,28.5 219.59,27.93 221.3,27.93 223.62,25.61 223.62,24.99 226.25,22.36 228.28,22.36 228.48,22.16 229.75,22.16 230.44,22.85 233.73,22.85 234.15,22.43 234.53,22.43 235.79,22.43 236.13,22.63 244.63,31.13 246.34,31.13 248.08,32.87 250.08,32.87 250.62,33.42 261.81,33.42 263.31,34.92 271.95,34.92 273.88,32.99 274.56,32.99 275.75,34.18 279.41,34.18 279.85,33.73 287.18,33.73 290.33,36.88 290.33,37.48 291.77,38.92 309.06,38.92 310.27,40.12 312.62,40.12 312.94,39.81 317.83,39.81 319.29,38.34 v2(322.1,38.34)
  BOTTOM w0.089: v2(218.96,28.5) 219.02,28.5 219.18,28.34 219.18,27.65 ; v2(218.32,25.72) 217.23,25.72 216.98,25.97 216.48,25.97 216.17,26.28 215.64,26.28 215.4,26.51 UH1.BE31
  BOTTOM w0.102: JSSD1.52 332.27,37.16 331.97,36.86 331.97,33.98 331.39,33.39 328.57,33.39 327.43,34.53 323.84,34.53 323.08,35.29 323.08,37.6 v1(322.59,38.09) 322.59,38.12 322.37,38.34 v2(322.1,38.34) ; 219.18,27.65 219.28,27.55 RP3.6
CLKREQ_PCIE#2: length 101.6
  TOP w0.089: v1(218.64,29.26) 218.83,29.08 219.18,29.08
  TOP w0.102: v2(219.28,29.08) 219.18,29.08
  IN1 w0.102: v2(219.28,29.08) 219.32,29.08 220.09,28.31 221.24,28.31 223.85,25.7 223.85,25.08 226.35,22.58 228.38,22.58 228.57,22.39 229.66,22.39 230.36,23.09 233.82,23.09 234.25,22.66 234.44,22.66 235.57,22.66 235.99,22.83 244.58,31.41 246.29,31.41 247.99,33.1 249.99,33.1 250.53,33.65 261.52,33.65 263.02,35.14 272.3,35.14 v2(273.95,33.5)
  IN2 w0.089: v2(209.25,26.85) 209.95,27.55 210.97,27.55 212.1,28.67 214.94,28.67 215.31,28.31 217.24,28.31 217.29,28.36 218.11,28.36 218.74,28.99 218.75,28.99 218.83,29.08 219.18,29.08
  IN2 w0.102: 219.18,29.08 v2(219.28,29.08)
  BOTTOM w0.102: RP3.7 219.79,28.05 219.4,28.44 219.4,28.95 v2(219.28,29.08) ; v2(273.95,33.5) 273.95,31.99 274.24,31.7 274.24,29.19 274.88,28.55 274.88,26.37 275.87,25.38 275.87,20.79 277.42,19.24 277.42,14.57 278.68,13.31 JSSD2.52
  BOTTOM w0.122: UH1.AR32 209.81,26.56 209.54,26.56 v2(209.25,26.85)
CLKREQ_PCIE#3: length 185
  IN1 w0.089: 198.25,45.7 198.26,45.68 198.26,44.47 198.55,44.19 198.89,43.84 198.89,42.66 201.11,40.44 203.91,40.44 204.61,39.74 204.61,38.41 205.11,37.9 208.03,37.9 208.42,37.52 208.42,35.93 208.87,35.48 210.45,35.48 211.27,34.66 211.57,34.22 212.09,33.7 212.11,33.7 212.6,33.2 213.13,33.2 213.92,32.41 213.92,32.27 215.41,30.78 215.41,28.01 215.17,27.76 213.34,27.76 213.19,27.61 213.19,27.04 v2(213.97,26.27)
  IN1 w0.102: 198.25,45.7 197.98,45.96 197.98,47.8 197.98,47.81 197.98,48.86 197.17,49.67 197.1,49.67 196.89,49.67 195.21,51.35 195.21,52.38 192.97,54.62 192.97,59.06 192.66,59.36 v2(192.63,59.36)
  IN2 w0.102: v2(172.6,153.31) 172.6,152.97 173.38,152.2 183.52,152.2 187.02,148.7 187.02,145.37 188.28,144.11 188.28,129.99 180.64,122.35 180.64,107.96 178.5,105.82 178.5,95.61 176.85,93.96 176.85,82.97 175.69,81.81 175.69,71.79 183.56,63.91 183.56,59.16 185.15,57.57 187.11,57.57 187.99,58.45 187.99,61.23 188.17,61.4 188.77,61.4 190.76,59.42 192.57,59.42 v2(192.63,59.36)
  BOTTOM w0.102: v2(172.6,153.31) 172.6,153.28 172.86,153.03 173.74,153.03 174.06,152.71 175.71,152.71 175.9,152.9 175.9,153.41 176.32,153.83 RT24.1 RT2.2
  BOTTOM w0.122: UH1.BB30 v2(213.97,26.27)
CLKREQ_PCIE#3_R: length 8.6
  TOP w0.089: UT1.AC5 177.76,161.29 176.91,160.44
  TOP w0.102: v2(175.81,157.82) 176.42,158.43 176.42,159.98 176.89,160.44 176.91,160.44
  BOTTOM w0.102: v2(175.81,157.82) 176.41,157.22 v1(176.41,157.13) ; 177.2,155.63 177.54,155.29 RT20.2 177.53,155.06 RT2.1
  BOTTOM w0.107: v1(176.41,157.13) 177.2,156.34 177.2,155.63
CLKREQ_PCIE#4: length 253.7
  TOP w0.102: v2(219.78,44.06) v1(219.78,43.51)
  IN1 w0.089: 219.18,35.65 219.1,35.72 219.1,43.38 219.18,43.46
  IN1 w0.102: v2(219.91,29.07) 220.18,29.34 220.18,33.76 219.59,34.34 219.59,35.23 219.18,35.65 ; 219.18,43.46 v2(219.78,44.06)
  IN2 w0.102: v2(192.22,64.51) 190.72,66.01 190.72,68.29 190.42,68.6 188.51,68.6 184.32,72.8 182.2,72.8 180.31,74.69 180.31,80.55 186.19,86.43 186.19,93.94 185.11,95.02 185.11,103.45 186.2,104.55 186.2,111.99 188.69,114.48 188.69,122.77 198.27,132.34 198.27,134.94 199.41,136.08 199.41,141.42 207.21,149.22 v2(210.32,149.22)
  IN3 w0.089: 217.94,43.88 217.94,43.46 217.52,43.04 213.88,43.04 213.04,43.88
  IN3 w0.102: v2(219.78,44.06) 219.38,44.46 218.39,44.46 217.94,44.02 217.94,43.88 ; v2(210.32,149.22) 211.18,149.22 212.82,150.85 212.82,152.1 212.99,152.27 262.65,152.27 267.65,157.27 267.65,158.72 269.42,160.49 272.87,160.49 274.33,161.95 274.33,162.3 v2(275.95,163.92) ; 213.04,43.88 212.95,43.97 212.95,43.97 212.45,44.48 212.44,44.48 210.32,46.6 210.32,47.92 208.87,49.37 208.87,52.81 206.72,54.96 203.27,54.96 202.36,55.87 202.36,61.35 200.92,62.79 200.92,64.06 198.76,66.22 195.91,66.22 194.45,64.76 193.37,64.76 193.11,64.51 v2(192.22,64.51)
  IN6 w0.089: v2(213,26.44) 213,26.47 213.31,26.79 216.92,26.79 217.37,27.23 217.85,27.23 218.36,27.74 219.08,27.74 219.18,27.83
  IN6 w0.102: 219.18,27.83 219.91,28.57 v2(219.91,29.07)
  BOTTOM w0.102: UL1.4 275.84,164.04 v2(275.95,163.92) ; v2(219.91,29.07) 219.64,28.81 219.64,28.65 219.74,28.55 RP3.8
  BOTTOM w0.122: v2(213,26.44) 213,26.47 213.23,26.7 UH1.BA30
CLKREQ_PCIE#5: length 127.1
  TOP w0.089: 219.18,26.37 219.13,26.42 219.13,26.51 219.13,27.4 219.18,27.45
  TOP w0.102: 219.18,27.45 219.78,28.05 RP5.6 ; v2(220.64,26.08) 220.5,25.94 v1(220.02,25.94) 219.63,25.94 219.29,26.27 219.28,26.27 219.18,26.37
  IN1 w0.102: v2(313.7,37.52) 313.7,38.66 312.56,39.81 310.4,39.81 309.19,38.6 307.63,38.6 307.54,38.69 291.86,38.69 290.58,37.41 290.58,36.73 287.32,33.47 279.8,33.47 279.32,33.95 275.84,33.95 274.65,32.76 273.45,32.76 271.62,34.59 265,34.59 263.6,33.19 252.03,33.19 251.38,32.54 248.07,32.54 246.37,30.84 246.06,30.84 246.03,30.81 245.71,30.81 245.66,30.77 244.59,30.77 238.28,24.46 238.28,23.56 237.3,22.57 237.16,22.57 236.8,22.22 235.98,22.22 235.95,22.2 235.46,22.2 235.34,22.09 234.62,21.36 230.05,21.36 229.86,21.56 228.56,21.56 228,21 227.29,21 226.39,21.9 225.75,21.9 224.86,22.79 224.01,22.79 223.16,23.64 223.16,23.94 222.03,25.07 220.99,25.07 220.8,25.26 220.8,25.55 220.7,25.65 220.7,26.02 v2(220.64,26.08)
  IN2 w0.089: v2(210.14,26.84) 210.5,26.84 210.82,27.16 211.55,27.16 211.6,27.21 213.24,27.21 213.54,26.91 215.17,26.91 215.24,26.85 217.05,26.85 217.43,26.47 218,26.47 218.39,26.08 218.47,26.08 218.68,25.87 218.68,25.79 219.02,25.45 219.18,25.45
  IN2 w0.102: 219.18,25.45 219.62,25.45 220.26,26.09 220.63,26.09 v2(220.64,26.08)
  BOTTOM w0.089: v2(210.14,26.84) 209.9,26.84 UH1.AN29
  BOTTOM w0.107: JWLAN.45 313.32,37.14 v2(313.7,37.52)
CLKREQ_PCIE#7: length 59.6
  IN1 w0.089: v2(206.13,21.9) 206.34,21.69 206.34,21.62 206.55,21.41 206.85,21.41 206.9,21.45 207.91,21.45 208.42,21.96 209.64,21.96 210.83,20.78 211.65,20.78 212.3,20.13 212.3,19.04 212.93,18.42 214.3,18.42 214.41,18.53 214.55,18.58 215,18.58 215.37,18.95 218.1,18.95 218.39,19.24 218.96,19.24 219.18,19.46
  IN1 w0.102: 219.18,19.46 221.15,19.46 221.81,20.12 222.26,20.12 222.64,19.74 223.21,19.74 224.35,18.6 226.06,18.6 226.39,18.26 230.97,18.26 231.24,18 233.6,18 233.64,18.04 v2(233.69,18.04)
  BOTTOM w0.089: 204.24,16.96 204.54,17.26 UH1.AC48 204.54,18.59 205.11,19.17 205.11,20.88 205.43,21.2 205.88,21.2 206.13,21.45 v2(206.13,21.9)
  BOTTOM w0.102: 204.24,16.96 203.77,16.49 203.77,13.07 203.59,12.9 R366.1 ; v2(233.69,18.04) 233.57,18.04 233.41,17.88 233.41,11.24 233.77,10.89 237.96,10.89 240.13,8.72 241.15,8.72 241.27,8.59 JSSD3.52
CLKREQ_PEG#0: length 150.3
  IN1 w0.089: 202.51,40 203.53,38.98 203.53,38.72 205.89,36.35 207.68,36.35 208.03,36 208.03,34.28 208.67,33.65 211.27,33.65 211.59,33.33 211.84,33.33 214.21,30.97 214.21,30.46 215.08,29.58 215.08,29.2 214.64,28.76 213.47,28.76 213.18,28.47 213.18,27.87 212.42,27.11 212.42,26.22 213.04,25.59 214.91,25.59 215.67,26.35 v2(216.85,26.35)
  IN1 w0.102: 202.51,40 200.8,40 197.43,43.36 197.43,45.56 197.53,45.66 197.53,47.61 197.52,47.62 197.52,48.57 196.88,49.21 196.71,49.21 194.75,51.16 194.75,52.19 192.52,54.43 192.52,58.58 191.99,59.1 191.99,59.63 192.52,60.15 192.52,60.66 192.86,61 192.86,61.83 193.56,62.53 193.56,63.74 193.3,64 193.3,64.38 194.13,65.21 v2(194.19,65.21) ; v2(200.52,122.19) 200.19,122.19 199.72,121.72 199.72,120.45 199.27,120.01 197.04,120.01 196.06,119.02 196.06,115.05 195,113.99 194.35,113.99 192.38,112.02 192.38,108.28 v2(191.91,107.81)
  IN6 w0.089: v2(216.85,26.35) 216.85,26.36 218.13,26.36 218.4,26.63 218.4,27 v2(218.77,27.36)
  IN6 w0.102: v2(194.19,65.21) 193.23,66.17 190.39,66.17 189.95,65.72 188.72,65.72 188.48,65.97 182.61,65.97 179.2,69.38 179.2,73.2 179.43,73.43 180.76,74.76 180.76,75.53 181.11,75.88 181.33,75.88 182.11,76.67 182.97,76.67 184.83,78.53 184.83,94.41 184.48,94.76 184.48,100.99 188.19,104.7 188.45,104.7 191.43,107.69 191.78,107.69 v2(191.91,107.81)
  BOTTOM w0.089: v2(218.77,27.36) 218.96,27.17 219.18,27.17
  BOTTOM w0.102: QG510.1 199.31,123.39 v2(200.52,122.19) ; 219.18,27.17 219.46,27.17 219.59,27.05 RP3.5
  BOTTOM w0.122: v2(216.85,26.35) 216.61,26.35 216.29,26.67 UH1.BF31
CLKREQ_PEG#0_R: length 52
  TOP w0.102: v2(212.8,130.48) 211.57,130.48 208.86,127.77 v1(208.75,127.77) 206.88,125.9 205.3,125.9 199.42,120.02 198.93,120.02 198.53,120.41 198.53,120.76 v2(198.26,121.03)
  IN1 w0.102: v2(235.37,121.37) 234.29,121.37 226.77,128.9 219.11,128.9 217.53,130.48 v2(212.8,130.48)
  BOTTOM w0.089: RG2.1 235.25,121.49 v2(235.37,121.37) 235.99,121.37 236.15,121.21 236.15,118.04 236.47,117.72 UG9.BL26
  BOTTOM w0.102: v2(198.26,121.03) 197.8,121.49 QG510.3
CLKREQ_PEG#6: length 318.6
  TOP w0.089: 219.18,27.96 219.08,27.87 218.7,27.87 218.39,27.55 218.39,27.23 218.44,27.17 218.44,26.99 218.7,26.72 v2(218.77,26.72)
  TOP w0.102: 219.18,27.96 219.77,28.55 RP5.5 ; v2(181.17,22.59) 179.65,24.12 179.65,29.84 182.38,32.57 182.38,33.52 184.6,35.74 v1(184.6,40.45) 184.6,41.23 189.68,46.3 189.68,50.36 186.29,53.74 186.29,60.6 186.39,60.7 v2(187.15,60.7)
  TOP w0.107: UE5.19 298.34,26.41 298.06,26.7 297.98,26.7 297.58,27.09 297.58,29.25 296.36,30.47 296.36,31.02 295.11,32.28 295.11,34.2 v2(293.44,35.87)
  IN1 w0.089: 219.18,25.53 218.94,25.53 218.68,25.79 218.68,25.87 218.64,25.92 218.64,26.53 218.77,26.66 v2(218.77,26.72)
  IN1 w0.102: 219.18,25.53 219.89,25.53 219.91,25.52 220.73,24.69 221.65,24.69 221.93,24.41 221.93,23.82 222.2,23.55 222.89,23.55 223.91,22.53 224.67,22.53 225.54,21.67 226.26,21.67 227.16,20.77 228.1,20.77 228.66,21.33 229.77,21.33 229.96,21.14 234.71,21.14 235.48,21.9 235.55,21.97 236.02,21.97 236.05,21.99 236.9,21.99 237.25,22.35 237.39,22.35 238.51,23.46 238.51,24.36 244.69,30.54 245.76,30.54 245.8,30.58 246.44,30.58 247.38,31.52 248.17,32.31 251.48,32.31 252.13,32.96 264.6,32.96 265.09,32.46 271.94,32.46 272,32.53 274.75,32.53 275.18,32.96 288.81,32.96 291.71,35.87 v2(293.44,35.87)
  IN2 w0.089: v2(206.18,19.19) 205.12,18.13 200.79,18.13 200.61,17.95 199.63,17.95 199.02,17.34 199.02,16.96 ; 193.27,19.63 193.84,19.07 193.91,19.07 194.71,18.26 194.71,16.96
  IN2 w0.102: v2(187.15,60.7) 187.1,60.7 183.79,64.01 175.92,71.88 175.92,81.71 177.08,82.87 177.08,93.87 178.69,95.48 178.69,105.68 180.87,107.86 180.87,122.26 188.51,129.9 188.51,144.2 187.25,145.46 187.25,148.8 183.62,152.43 174.06,152.43 170.85,155.64 169.36,155.64 169.11,155.88 169.11,158.55 169.79,159.24 169.79,160.15 v2(169.69,160.25) ; 199.02,16.96 199.02,16.67 198.92,16.56 196.29,16.56 196.2,16.48 195.15,16.48 194.71,16.91 194.71,16.96 ; 193.27,19.63 193.04,19.87 191.39,19.87 189.02,22.24 184.13,22.24 183.75,22.62 181.58,22.62 181.55,22.59 v2(181.17,22.59)
  IN4 w0.089: v2(218.77,26.72) 218.7,26.66 218.64,26.66 218.49,26.51 218.49,26.49 216.95,24.95 216.68,24.95 214.44,22.72 212.92,22.72 212.48,22.28 211.78,22.28 211.46,21.96 211.46,21.18 211.09,20.81 210.01,20.81 209.77,21.05 208.46,21.05 206.6,19.19 v2(206.18,19.19)
  BOTTOM w0.089: UH1.AE47 205.83,18.84 v2(206.18,19.19)
  BOTTOM w0.381: UM4.17 169.24,160.7 v2(169.69,160.25)
CLKRUN#: length 4.8
  TOP w0.089: RH85.1 214.98,27.69 214.93,27.69 214.86,27.76 213.32,27.76 212.92,27.36 v1(212.62,27.36) 212.26,27.36 v2(211.75,26.85)
  BOTTOM w0.122: UH1.AV32 v2(211.75,26.85)
CMSRC_CHG: length 4.7
  TOP w0.102: PR706.2 58.29,28.14 58.94,28.78 58.94,29.51 v1(59.48,30.05)
  TOP w0.203: PU700.3 57.84,27.28 58.29,27.73 PR706.2
CNV_BRI_PRX_DTX: length 9.9
  BOTTOM w0.089: UH1.AY2 212.8,40.64 212.8,42.3 213.41,42.91 213.48,42.98 215.12,42.98 215.41,43.27 215.41,43.88
  BOTTOM w0.102: 215.41,43.88 216.07,44.53 216.78,44.53 217.26,45.01 217.26,46.46 RH181.2
CNV_BRI_PTX_DRX: length 10.2
  BOTTOM w0.089: UH1.AV4 211.74,39.66 211.59,39.81 211.59,40.29 211.65,40.35 211.65,40.36 211.75,40.47 211.75,40.73 211.99,40.97 211.99,40.97 212.1,41.08 212.1,42.14 212.16,42.2 212.16,42.42 212.87,43.13 212.87,43.84 212.92,43.88
  BOTTOM w0.102: 212.92,43.88 213.48,44.44 214.54,44.44 214.89,44.8 RH603.2 214.42,45.7 214.42,47.03 v1(214.72,47.32)
CNV_RGI_PRX_DTX: length 7.6
  BOTTOM w0.089: 213.29,43.88 213.29,43.3 212.43,42.43 212.43,42.22 212.29,42.08 212.29,41.01 211.93,40.65 211.93,40.39 211.83,40.29 UH1.AV3
  BOTTOM w0.102: RH182.2 215.78,45.07 215.24,44.53 214.95,44.53 214.63,44.21 213.57,44.21 213.29,43.93 213.29,43.88
CNV_RGI_PTX_DRX: length 5.3
  TOP w0.089: RH595.1 212.45,41.68 RH168.1 212.54,41.66 213.29,42.41 v2(213.43,42.41)
  BOTTOM w0.089: v2(213.43,42.41) 213.29,42.41 213.04,42.15 213.04,41.1 213.19,40.95 213.19,40.11 213.54,39.76 UH1.BA4
CNV_WT_RCOMP: length 10.5
  BOTTOM w0.122: UH1.BA1 213.39,41.73 214.39,42.73 218.49,42.73 219.02,43.26 v1(220.09,43.26) 220.22,43.26 220.66,42.81 221.75,42.81 222.22,42.35 RH213.1
CODEC_MUTE#: length 342.8
  TOP w0.107: UA4.15 36.65,15.5 36.96,15.81 36.96,16.35 RA70.2 38.06,16.91 v2(38.06,16.5) ; v2(324.65,20.23) 324.65,20.41 324.9,20.66 JIO.19 ; DA3.1 v2(35.14,42.39)
  IN2 w0.089: 202.04,16.96 202.1,17.01 207.28,17.01 207.34,16.96
  IN2 w0.102: 202.04,16.96 201.02,15.93 197.69,15.93 197.69,15.93 197.5,15.93 197.5,15.93 197.31,15.93 196.26,14.88 194.53,14.88 193.57,15.85 193.57,16.55 192.77,17.35 192.07,17.35 191.82,17.6 191.82,18.47 189.41,20.88 187.5,20.88 187.06,21.31 181.74,21.31 181.58,21.47 169.46,21.47 169.01,21.02 127.59,21.02 125.98,19.41 99.21,19.41 96.28,16.48 84.43,16.48 82.79,14.84 56.43,14.84 55.27,16 38.56,16 v2(38.06,16.5) ; v2(324.65,20.23) 324.31,20.23 323.48,19.41 321.33,19.41 320.69,20.05 320.56,20.18 313.25,20.18 312.11,19.05 312.11,18.53 311.95,18.37 310.53,16.95 309.95,16.95 309.63,16.63 308.17,16.63 307.73,16.18 307.73,15.15 306.45,13.87 304.89,13.87 303.81,14.95 303.55,15.22 300.16,15.22 299.6,15.22 299.59,15.22 299.4,15.22 299.4,15.21 299.27,15.08 297.5,15.08 297.34,14.92 295,14.92 294.6,15.32 294.38,15.54 293.56,15.54 292.66,16.43 292.57,16.53 282.59,16.53 279.93,16.53 279.79,16.66 278.85,17.61 278.79,17.61 278.79,17.61 278.03,17.61 277.85,17.61 277.4,18.06 277.4,19.17 276.73,19.84 276.02,19.84 275.39,20.46 273.67,20.46 272.04,22.08 271.85,22.08 269.65,22.08 269.6,22.12 267.21,22.12 266.85,22.49 259.34,22.49 256.84,19.99 251.11,19.99 248.11,17 247.66,17 247.35,16.69 246.82,16.69 246.27,17.25 239.26,17.25 237.22,15.21 222.09,15.21 221.32,15.97 220.13,15.97 219.79,15.64 218.6,15.64 218.29,15.95 214.4,15.95 213.9,15.45 208.85,15.45 207.34,16.96
  IN6 w0.097: v2(38.06,16.5) 37.83,16.73 37.83,19.34 36.48,20.69 36.48,23.42 35.32,24.58 35.32,28.01 ; 33.28,40.54 v2(35.14,42.39)
  IN6 w0.102: 35.32,28.01 34.73,28.6 34.73,29.67 35.02,29.96 35.02,34.42 33.28,36.16 33.28,40.54
  BOTTOM w0.102: v2(38.06,16.5) v1(38.58,16.5)
COMP: length 3.6
  BOTTOM w0.203: PU6000.30 272.59,141.87 v1(271.57,142.9) 271.54,142.93 270.72,142.93 PR6017.1
  BOTTOM w0.254: PR6017.1 PC6007.2
COMP_1PH: length 8.8
  TOP w0.203: PU500.50 125.74,139.14 125.97,138.92 125.97,138.74 126.07,138.64 v2(126.07,138.65)
  BOTTOM w0.102: v1(128.66,134.52) 128.41,134.78 128.41,135.32 128.8,135.72 PC509.1
  BOTTOM w0.254: PC509.1 128.81,136.27 128.28,136.81 128.28,137.93 128.11,138.09 128.11,138.9 127.52,139.5 PC510.2 126.89,139 126.44,139 126.07,138.64 v2(126.07,138.65)
COMP_2PH: length 3.2
  TOP w0.203: v2(120.18,142.72) 120.18,142.75 120.22,142.7 PU500.33
  BOTTOM w0.102: v2(120.18,142.72) 120.44,142.72 v1(120.68,142.47)
  BOTTOM w0.254: PC521.2 119.44,143.67 PC519.2 120.07,142.83 v2(120.18,142.72)
COMP_4PH: length 2.9
  TOP w0.203: PU500.6 v2(128.07,142.3)
  BOTTOM w0.254: v2(128.07,142.3) 128.14,142.23 PR535.1 128.82,142.23 129.69,141.35 PC515.1
CORE_SW1: length 7
  TOP w0.102: PR555.1 v1(150.18,141.78)
  TOP w0.254: PR601.1 151.37,139.42 v2(151.48,139.31)
  TOP w0.508: v2(149.18,144.02) 149.88,143.33 PR555.1
  BOTTOM w0.254: v2(151.48,139.31) 151.02,139.77 PL501.1
CORE_SW2: length 6
  TOP w0.127: v2(156.97,139.52) v1(156.2,139.52)
  TOP w0.254: PR602.1 158.48,136.15 v2(158.62,136.01)
  TOP w0.508: PR565.1 v2(156.97,139.52)
  BOTTOM w0.254: v2(158.62,136.01) 158.62,137.09 158.37,137.34 PL502.1
CORE_SW3: length 8
  TOP w0.102: PR575.1 v1(164.25,139.52)
  TOP w0.254: v2(168.03,136.3) 168.11,136.38 PR603.1
  TOP w0.508: PR575.1 v2(165.6,140.98)
  BOTTOM w0.254: v2(168.03,136.3) 168.03,137.09 168.28,137.34 PL503.1
CORE_SW4: length 6.5
  TOP w0.102: v2(175.81,135.87) v1(176.37,135.87)
  TOP w0.254: PR604.1 175.69,135.99 v2(175.81,135.87)
  TOP w0.508: PR593.1 v2(173.59,139.52)
  BOTTOM w0.254: 176.93,139.04 PL506.1 176.93,136.06 176.74,135.87 v2(175.81,135.87)
CPU_24MHZ_N: length 106
  IN1 w0.089: v2(176.41,116.6) 176.22,116.79 173.49,116.79 172.92,117.36 172.92,118.55 172.67,118.8 170.89,118.8 170.44,118.35 170.44,117.74 170.44,117.63 170.67,117.4 v2(170.7,117.4)
  IN3 w0.127: v2(191.19,40.51) 191.19,40.44 191.06,40.31 190.65,40.31 190.52,40.44 190.52,42.58 188.41,44.7 188.41,52.69 187.75,53.35 187.75,54.7 186.83,55.61 186.83,55.95 186.5,56.29 186.5,58.36 186.62,58.48 186.8,58.48 v2(186.98,58.31)
  BOTTOM w0.107: v2(191.19,40.51) 191.07,40.39 191.07,40.21 191.55,39.73 191.75,39.73 192.06,39.42 192.61,39.42 193.48,38.55 194.12,38.55 194.15,38.53 194.67,38.53 UH1.C6 ; v2(176.41,116.6) 176.44,116.6 176.61,116.77 177.46,116.77 177.46,116.77 177.93,116.77 177.93,116.77 178.27,116.77 182.23,112.81 182.23,109.17 179,105.94 179,96.62 176.86,94.48 176.86,89.87 185.01,81.72 185.01,71.74 183.52,70.25 183.52,67.14 182.91,66.53 182.91,62.95 184.65,61.21 184.65,59.51 185.64,58.51 186.77,58.51 v2(186.98,58.31) ; v2(170.7,117.4) 170.72,117.4 171.03,117.71 UC1.D31
CPU_24MHZ_P: length 107
  IN1 w0.089: v2(176.41,117.15) 176.22,116.96 173.55,116.96 173.08,117.43 173.08,118.61 172.73,118.96 170.82,118.96 170.28,118.42 170.28,117.74 170.28,117.6 v2(170.05,117.38)
  IN3 w0.127: v2(186.99,58.89) 186.98,58.89 186.79,58.7 186.53,58.7 186.28,58.45 186.28,56.2 186.61,55.86 186.61,55.52 187.53,54.61 187.53,53.26 188.19,52.6 188.19,44.61 190.31,42.49 190.31,40.35 v2(190.76,39.89)
  BOTTOM w0.107: v2(186.99,58.89) 186.81,58.72 185.73,58.72 184.85,59.59 184.85,61.3 183.12,63.03 183.12,66.45 183.73,67.06 183.73,70.17 185.22,71.66 185.22,81.8 177.06,89.96 177.06,94.39 179.2,96.54 179.2,105.85 182.43,109.08 182.43,112.9 178.35,116.98 v4(177.69,116.98) 176.58,116.98 v2(176.41,117.15) ; v2(190.76,39.89) 191.1,39.89 191.47,39.53 191.67,39.53 191.97,39.22 192.53,39.22 193.4,38.35 194.04,38.35 194.06,38.32 194.49,38.32 194.6,38.22 194.95,38.22 195.05,38.31 UH1.D7 ; UC1.E31 170.38,117.71 v2(170.05,117.38)
CPU_B+: length 17.6
  IN3 w0.254: v2(127.69,148.78) 128.16,148.78 130.21,150.83 130.21,151.49 130.21,151.49 130.21,151.99 130.21,152 130.21,152.05 131.61,153.44 137.08,153.44 138.21,152.32 138.21,151.67 138.21,151.66 138.21,151.16 138.21,151.16 138.21,150.88 139.45,149.63
  BOTTOM w0.254: PR571.1 v2(127.69,148.78)
  vias: v1(184.54,147.79) v2(139.23,148.92) v2(139.23,148.34) v2(139.23,147.76) v2(139.23,147.15) v2(139.23,146.51) v2(139.23,145.93) v2(139.23,145.28) v2(139.84,148.92) v2(139.84,148.34) v2(139.84,147.76) v2(139.84,147.15) v2(139.84,146.51) v2(139.84,145.93) v2(139.84,145.28) v2(147.1,149.57) v2(147.1,148.98) v2(147.1,148.4) v2(147.68,149.59) v2(147.68,149.01) v2(147.68,148.42) v2(154.91,149.59) v2(155.21,149.07) v2(155.23,148.47) v2(155.37,155.01) v2(155.37,154.43) v2(155.5,149.61) v2(155.79,149.07) v2(155.82,148.47) v2(155.97,155.04) v2(155.97,154.46) v2(156.96,155.01) v2(156.96,154.43) v2(157.56,155.04) v2(157.56,154.46) v2(158.61,155.01) v2(158.61,154.43) v2(159.21,155.04) v2(159.21,154.46) v2(162.59,147.18) v2(162.59,146.59) v2(162.59,146.01) v2(163.13,146.95) v2(163.13,146.37) v2(163.13,145.78) v2(170.07,147.05) v2(170.67,147.07) v2(171.34,146.86) v2(171.36,146.26) v2(171.92,146.86) v2(171.95,146.26) v2(177.83,146.74) v2(178.35,147.01) v2(178.29,146.21) v2(178.89,146.76) v2(178.89,146.18) v2(178.89,145.59) v2(185.38,146.89) v2(185.38,146.3) v2(185.98,146.91) v2(185.98,146.33) v2(186.08,145.74) v2(186.09,145.14)
CPU_DDC1CLK: length 47
  TOP w0.107: v2(208.94,35.94) 208.5,36.38 208.5,37.17 208.32,37.36 208.32,37.9 208.99,38.57 208.99,40.38 209.64,41.02 213.44,41.02 214.22,41.81 215.69,41.81 217.09,43.21 217.09,43.42 216.95,43.56 v2(216.95,43.57)
  IN1 w0.089: v2(216.95,43.57) 217.14,43.76 217.14,46.2 214.27,49.07 214.27,50.69 210.4,54.57 210.4,61.63 210.88,62.11 210.88,65.95 210.65,66.18 209.4,66.18 v2(209.19,65.97)
  BOTTOM w0.107: v2(209.19,65.97) 208.98,66.18 208.49,66.18 RT128.1 ; UH1.AL13 208.33,35.33 v2(208.94,35.94) ; v2(216.95,43.57) 217.14,43.76 217.14,44.21 218.03,45.1 218.03,45.51 RH604.2
CPU_DDC1CLK_R: length 146.5
  TOP w0.102: v2(178.05,163.01) UT1.Y5
  IN1 w0.089: v2(174.87,165.85) 174.87,165.81 175.24,165.43 175.97,165.43 176.06,165.34 176.06,162.86 177.31,161.61 186.11,161.61 187.45,160.26 188.21,160.26 188.88,159.59 188.88,159.43 190.66,157.66 190.66,155.16 196.67,149.15 196.67,145.54 197.27,144.94 197.27,134.12 192.41,129.26 192.41,123.75 190.95,122.29 190.95,114.58 188.4,112.03 188.4,110.69 187.43,109.72 187.43,100.43 188.73,99.13 188.73,97.48 190.5,95.71 190.5,88.32 188.28,86.1 188.28,71.93 191.49,68.72 193.53,68.72 193.93,68.32 199.83,68.32 200.45,67.71 201.52,67.71 203.14,66.09 206.47,66.09 v2(206.68,65.88)
  IN4 w0.127: v2(178.05,163.01) 177.63,162.59 177.23,162.59 176.79,163.02 176.79,164.14 176.35,164.58 176.35,166.04 175.66,166.73 175.07,166.73 174.87,166.53 v2(174.87,165.85)
  BOTTOM w0.107: v2(174.87,165.85) 174.87,165.72 174.63,165.48 RPT1.3 ; RT128.2 207.55,66.16 206.96,66.16 v2(206.68,65.88)
CPU_DDC1DATA: length 47.1
  TOP w0.107: v2(209.36,37.06) 208.9,37.06 208.52,37.44 208.52,37.81 209.2,38.49 209.2,40.3 209.72,40.82 213.53,40.82 214.31,41.6 215.77,41.6 217.29,43.12 217.29,43.32 217.53,43.56 v2(217.53,43.57)
  IN1 w0.089: v2(209.19,66.56) 209.4,66.35 210.72,66.35 211.04,66.02 211.04,62.04 210.56,61.56 210.56,54.63 214.44,50.76 214.44,49.13 217.31,46.27 217.31,43.79 217.53,43.56 v2(217.53,43.57)
  BOTTOM w0.107: v2(209.36,37.06) 209.51,37.21 209.51,37.44 209.97,37.91 UH1.AR8 ; v2(217.53,43.57) 217.34,43.76 217.34,44.12 218.23,45.01 218.23,45.46 RH605.2 ; v2(209.19,66.56) 209.01,66.38 208.49,66.38 RT129.1
CPU_DDC1DATA_R: length 141.3
  TOP w0.089: UT1.R4 v2(177.4,165.61)
  IN1 w0.089: v2(177.4,165.61) 176.46,165.61 176.22,165.37 176.22,162.93 177.38,161.77 186.18,161.77 187.52,160.43 188.28,160.43 189.05,159.66 189.05,159.5 190.83,157.72 190.83,155.23 196.83,149.22 196.83,145.61 197.44,145.01 197.44,134.05 192.58,129.19 192.58,123.68 191.12,122.22 191.12,114.51 188.57,111.96 188.57,110.62 187.59,109.65 187.59,100.5 188.9,99.2 188.9,97.55 190.67,95.77 190.67,88.25 188.45,86.03 188.45,72 191.55,68.89 193.6,68.89 194,68.49 199.9,68.49 200.52,67.87 201.59,67.87 203.21,66.25 206.47,66.25 v2(206.68,66.46)
  BOTTOM w0.099: RPT1.4 174.33,164.98
  BOTTOM w0.107: 174.33,164.98 174.48,165.13 174.91,165.13 175.19,165.41 176,165.41 v1(176.2,165.61) v2(177.4,165.61) ; v2(206.68,66.46) 206.78,66.36 207.51,66.36 RT129.2
CPU_DDC2CLK: length 48.3
  TOP w0.107: RH607.2 216.8,39.58 v2(217.06,39.84)
  IN1 w0.089: v2(209.17,67.14) 209.38,67.35 210.63,67.35 211.54,66.44 211.54,61.77 211.03,61.26 211.03,54.83 214.91,50.95 214.91,49.33 217.9,46.34 217.9,41.18 217.27,40.55 217.27,40.05 v2(217.06,39.84)
  IN6 w0.089: v2(208.87,35.06) 208.3,35.63 208.3,36.08 208.07,36.31 208.07,36.59 208.37,36.89 208.37,37.02 208.97,37.62 211.46,37.62 211.87,38.03 212.75,38.03 213.19,38.46 215.79,38.46 216.22,38.89 217.03,38.89 217.27,39.12 217.27,39.63 v2(217.06,39.84)
  BOTTOM w0.107: v2(209.17,67.14) 208.98,67.33 208.49,67.33 RT126.1 ; UH1.AN13 208.9,35.08 v2(208.87,35.06)
CPU_DDC2CLK_R: length 146.8
  TOP w0.089: UT1.Y8 179.33,162.98 179.33,164.1 179.52,164.3 180.02,164.3 v2(180.03,164.31)
  IN1 w0.089: v2(180.03,164.31) 180.03,164.51 180.3,164.79 181.21,164.79 181.76,165.35 181.76,165.36 181.83,165.43 182.34,165.43 182.34,165.43 182.39,165.43 182.49,165.53 182.49,165.53 183.02,166.07 183.65,166.07 183.74,165.98 183.74,164.03 184.31,163.45 185.96,163.45 187.25,162.16 187.25,161.61 187.96,160.9 188.47,160.9 188.83,160.54 189.86,160.54 190.12,160.28 190.12,159.29 191.3,158.11 191.3,155.42 197.33,149.39 197.33,145.78 197.91,145.2 197.91,133.8 193.05,128.94 193.05,123.37 192.44,122.76 192.44,115.17 189.07,111.8 189.07,106.4 188.79,106.12 188.79,100.46 189.39,99.86 189.39,97.72 191.14,95.97 191.14,88.06 188.92,85.84 188.92,72.19 191.75,69.36 194.04,69.36 194.38,69.02 200.03,69.02 200.71,68.34 201.79,68.34 202.8,67.33 206.46,67.33 v2(206.67,67.12)
  IN4 w0.127: v2(174.15,166.98) 174.15,166.93 174.25,166.83 174.25,165.74 174.57,165.42 175.32,165.42 175.66,165.42 175.84,165.24 175.84,164.37 176.28,163.93 176.28,162.81 177.02,162.08 178.36,162.08 179.52,163.24 179.52,163.8 v2(180.03,164.31)
  BOTTOM w0.099: RPT1.1 174.03,166.48
  BOTTOM w0.107: v2(174.15,166.98) 174.15,166.6 174.03,166.48 ; RT126.2 207.53,67.33 206.88,67.33 v2(206.67,67.12)
CPU_DDC2DATA: length 47.9
  TOP w0.107: v2(217.64,39.84) 217.67,39.81 RH606.2
  IN1 w0.089: v2(209.17,67.73) 209.38,67.52 210.69,67.52 211.71,66.51 211.71,61.7 211.2,61.19 211.2,54.9 215.07,51.02 215.07,49.4 218.06,46.41 218.06,41.11 217.43,40.48 217.43,40.05 v2(217.64,39.84)
  IN6 w0.089: v2(209.03,36.53) 208.82,36.53 208.49,36.2 208.42,36.2 208.24,36.38 208.24,36.52 208.54,36.82 208.54,36.95 209.04,37.46 211.53,37.46 211.93,37.86 212.82,37.86 213.26,38.29 215.86,38.29 216.29,38.73 217.1,38.73 217.43,39.06 217.43,39.63 v2(217.64,39.84)
  BOTTOM w0.107: UH1.AL10 208.97,36.58 v2(209.03,36.53) ; RT127.1 208.49,67.54 208.98,67.54 v2(209.17,67.73)
CPU_DDC2DATA_R: length 140.4
  TOP w0.102: UT1.N4 v2(177.4,166.26)
  IN1 w0.089: v2(177.4,166.26) 177.47,166.26 178.31,165.42 178.31,164.72 178.51,164.52 179.56,164.52 180.01,164.96 181.13,164.96 181.77,165.6 182.32,165.6 182.95,166.23 183.72,166.23 183.9,166.05 183.9,164.1 184.38,163.62 186.02,163.62 187.41,162.23 187.41,161.68 188.02,161.06 188.54,161.06 188.9,160.71 189.92,160.71 190.28,160.35 190.28,159.36 191.46,158.18 191.46,155.49 197.49,149.46 197.49,145.85 198.07,145.27 198.07,133.73 193.21,128.87 193.21,123.3 192.6,122.69 192.6,115.1 189.24,111.73 189.24,106.33 188.96,106.05 188.96,100.52 189.56,99.93 189.56,97.78 191.3,96.04 191.3,87.99 189.08,85.77 189.08,72.26 191.82,69.52 194.11,69.52 194.45,69.18 200.1,69.18 200.78,68.51 201.86,68.51 202.87,67.49 206.46,67.49 v2(206.67,67.7)
  BOTTOM w0.107: RPT1.2 174.25,165.98 174.53,166.26 174.7,166.26 175.04,166.26 175.04,166.26 v2(177.4,166.26) ; v2(206.67,67.7) 206.83,67.54 207.53,67.54 RT127.2
CPU_DISPA_BCLK: length 105.5
  IN6 w0.097: v2(169.46,115.06) 168.61,115.06 168.19,114.64 168.19,107.64 169.05,106.78 172.28,106.78 172.93,106.13 172.93,97.25 176.5,93.68 176.5,92.94
  IN6 w0.102: v2(202.96,62.48) 202.03,63.41 202.03,63.43 199.5,65.97 196.02,65.97 195.62,65.57 195.62,64.59 194.24,63.22 193.51,62.73 192.56,62.73 191.64,63.64 190.19,63.64 189.13,64.7 187.52,64.7 187.33,64.9 186.94,64.9 186.57,64.53 182.3,64.53 178.31,68.52 178.17,68.65 178.17,73.98 178.48,74.29 178.7,74.29 179.68,75.26 179.68,80.41 178.42,81.67 178.42,89.93 176.5,91.85 176.5,92.94
  BOTTOM w0.089: UC1.G27 169.08,114.68 v2(169.46,115.06)
  BOTTOM w0.102: 213.64,49.57 213.95,49.26 RH38.1
  BOTTOM w0.107: v2(202.96,62.48) 203.24,62.76 203.39,62.76 204.1,62.05 v1(204.1,61.4) 204.1,60.37 204.5,59.97 204.71,59.97 205.13,59.97 208.52,56.58 208.52,55.32 211.28,52.56 211.28,52.17 213.3,50.14 213.3,49.91 213.64,49.57
CPU_DISPA_BCLK_R: length 10.5
  BOTTOM w0.089: UH1.AM3 209.37,40.41 209.37,41.01
  BOTTOM w0.122: 209.37,41.01 209.37,42.07 209.38,42.08 209.37,42.09 209.37,42.15 209.5,42.28 209.5,43.27 209.5,43.27 209.5,43.52 209.72,43.74 210.67,43.74 210.96,44.02 v1(210.96,46.24) 210.96,46.32 212.43,47.79 212.91,47.79 RH38.2
CPU_DISPA_SDI: length 119.4
  IN2 w0.102: v2(181.3,62.21) 182.88,60.63 182.88,58.88 186.41,55.34 187.57,55.34 187.89,55.65 193.15,55.65 195.05,57.56 195.05,58.64 198.45,62.03 198.45,62.18 v2(198.44,62.18)
  IN3 w0.089: 210.46,43.88 210.46,43.24 210.01,42.79 v2(209.88,42.79)
  IN3 w0.102: 210.46,43.88 210.46,44.18 208.94,45.71 203.74,45.71 200.92,48.54 200.92,59.3 198.92,61.3 198.92,61.43 198.45,61.89 198.45,62.18 v2(198.44,62.18)
  BOTTOM w0.089: RC66.2 177.19,115.48 177.75,114.93 177.75,114.74 178.94,113.54 v1(178.94,113.29) 179.53,112.7
  BOTTOM w0.102: v2(181.3,62.21) 181.26,62.21 180.64,62.83 180.64,66.36 181.09,66.81 181.09,73.3 182.29,74.5 182.29,76.02 183.39,77.12 183.39,80.58 182.18,81.79 180.59,81.79 175.21,87.18 175.21,94.48 178.12,97.39 178.12,107.36 180.6,109.85 180.6,111.62 179.53,112.7
  BOTTOM w0.122: UH1.AN3 209.58,40.07 209.58,41.98 209.88,42.28 v2(209.88,42.79)
CPU_DISPA_SDI_R: length 7.1
  BOTTOM w0.076: UC1.G29 169.36,116.52 173.89,116.52 174.2,116.83 v1(174.52,116.83) 175.29,116.83 RC66.1
CPU_DISPA_SDO: length 107.2
  IN6 w0.097: 176.82,92.9 176.82,93.77 173.19,97.41 173.19,106.74 172.36,107.57 168.68,107.57 168.38,107.88 168.38,113.16 v2(168.7,113.48)
  IN6 w0.102: 176.82,92.9 176.82,92 178.81,90.02 178.81,81.84 180.07,80.58 180.07,75.97 179.96,75.86 179.96,75.17 178.4,73.61 178.4,68.75 182.39,64.76 186.48,64.76 186.84,65.12 187.42,65.12 187.62,64.93 189.23,64.93 189.27,64.89 190.29,63.87 191.74,63.87 191.95,63.66 192.82,63.66 193.12,63.36 194.05,63.36 194.1,63.39 194.19,63.49 194.19,63.49 195.39,64.69 195.39,65.66 195.92,66.2 199.59,66.2 202.26,63.53 202.26,63.51 202.27,63.49 202.64,63.49 203.46,62.67 v2(203.46,62.09)
  BOTTOM w0.076: v2(168.7,113.48) 168.7,113.47 UC1.G25
  BOTTOM w0.102: v2(203.46,62.09) 203.46,62.03 203.02,61.59 203.02,60.68 203.32,60.38 203.76,60.38 204.4,59.74 205.03,59.74 205.7,59.07
  BOTTOM w0.107: 205.7,59.07 208.28,56.49 208.28,55.23 211.04,52.46 211.04,52.07 212.87,50.25 v1(212.87,49.1) 212.87,48.63 210.42,46.19 RH39.1
CPU_DISPA_SDO_R: length 5.3
  BOTTOM w0.089: 209.58,43.88 209.24,43.55 209.24,42.54 209.05,42.35 208.8,42.35 208.53,42.08 208.53,41.11 208.93,40.72 UH1.AM2
  BOTTOM w0.102: 209.58,43.88 209.64,43.94 209.81,43.94 209.84,43.97 210.17,43.97 210.42,44.22 RH39.2
CPU_DP1_AUXN: length 67.1
  IN6 w0.089: v2(170.06,114.23) 170.42,114.59 170.76,114.59 171.2,115.03 171.96,115.03 175.33,118.39 176.49,118.39 178.02,119.92 180.72,119.92 181.26,120.45 183.07,120.45 192.89,130.27 192.89,135.37 192.38,135.88 192.38,139.45 192.88,139.95 192.88,142.23 192.1,143.01 192.1,148.9 189.94,151.06 189.94,151.65 189.62,151.97 189.51,151.97 189.43,151.89 189.43,151.57 v2(189.49,151.5)
  BOTTOM w0.089: UC1.E27 170.38,114.48 170.32,114.42 v2(170.06,114.23)
  BOTTOM w0.107: v2(189.49,151.5) 189.37,151.5 189.26,151.4 189.25,151.4 189.03,151.17 188.58,151.17 188.19,151.56 187.28,151.56 186.32,152.52 179.48,152.52 178.82,153.18 CT26.1
CPU_DP1_AUXN_C: length 11.7
  TOP w0.089: UT1.W11 v2(180,163.66)
  BOTTOM w0.099: CT26.2 178.8,155.06 RT76.1
  BOTTOM w0.107: CT26.2 178.97,155.23 178.97,155.74 179.38,156.15 180.24,156.15 180.34,156.24 180.34,156.43 180.31,156.46 180.31,157.16 179.17,158.3 179.17,158.36 179.16,158.37 v4(179.16,159.27) 179.16,160.05 179.07,160.15 179.07,161.52 179.21,161.66 179.21,162.91 179.69,163.39 179.74,163.39 v2(180,163.66)
