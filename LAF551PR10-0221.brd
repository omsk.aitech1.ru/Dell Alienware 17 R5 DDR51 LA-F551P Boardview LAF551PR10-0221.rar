# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PC_BEEP: length 14.6
  TOP w0.254: RA15.1 31.2,23.16 32.97,21.39 35.31,21.39 v1(36.66,22.74) 38.3,24.37 38.3,25.2 RA9.1 36.93,27.23 DA1.1
PCH_BATLOW#: length 214.2
  TOP w0.089: 219.18,18.41 v2(219.05,18.53)
  TOP w0.102: RH515.1 219.62,17.96 219.18,18.41
  TOP w0.107: RT14.2 171.74,163.71 171.57,163.54 v2(170.49,163.54)
  IN1 w0.089: v2(219.05,18.53) 218.77,18.53 218.64,18.41 216.42,18.41 215.44,17.43 214.57,17.43 214.26,17.73 212.77,17.73 211.78,18.72 211.78,19.14 211.22,19.71 211.21,19.71 211,19.92 211,19.92 210.66,20.26 210.61,20.26 210.33,20.54 209.8,20.54 208.92,19.66 207.75,19.66 206.36,18.28 200.35,18.28 199.84,18.79 198.76,18.79 197.43,20.12 197.43,20.69 197.68,20.95 198.57,20.95 199.14,20.37 200.83,20.37 200.92,20.46 200.92,20.5 201.49,21.07 201.49,21.83 201.18,22.15 200.22,22.15 199.62,22.76 199.62,26.18 198.95,26.85 198.95,29.13 198.38,29.7 198.38,31.23 197.98,31.63 196.47,31.63 196.07,32.02 196.07,32.66 194.75,33.98 194.75,35.31 193.41,36.65 192.1,36.65
  IN1 w0.102: v2(185.43,62.98) 185.43,62.84 185.43,56.64 186.01,56.06 186.01,43.1 187.17,41.93 187.17,40.79 187.53,40.43 187.53,39.22 188.85,37.9 189.37,37.9 189.75,37.52 189.75,36.81 190.56,35.99 190.99,35.99 191.65,36.65 192.1,36.65
  IN2 w0.102: v2(170.49,163.54) 170.09,163.13 170.09,160.42 170.63,159.88 170.63,157.47 171.01,157.09 171.01,155.79 174.15,152.66 183.71,152.66 187.48,148.89 187.48,145.56 188.74,144.3 188.74,129.8 181.1,122.16 181.1,107.77 178.88,105.55 178.88,95.35 177.31,93.77 177.31,86.59 177.31,86.59 177.31,82.78 176.15,81.62 176.15,71.98 185.14,62.98 v2(185.43,62.98)
  BOTTOM w0.102: v2(170.49,163.54) 170.49,163.66 v1(171.2,164.37)
  BOTTOM w0.122: UH1.BF44 215.98,20 216.25,19.74 216.51,19.74 217.24,19 218.58,19 v2(219.05,18.53)
PCH_CPU_BCLK_N: length 106.5
  IN3 w0.127: v2(188.9,39.49) 188.92,39.49 189.1,39.67 189.1,40.18 188.92,40.36 187.82,40.36 187.31,40.88 187.31,52.27 186.62,52.96 186.62,54.3 185.76,55.17 185.76,55.51 185.42,55.84 185.42,58.8 185.74,59.12 185.74,59.67 186.04,59.97 186.85,59.97 v2(187,60.12)
  BOTTOM w0.107: v2(188.9,39.49) 189.03,39.36 190.1,39.36 190.9,38.56 191.27,38.56 192.09,37.74 193.14,37.74 193.54,38.14 193.97,38.14 194.03,38.08 194.42,38.08 194.55,37.95 194.55,37.95 194.6,37.89 UH1.C8 ; UC1.A32 172.86,118.13 172.86,117.94 172.89,117.91 173.17,117.91 173.44,118.18 178.31,118.18 183.25,113.23 183.25,108.74 179.6,105.09 179.6,98.37 181,96.97 182.98,96.97 183.01,97 183.58,97 183.61,96.97 184.31,96.97 186.46,94.82 186.46,86.3 186.03,85.88 186.03,70.95 185.31,70.23 185.31,69.06 184.54,68.29 184.54,66.72 183.94,66.11 183.94,63.37 185.67,61.64 185.67,61.63 185.7,61.61 185.7,60.03 185.8,59.92 186.81,59.92 v2(187,60.12)
PCH_CPU_BCLK_P: length 106.5
  IN3 w0.127: v2(187,59.53) 186.88,59.66 186.86,59.66 186.77,59.75 186.13,59.75 185.96,59.58 185.96,59.03 185.64,58.71 185.64,55.93 185.98,55.6 185.98,55.26 186.84,54.39 186.84,53.05 187.53,52.36 187.53,40.97 187.91,40.58 189.01,40.58 189.32,40.28 189.32,39.31 189.07,39.07 189.06,39.07 v2(188.9,38.9)
  BOTTOM w0.107: UH1.B8 193.96,37.86 193.88,37.94 193.63,37.94 193.22,37.53 192.01,37.53 191.18,38.36 190.81,38.36 190.01,39.16 189.19,39.16 188.93,38.9 v2(188.9,38.9) ; UC1.B31 172.7,117.81 172.8,117.71 173.26,117.71 173.52,117.97 178.23,117.97 183.05,113.15 183.05,108.83 179.4,105.18 179.4,98.29 180.92,96.76 v4(183.3,96.76) 184.22,96.76 186.25,94.73 186.25,86.38 185.83,85.96 185.83,71.04 185.11,70.32 185.11,69.14 184.34,68.37 184.34,66.8 183.73,66.19 183.73,63.29 185.49,61.53 185.49,59.95 185.72,59.72 186.81,59.72 v2(187,59.53)
PCH_CPU_PCIBCLK_N: length 104.3
  IN1 w0.089: v2(176.35,119.88) 174.49,119.88 173.92,120.45 172.58,120.45 172.35,120.68 171.44,120.68 171.28,120.52 171.2,120.4 171.08,120.37 v2(170.84,120.53)
  IN3 w0.127: v2(192.18,40.76) 192.18,40.6 192.31,40.48 192.51,40.48 192.65,40.62 192.65,41.38 191.8,42.23 191.8,42.63 189.44,45 189.44,47.17 189.21,47.4 189.21,55.86 187.93,57.14 187.93,60.23 187.68,60.48 187.68,61.96 187.51,62.13 187.51,63.03 187.77,63.29 188.3,63.29 v2(188.38,63.37)
  BOTTOM w0.076: v2(170.84,120.53) 170.84,120.53 UC1.C36
  BOTTOM w0.107: v2(192.18,40.76) 192.79,40.15 192.79,39.88 193.62,39.06 193.98,39.06 194.24,38.8 UH1.B6 ; v2(176.35,119.88) 177.77,119.88 184.07,113.57 184.07,108.4 180.42,104.75 180.42,100.31 182.77,97.96 184.47,97.96 187.28,95.16 187.28,85.96 186.85,85.54 186.85,70.62 186.39,70.16 186.39,67.12 185.9,66.63 185.9,64.58 187.11,63.37 v2(188.38,63.37)
PCH_CPU_PCIBCLK_P: length 104.4
  IN1 w0.089: v2(176.35,119.33) 175.97,119.71 174.42,119.71 173.85,120.29 172.51,120.29 172.28,120.51 171.51,120.51 171.41,120.41 171.34,120.31 171.36,120.18 v2(171.61,120.02)
  IN3 w0.127: v2(188.36,62.79) 188.36,62.81 188.36,62.81 188.22,62.95 188.21,62.95 188.09,63.07 187.86,63.07 187.73,62.94 187.73,62.22 187.89,62.05 187.89,60.57 188.15,60.32 188.15,57.23 189.42,55.95 189.42,47.5 189.66,47.26 189.66,45.09 192.02,42.72 192.02,42.32 192.87,41.47 192.87,40.52 192.6,40.26 192.16,40.26 192.08,40.34 v2(191.77,40.34)
  BOTTOM w0.076: UC1.D35 171.14,120.02 v2(171.61,120.02)
  BOTTOM w0.107: v2(176.35,119.33) 176.52,119.5 176.52,119.53 176.67,119.68 177.68,119.68 183.87,113.49 183.87,108.49 180.22,104.84 180.22,100.23 182.68,97.76 184.38,97.76 187.07,95.07 187.07,86.04 186.65,85.62 186.65,70.7 186.19,70.24 186.19,67.21 185.7,66.71 185.7,64.49 187.02,63.17 188,63.17 188.36,62.81 188.36,62.81 v2(188.36,62.79) ; v2(191.77,40.34) 191.81,40.34 191.82,40.35 192.31,40.35 192.59,40.06 192.59,39.79 193.59,38.8 UH1.A6
PCH_DP3_CTRL_DATA: length 8.4
  BOTTOM w0.089: UH1.AR3 210.66,40.14 210.87,40.35 210.87,43.05 v1(210.66,43.25) 210.66,43.39 211.15,43.88
  BOTTOM w0.102: RH601.2 212.21,47.11 211.34,46.23 211.34,44.07 211.15,43.88
PCH_DP4_CTRL_DATA: length 1.9
  TOP w0.089: RH602.2 209.17,23.73 v2(209.94,22.96)
  BOTTOM w0.089: UH1.AN40 209.94,22.43 v2(209.94,22.96)
PCH_DPWROK: length 145
  TOP w0.114: v2(302.65,18.75) 303.01,18.75 304.64,20.38 304.64,22.52 305.73,23.61 UE5.127 ; v2(224.93,33.2) 225.18,33.46 225.83,33.46 v3(226.02,33.65)
  TOP w0.122: RH90.2 215.76,18.87 215.46,19.17 215.46,20.12 214.13,21.45 v2(213.11,21.45)
  IN3 w0.127: v2(224.93,33.2) 224.93,32.51 227.1,30.33 227.1,26.99 227.86,26.22 228.96,25.12 229.96,25.12 230.5,24.58 232.51,24.58 233.12,23.97 236.1,23.97 236.89,24.76 237.01,24.88 238.19,24.88 243.36,30.05 247.27,30.05 248.73,31.51 259.33,31.51 259.34,31.52 268.22,31.52 269.44,30.31 278.11,30.31 278.82,29.6 287.82,29.6 292.42,25.01 300.64,25.01 301.74,23.91 301.74,22.57 301.19,22.03 300.28,22.03 299.83,21.57 299.83,19.6 300.45,18.98 302.43,18.98 v2(302.65,18.75)
  IN6 w0.081: v2(213.11,21.45) 213.11,21.77 212.49,22.39 212.24,22.39 211.64,22.99 211.64,23.59 212.61,24.55 212.61,26.59 212.87,26.85 212.87,27.3 213.19,27.62 213.19,28.56 212.73,29.01 211.91,29.01 211.59,29.33 211.59,29.65 213.18,31.23 213.28,31.23 214.28,32.23 214.28,33.35 215.27,34.34 216.54,34.34 216.86,34.66 216.99,34.66 217.21,34.88 218.61,34.88 219.01,34.49 219.69,34.49 221.17,33.01 223.31,33.01 223.69,33.39 224.74,33.39 v2(224.93,33.2)
  BOTTOM w0.114: DE4.2 227.06,36.31 224.93,34.17 v2(224.93,33.2)
  BOTTOM w0.122: v2(213.11,21.45) 212.77,21.45 UH1.AW41
PCH_JTAG_TCK: length 287.4
  TOP w0.089: v2(130.87,114.35) v3(130.87,113.8) ; v2(206.13,41.65) 206.29,41.48 207.53,41.48 207.84,41.8 207.84,43.61 207.58,43.88
  TOP w0.114: JPCMC.32 120.24,161.94 120.56,162.26 121.82,162.26 122.5,161.58 122.77,161.58 125.36,158.99 125.36,158.68 v2(125.48,158.55) 125.67,158.36 RC35.1 ; 207.58,43.88 207.58,44.67 206.28,45.97 204.64,45.97 203.81,46.13 203.02,46.45 202.31,46.92 202.03,47.2 201.78,47.2 200.47,48.52 200.47,52.77 202.79,55.1 202.79,58.5 v2(203.91,59.62)
  IN1 w0.081: v2(125.48,158.55) 126.37,157.66 126.37,155.8 122.46,151.89 122.46,150.98 119.86,148.38 119.86,146.83 119.59,146.55 119.59,144.03 119.06,143.5 119.06,137.17 119.92,136.31 119.92,134.74 120.98,133.67 120.98,132.47 127.2,126.25 127.2,120.48 130.65,117.02 130.65,114.57 v2(130.87,114.35)
  IN3 w0.089: 129.44,104.6 129.7,104.86 129.7,105.3 130.47,106.07 130.47,113.96 v2(130.87,114.35)
  IN3 w0.127: 129.44,104.6 127.8,102.95 127.8,100.7 126.38,99.29 126.38,79.12 121.32,74.06 121.32,73.45 107.81,59.93 107.81,58.19 107.35,57.74 107.35,42.83 v2(107.52,42.66)
  IN6 w0.081: v2(203.91,59.62) 203.83,59.62 203.44,59.22 201.53,59.22 199.47,61.29 197.06,61.29 197.06,61.29 196.89,61.29 196.71,61.29 196.32,60.89 196.27,60.89 196.22,60.85 196.06,60.78 195.94,60.7 195.7,60.54 195.6,60.47 195.54,60.43 195.44,60.36 194.91,59.83 194.52,59.25 194.49,59.21 194.46,59.14 194.41,59.1 194.4,59.08 192.46,57.14 190.03,57.14 189.8,57.38 188.22,57.38 188.06,57.53 187.07,57.53 186.92,57.38 186.5,57.38 183.93,54.81 183.93,47.87 182.6,46.54 181.52,46.54 181.41,46.42 181.41,43.24 179.77,41.6 174.28,41.6 173.06,40.38 120.98,40.38 120.31,41.05 113.05,41.05 111.83,42.27 107.91,42.27 v2(107.52,42.66)
  BOTTOM w0.076: UC1.BR28 133.01,115.02 132.7,114.71 132.47,114.71 131.23,114.71 v2(130.87,114.35)
  BOTTOM w0.089: UH1.AH4 206.88,39.71 206.53,40.07 206.53,40.76 206.14,41.15 206.14,41.64 v2(206.13,41.65)
PCH_PECI: length 6.8
  BOTTOM w0.089: 207.39,43.88 207.42,43.86 207.89,43.86 207.91,43.88 ; UH1.AF2 206.26,40.78 205.77,41.27 205.77,42.6 205.69,42.68 205.69,43.58 205.75,43.64 205.75,43.88
  BOTTOM w0.114: RH73.1 208.24,44.12 208.16,44.12 207.91,43.88 ; 205.75,43.88 205.75,43.93 205.86,44.05 v1(206.73,44.05) 207.23,44.05 207.39,43.88
PCH_PLTRST#: length 260.6
  TOP w0.114: v2(200.1,125.69) 199.72,125.31 199.72,125.17 198.04,123.49 190,123.49 185.12,118.61 184.74,118.61 181.71,115.58 181.71,102.26 181.75,102.23 181.75,101.95 181.94,101.75 181.94,101.34 183.2,100.08 183.2,99.1 187.96,94.35 187.96,73.98 191.15,70.79 191.15,69.07 191.81,68.4 v1(191.81,67.68) 191.8,67.67 191.8,65.37 191.78,65.34 191.78,63.03 v2(191.35,62.6)
  IN1 w0.081: 193.69,44.3 193.35,44.65 191.75,44.65 190.23,46.17 190.23,46.97 189.9,47.29 189.9,48.72 191.33,50.15 191.33,52.58 191.21,52.7 v2(191.21,52.7) 191.21,53.52 190.91,53.82 190.91,57.01 190.56,57.36 190.56,61.63 190.68,61.76 191.35,62.42 v2(191.35,62.6) ; v2(200.1,125.69) 199.87,125.69 199.35,126.22 199.22,126.22 198.48,126.96 198.48,128.11 199.38,129 199.46,129 201.22,129 202.19,129.98 202.19,131.35 203.1,132.26 203.1,135.54 200.84,137.8 200.84,143.65 202.99,145.8 202.99,146.5 203.91,147.41 203.91,148.55 207.47,152.11 207.47,154.81 207.36,154.92 204.7,154.92 202.59,157.02 202.59,160.26 201.81,161.04 201.81,161.89 202.57,162.65 202.57,166.04 201.4,167.21 201.4,167.87 201.67,168.14 201.67,169.12 200.87,169.92 198.25,169.92 197.87,170.29 197.87,171.11 197.1,171.89 193.22,171.89 190.11,175 188.13,175 187.63,175.5 185.99,175.5 185.93,175.55 183.53,175.55 182.82,176.25 180.87,176.25 180.22,176.9 175.51,176.9 174.6,177.82 171.92,177.82 171.07,176.97 169.84,176.97 168.67,175.8 164.27,175.8 163.2,174.73 163.2,173.41 162.82,173.03 161.68,173.03 161.11,173.6 v2(160.73,173.6) ; 194.57,43.23 196.32,41.49 196.32,41.43
  IN1 w0.089: 193.69,44.3 194.45,43.55 194.45,43.36 194.57,43.23
  IN1 w0.097: 196.32,41.43 198.57,39.18 v2(198.57,39.04)
  IN2 w0.089: v2(218.39,39.55) 217.43,38.6 212.8,38.6 212.35,39.04 209.81,39.04 208.67,37.9 207.46,37.9 207.15,37.58 203.61,37.58 203.54,37.52 203.22,37.52 202.75,37.99 202.75,38.33 202.19,38.89 199.1,38.89 199.07,38.92 198.7,38.92 v2(198.57,39.04)
  IN6 w0.089: v2(218.39,39.55) 218.13,39.3 218,39.3 216.92,38.22 216.61,38.22 216.02,37.63 216.01,37.63 214.25,35.87 214,35.87 213.6,35.47 213.29,35.47 211.91,34.09 211.91,33.01 211.59,32.69 210.13,32.69 209.81,32.38 209.81,31.8 210.7,30.92 210.7,28.95 v2(211.21,28.44)
  BOTTOM w0.089: 219.18,39.6 219.05,39.47 218.83,39.47 218.75,39.55 v2(218.39,39.55)
  BOTTOM w0.114: UM3.2 160.47,173.78 160.58,173.66 160.67,173.66 v2(160.73,173.6) ; v2(200.1,125.69) 200.44,125.69 200.87,125.27 200.87,124.35 200.76,124.25 UG10.2 ; UG31.8 190.78,53.12 191.21,52.7 v2(191.21,52.7) ; UH3.2 UH3.1 219.56,39.98 219.18,39.6
  BOTTOM w0.122: v2(211.21,28.44) 211.27,28.38 211.27,27.86 UH1.AV29
PCH_PWR_EN: length 150.5
  TOP w0.114: v2(220.8,48.76) 221.02,48.98 221.02,49.62 221.24,49.84 223.66,49.84 224.34,49.15 C268.1 224.34,46.49 U18.4 225.58,46.52 v1(232.11,46.52) 232.3,46.52 232.99,45.84 232.99,37.84 233.72,37.11 236.17,37.11 238.26,35.01 238.26,32.9 239.07,32.09 239.07,30.52 238.96,30.41 238.96,28.31 239.66,27.61 239.66,24.87 239.08,24.28 239.08,22.15 238.58,21.64 v2(238.58,21.33) ; v2(311.35,19.63) 311.15,19.43 311.15,15.28 310.58,14.7 RE74.1 ; PR300.1 240.92,18.84 241.35,19.28 241.35,22.9 242.05,23.59 v2(242.8,23.59)
  IN6 w0.081: v2(311.35,19.63) 310.84,20.13 309.48,20.13 308.64,20.98 307.45,20.98 303.44,24.98 291.52,24.98 290.22,26.29 287.49,26.29 286.9,25.71 286.14,25.71 285.89,25.45 283.54,25.45 283.28,25.71 275.27,25.71 273.36,27.61 264.09,27.61 263.35,28.36 259.8,28.36 258.73,29.43 249.44,29.43 246.8,26.79 246.8,26.44 244.54,24.19 243.4,24.19 v2(242.8,23.59) 242.78,23.61 241.69,23.61 239.4,21.33 v2(238.58,21.33)
  BOTTOM w0.114: v2(220.8,48.76) 220.23,48.76 220.01,48.54 220,48.54 219.78,48.31 219.78,45.08 220.26,44.6 220.26,43.89 220.85,43.3 221.1,43.3 221.29,43.3 221.3,43.29 221.95,43.29 222.2,43.04 222.76,43.04 223,42.8 223,42.4 223.47,41.94 224.18,41.94 224.29,41.82 PR807.2
PCH_PWROK: length 120.1
  TOP w0.114: UE5.32 293.14,27.26 CE44.1 ; v2(224.54,34.79) 224.54,35.36 v3(224.99,35.8) ; CE44.1 RE75.1 ; CE44.1 293.37,27.28 293.76,27.68 v2(293.76,28.9)
  IN3 w0.127: v2(293.76,28.9) 293.76,29.18 288.16,34.77 283.93,34.77 283.16,35.54 277.92,35.54 277.23,36.23 273.43,36.23 266.64,43.02 251.58,43.02 250.29,41.72 250.29,40.05 246.21,35.97 243.5,35.97 242.8,35.27 240.26,35.27 238.86,33.87 235.63,33.87 235.24,34.27 234.31,34.27 233.38,33.34 230.76,33.34 229.97,34.13 228.35,34.13 227.75,33.52 226.51,33.52 226.07,33.96 226.07,35.24 225.69,35.61 224.86,35.61 224.54,35.3 v2(224.54,34.79)
  IN6 w0.081: 219.04,35.41 219.31,35.41 219.83,34.89 219.85,34.89 219.86,34.88 220.75,34.88 220.98,34.65 220.98,33.92 221.06,33.84 223.59,33.84 v2(224.54,34.79) ; 218.21,35.07 216.9,35.07 216.86,35.11 215.72,35.11 214.11,33.5 214.11,32.3 213.21,31.4 213.11,31.4 211.42,29.72 211.42,29.26 211.8,28.87 211.8,27.72 212.29,27.23 212.29,24.48 211.47,23.66 211.47,22.91 212.29,22.1 212.29,21.59 211.97,21.27 211.97,21.27 v2(211.98,21.27)
  IN6 w0.089: 218.21,35.07 218.33,35.18 218.41,35.18 218.63,35.41 219.04,35.41
  BOTTOM w0.114: v2(224.54,34.79) 223.64,35.69 DE3.2
  BOTTOM w0.122: v2(211.98,21.27) 211.97,21.27 211.97,21.27 212.56,21.27 UH1.AY42
PCH_RTCRST#: length 222.9
  TOP w0.114: v2(188.89,46.41) 188.55,46.41 183.51,41.37 v3(183.51,38.42) 183.51,37 180.92,34.41 180.92,32.57 176.21,27.86 v2(173.94,27.86) ; v2(286.08,26.85) 285.9,26.68 285.9,25.52 285.78,25.4 285.78,23.6 286.21,23.18 QE5.6 ; v2(216.86,15.18) 216.86,15.37 216.98,15.48 217.62,15.48 217.76,15.63 217.76,15.81 217.65,15.93 216.29,15.93 216.23,15.99 216.23,16.51 216.11,16.63 215.91,16.63 215.78,16.5 215.78,16.03 215.71,15.95 RH84.2 215.4,16.39 215.29,16.5 214.71,16.5 214.59,16.61 214.59,17.25 214.45,17.39 214.45,17.94 214.33,18.06 214.12,18.06 214,18.17 214,18.4 214.12,18.52 214.33,18.52 214.45,18.63 214.45,18.82 v2(214.58,18.95)
  IN1 w0.089: v2(208.94,22.36) 209.01,22.43 210.38,22.43 211.62,21.2 211.62,21.07 212.48,20.21 212.48,19.12 213,18.6 214.22,18.6 v2(214.58,18.95)
  IN4 w0.089: 194.28,44.89 195.26,43.91 196.34,43.91 198.84,41.42 200.34,41.42 200.68,41.07 202.75,41.07 203.01,40.81 204.22,40.81 204.46,40.58 209.8,40.58 210.99,39.38 211.83,39.38 212.11,39.11 213.73,39.11 214.56,38.28 218.58,38.28 218.89,37.96 219.18,37.96
  IN4 w0.127: 219.18,37.96 223.94,37.96 224.36,38.38 224.71,38.38 225.1,37.99 227.25,37.99 228.02,38.76 231.15,38.76 231.52,38.4 232.59,37.33 232.59,37.33 233.07,36.85 235.12,36.85 237.78,34.19 237.78,26.46 237.78,26.45 237.78,26.11 238.02,25.86 238.37,25.86 238.6,26.09 246,26.09 246.01,26.08 247.08,25.01 252.27,25.01 253.64,23.64 256.57,23.64 257.5,22.71 258.28,22.71 258.45,22.55 263.77,22.55 265.04,23.82 265.53,23.82 269.54,27.83 277.49,27.83 277.97,27.35 285.58,27.35 v2(286.08,26.85) ; v2(188.89,46.41) 189.21,46.41 190.49,45.13 194.04,45.13 194.28,44.89
  IN6 w0.081: v2(208.94,22.36) 208.65,22.64 206.12,22.64 205.28,23.48 203.79,23.48 202.45,24.82 201.98,24.82 200.37,26.43 199.9,26.43 198.9,27.44 196.94,27.44 196.67,27.17 196.62,27.17 196.61,27.17 192.41,27.17 191.84,27.74 191.84,29.27 190.67,30.44 190.39,30.44 190.27,30.56 189.64,30.56 189.52,30.44 185.33,30.44 184.14,29.25 182.35,29.25 180.79,27.68 174.13,27.68 173.96,27.86 v2(173.94,27.86)
  BOTTOM w0.089: UH1.BE47 215.32,18.6 214.96,18.6 214.7,18.85 214.67,18.85 v2(214.58,18.95)
  BOTTOM w0.114: v2(216.86,15.18) 216.86,15.75 216.98,15.87 218.83,15.87 219.53,15.17 219.99,15.17 220.1,15.05 220.1,14.47 219.73,14.09 219.11,14.09 218.99,14.21 218.99,14.61 218.88,14.72 218.65,14.72 218.54,14.61 218.54,14.21 218.42,14.09 218.19,14.09 218.08,14.21 218.08,14.61 217.96,14.72 217.74,14.72 217.62,14.61 217.62,14.21 217.51,14.09 217.02,14.09 CH53.1 ; CLRP1.1 v2(173.94,27.86)
PCH_RTCX1: length 5.7
  BOTTOM w0.089: UH1.BA49 213.25,17.45 213.25,17.25 213.17,17.16 213.17,16.96
  BOTTOM w0.114: YH1.1 211.52,13.5 CH45.1 212.43,14.71 212.28,14.86 RH70.1 213.17,16.18 213.17,16.96
PCH_RTCX2: length 5.9
  BOTTOM w0.114: 213.66,17.04 213.66,15.76 RH70.2 213.19,14.51 CH46.1 214.02,13.67 YH1.2
  BOTTOM w0.122: UH1.BA48 213.66,18.02 213.66,17.04
PCH_SATADET#: length 100.7
  TOP w0.102: RS8.1 124.53,15.93 125.04,16.44 v1(125.04,18.2) 125.04,19.43 126.31,20.7 v2(126.31,21.26)
  IN2 w0.089: 191.78,19.42 191.84,19.36
  IN2 w0.102: 191.78,19.42 191.56,19.64 191.3,19.64 189.6,21.34 187.69,21.34 187.25,21.77 181.93,21.77 181.77,21.92 169.27,21.92 168.82,21.48 144.58,21.48 142.92,23.13 128.18,23.13 v2(126.31,21.26) ; 191.84,19.36 v2(192.99,18.22)
  IN3 w0.089: 200.59,16.96 199.33,16.96 198.79,17.5 195.04,17.5 194.45,18.09 193.27,18.09
  IN3 w0.102: 200.59,16.96 201.14,16.41 201.62,16.41 201.9,16.69 202.95,16.69 203.78,15.87 205.89,15.87 206.06,15.7 v2(206.06,15.41) ; 193.27,18.09 193.11,18.09 v2(192.99,18.22)
  BOTTOM w0.102: v2(206.06,15.41) 206.06,14.99 206.76,14.28 207.2,14.28 RH512.1
  BOTTOM w0.122: RH512.1 207.53,14.61 207.53,15.12 207.53,15.12 207.53,15.47 207.53,15.47 207.53,17.49 207.84,17.8 207.84,18.09 207.8,18.14 UH1.AK48
PCH_SMBCLK: length 152.1
  TOP w0.089: 218.96,32.1 218.96,32.17 v2(218.75,32.38)
  TOP w0.114: RE659.1 187.15,5.76 186.99,5.76 186.39,5.16 185.45,5.16 184.57,6.05 184.57,12.96 182.5,15.03 180.07,15.03 179.83,15.27 179.83,16.18 v2(179.96,16.31) ; v2(180.81,29.1) 180.63,28.93 180.63,28.73 180.75,28.62 181.14,28.62 181.44,28.92 181.44,30.82 182.99,32.38 184.67,32.38 187.14,34.85 188.2,34.85 v2(188.31,34.97) ; 218.96,32.1 218.96,31.97 219.51,31.42 219.51,30.33 219.76,30.07 219.98,30.07 RH463.2 ; US1.4 185.74,64.95 185.99,64.7 186.23,64.7 186.41,64.52 186.41,63.23 182.14,58.96 182.14,57.75 181.2,56.81 178.86,56.81 v2(178.55,57.12)
  IN4 w0.089: 192.1,35.64 192.15,35.59 192.78,35.59 193.1,35.27 193.1,34.54 195.65,31.99 195.97,31.99 197.09,30.87 197.09,30.87 199.51,28.45 199.51,26.82 200.23,26.1 200.71,26.1 201.81,25 202.65,25 202.87,25.22 202.87,25.57 203.63,26.33 207.93,26.33 208.14,26.54 208.14,26.77 208.88,27.5 212.89,27.5 213.47,26.91 214.59,26.91 215.08,27.41 215.08,28.48 214.92,28.64 214.45,28.64 214.26,28.83 214.26,29.27 v2(214.04,29.48)
  IN4 w0.127: v2(188.31,34.97) 188.32,34.97 188.57,34.73 191.05,34.73 191.97,35.64 192.1,35.64
  IN6 w0.081: v2(214.04,29.48) 214.26,29.71 214.26,29.89 214.47,30.1 215.06,30.1 215.89,29.27 215.89,28.97 216.56,28.29 217.55,28.29 218.22,28.95 218.22,30.36 218.98,31.13 218.98,32.15 v2(218.75,32.38) ; v2(178.55,57.12) 178.76,56.9 179.17,56.9 180.67,55.4 180.67,49.37 179.21,47.91 179.21,47.65 179.29,47.57 179.44,47.57 v2(179.65,47.77)
  BOTTOM w0.089: UH1.BE26 214.75,29.08 214.45,29.08 v2(214.04,29.48)
  BOTTOM w0.114: JDIMM2.253 176.69,47.71 177.62,46.79 178.29,46.79 179.11,47.6 179.48,47.6 v2(179.65,47.77) 179.88,47.54 180.36,47.54 181.11,46.79 181.11,30.34 180.63,29.86 180.63,29.28 v2(180.81,29.1) 180.81,28.73 180.63,28.56 180.63,23.71 179.51,22.58 179.51,18.6 179.79,18.32 179.79,16.48 v2(179.96,16.31) ; JDIMM1.253 176.69,60.76 177.37,60.09 177.37,57.33 177.81,56.89 178.31,56.89 v2(178.55,57.12)
PCH_SMBDATA: length 155.5
  TOP w0.114: v2(219.34,32.38) 219.34,32.37 219.24,32.27 219.24,32.22 219.18,32.16 219.18,32.09 219.75,31.52 219.75,30.43 219.86,30.31 220.02,30.31 220.28,30.57 RH462.2 ; v2(179.38,16.31) 179.59,16.1 179.59,15.17 179.97,14.79 182.4,14.79 184.32,12.86 184.32,5.95 185.35,4.92 186.49,4.92 187.09,5.52 187.26,5.52 RE660.1 ; v2(178.55,56.54) 178.58,56.57 181.3,56.57 182.38,57.65 182.38,58.86 186.65,63.13 186.65,64.93 186.95,65.24 186.95,66.05 187.51,66.6 187.51,66.81 187.39,66.93 US1.6 ; v2(180.22,29.1) 180.39,28.93 180.39,28.63 180.65,28.38 181.24,28.38 181.68,28.82 181.68,30.72 183.09,32.13 184.77,32.13 187.24,34.61 188.07,34.61 v2(188.3,34.38)
  IN4 w0.089: 192.1,35.39 192.12,35.41 192.21,35.41 192.71,35.41 192.92,35.2 192.92,34.47 195.57,31.82 195.89,31.82 197.02,30.69 197.02,30.69 199.34,28.38 199.34,26.74 200.16,25.92 200.64,25.92 201.74,24.82 202.72,24.82 203.05,25.14 203.05,25.5 203.7,26.15 208,26.15 208.32,26.46 208.32,26.69 208.95,27.32 212.81,27.32 213.4,26.74 214.66,26.74 215.26,27.33 215.26,28.55 215,28.82 214.53,28.82 214.44,28.91 214.44,29.25 v2(214.66,29.46)
  IN4 w0.127: v2(188.3,34.38) 188.3,34.39 188.3,34.39 188.3,34.42 188.35,34.47 191.16,34.47 192.07,35.39 192.1,35.39
  IN6 w0.081: v2(178.55,56.54) 178.7,56.7 179.08,56.7 180.46,55.32 180.46,49.46 179,48 179,47.56 179.2,47.36 179.47,47.36 v2(179.65,47.19) ; v2(219.34,32.38) 219.15,32.19 219.15,31.06 218.39,30.29 218.39,28.88 217.62,28.12 216.49,28.12 215.72,28.9 215.72,29.2 214.99,29.93 214.54,29.93 214.43,29.82 214.43,29.71 214.66,29.48 v2(214.66,29.46)
  BOTTOM w0.089: v2(214.66,29.46) 214.68,29.46 215.19,28.96 215.58,28.96 UH1.BF26
  BOTTOM w0.114: JDIMM1.254 176.94,55.01 177.45,55.52 177.45,56.34 177.76,56.65 178.44,56.65 v2(178.55,56.54) ; JDIMM2.254 176.94,41.98 176.95,41.98 176.95,42.29 177.32,42.67 177.32,45.01 177.6,45.28 177.6,46.43 177.71,46.55 178.39,46.55 179.17,47.33 179.51,47.33 v2(179.65,47.19) 179.76,47.3 180.26,47.3 180.87,46.69 180.87,30.44 180.39,29.96 180.39,29.26 v2(180.22,29.1) 180.22,28.73 180.39,28.56 180.39,23.81 179.27,22.68 179.27,18.5 179.55,18.22 179.55,16.48 v2(179.38,16.31)
PCH_SML1ALERT#: length 5.5
  BOTTOM w0.089: UH1.BD33 215.08,25.38 215.34,25.64 215.97,25.64 216.12,25.49 216.12,25.43 216.29,25.27 216.66,25.27 216.67,25.25 216.98,25.25 216.99,25.27 217.07,25.34 218.2,25.34 218.3,25.24 219.18,25.24
  BOTTOM w0.102: RH63.2 219.48,25.4 219.32,25.24 219.18,25.24
PCH_SPI_0_CLK: length 20.5
  IN6 w0.081: v2(224.59,19.4) 224.54,19.36 223.53,19.36 222.94,19.95 222.51,19.95 222.39,20.06 220.41,20.06 219.92,19.57 219.31,19.57 219.18,19.44
  IN6 w0.089: v2(210.75,17.58) 211.57,18.4 214.07,18.4 214.62,17.85 215.76,17.85 216.76,18.85 218.13,18.85 218.53,19.24 218.98,19.24 219.18,19.44
  BOTTOM w0.089: v2(210.75,17.58) 211,17.33 211.3,17.33 211.95,17.97 211.95,18.44 212.34,18.84 UH1.AW47
  BOTTOM w0.114: v2(224.59,19.4) 225.03,19.84 225.03,20.85 RH104.1
PCH_SPI_0_CLK_R: length 7.8
  BOTTOM w0.114: UH4.6 224.6,18.46 223.91,19.16 223.91,20.6 RH591.1 224.21,21.92 RH104.2
PCH_SPI_0_CS#: length 26.3
  IN3 w0.089: v2(212.85,19.33) 212.88,19.3 213.23,19.3 213.95,18.58 214.73,18.58 215.24,19.1 216.1,19.1 216.35,19.35 217.53,19.35 217.62,19.26 217.62,19.07 217.71,18.98 217.89,18.98 217.98,19.07 217.98,19.33 218.07,19.41 218.24,19.41 218.33,19.33 218.33,19.07 218.42,18.98 218.6,18.98 218.69,19.07 218.69,19.18 218.78,19.27 219.01,19.27 219.18,19.1
  IN3 w0.127: v2(223.34,17.23) 223.04,17.53 220.75,17.53 219.18,19.1
  BOTTOM w0.089: UH1.AY47 v2(212.85,19.33)
  BOTTOM w0.114: v2(223.34,17.23) 223.73,17.23 224.11,16.85 224.11,15.22 224,15.1 223.5,15.1 223.39,15.22 223.39,16.07 223.27,16.18 223.05,16.18 222.93,16.07 222.93,15.22 222.82,15.1 222.23,15.1 222.12,15.22 222.12,16.57 222,16.68 221.78,16.68 221.66,16.57 221.66,14.9 221.55,14.79 221.32,14.79 221.2,14.9 221.2,15.81 221.09,15.92 UH4.1
PCH_SPI_0_HOLD#: length 20.2
  TOP w0.089: 219.18,23.94 219.16,23.94 v2(219.08,23.87)
  TOP w0.114: v1(220.04,22.71) 220.04,23.58 RH78.2 219.68,23.94 219.18,23.94
  IN4 w0.089: v2(219.08,23.87) 219.08,23.68 218.51,23.1 218.51,21.5 217.88,20.87 217.37,20.87 216.9,20.4 216.9,19.41 215.32,17.83 213.52,17.83 213.01,17.33 212.37,17.33 v2(212.07,17.03)
  BOTTOM w0.089: 212,16.96 v2(212.07,17.03)
  BOTTOM w0.114: RPH5.4 210.12,14.38 211.02,15.28 211.02,15.66 211.08,15.72 211.08,15.85 211.23,16.01 211.23,16.28 211.45,16.5 211.45,16.5 211.53,16.58 211.53,16.58 211.68,16.72 211.76,16.72 212,16.96
  BOTTOM w0.122: v2(212.07,17.03) 212.65,17.61 212.94,17.61 213.32,17.98 213.32,18.8 213.54,19.02 UH1.BA46
PCH_SPI_0_HOLD#_R: length 29.8
  TOP w0.102: v2(222.9,19.31) 222.9,15.87 221.69,14.66 221.69,10.91 221.56,10.79 220.93,10.79 220.72,10.58 218.58,10.58 218,11.16 218,11.31 217.45,11.87 212.24,11.87 v1(211.28,12.83) v2(210.62,13.49)
  BOTTOM w0.114: v2(210.62,13.49) 210.79,13.32 210.79,12.22 210.68,12.11 210.23,12.11 210.12,12.22 RPH5.5 ; v2(222.9,19.31) 222.9,18.97 223.91,17.96 226.07,17.96 226.84,17.19 UH4.7
PCH_SPI_0_SI: length 34.2
  TOP w0.089: v1(210.89,16.96) 211.79,17.85 211.79,19.22 211.78,19.22 211.78,19.38 212.03,19.63 212.03,20.63 210.94,21.72 210.94,23.13 211.12,23.3 v2(211.12,23.31)
  TOP w0.114: v2(210.57,16.28) 210.57,16.64 v1(210.89,16.96)
  IN3 w0.089: 219.18,23.3 218.25,23.3 218.04,23.5 216.81,23.5 216.04,22.72 212.98,22.72 212.15,23.55 211.37,23.55 211.12,23.31 v2(211.12,23.31)
  IN3 w0.127: v2(225.26,26.74) 225.26,23.47 224.91,23.13 223.94,23.13 223.5,23.56 221.15,23.56 220.89,23.3 219.18,23.3
  BOTTOM w0.089: v2(211.12,23.31) 211.12,23.31 211.12,22.9 210.73,22.51 210.72,22.51 210.56,22.34 210.56,22.1 210.57,22.08 210.57,22.06 210.7,21.94 210.71,21.94 211.16,21.49 UH1.AU41
  BOTTOM w0.114: RPH5.2 209.12,14.79 210.57,16.24 v2(210.57,16.28) ; RH1.2 224.62,26.03 224.62,26.04 225.26,26.67 v2(225.26,26.74)
PCH_SPI_0_SI_R: length 33.6
  TOP w0.114: v2(208.62,11.83) 208.64,11.85 208.64,13.14 209,13.49 210.02,13.49 211.18,14.66 211.18,16.87 211.98,17.66 211.98,19.3
  TOP w0.122: v2(212.37,20.83) 212.23,20.68 212.23,19.55 211.98,19.3
  IN4 w0.127: v2(221.44,25.51) 221.19,25.26 217.63,25.26 217.12,24.76 216.77,24.76 214.43,22.42 213.51,22.42 212.67,21.58 212.67,21.13 v2(212.37,20.83)
  BOTTOM w0.114: v2(208.62,11.83) 209.12,12.33 RPH5.7 ; UH4.5 226.51,19.73 226.4,19.85 226.4,21.21 224.81,22.8 224.81,23.81 RH489.1 224.37,24.54 224.1,24.81 223.86,24.81 223.17,25.49 v1(223.02,25.49) 221.46,25.49 v2(221.44,25.51)
PCH_SPI_0_SO: length 7.4
  BOTTOM w0.114: RPH5.3 209.62,14.6 v1(210.35,15.34) 210.84,15.82 210.84,15.95 210.99,16.11 210.99,16.38 211.21,16.6 211.21,16.6 211.62,17.01 211.62,17.11
  BOTTOM w0.122: 211.62,17.11 212.32,17.82 212.85,17.82 213.11,18.07 213.11,18.88 213.26,19.04 213.26,19.21 213.26,19.21 UH1.BA45
PCH_SPI_0_SO_R: length 19.4
  IN4 w0.127: v2(221.88,17.11) 221.88,15.04 220.42,13.58 217.91,13.58 215.53,11.2 209.88,11.2 v2(209.25,11.83)
  BOTTOM w0.114: v2(209.25,11.83) 209.62,12.19 RPH5.6 ; UH4.2 221.36,17.19 221.42,17.14 221.88,17.14 v2(221.88,17.11)
PCH_SPI_0_WP#: length 289.9
  TOP w0.089: v2(216.92,24.37) 217.38,24.37 217.83,23.93 218.07,23.93 v1(218.89,24.76) 219.18,24.76
  TOP w0.114: RH75.2 219.75,24.76 219.18,24.76 ; v2(128.61,161.61) 129.24,162.25 RC354.2
  IN1 w0.081: v2(216.92,24.37) 215.4,24.37 214.36,25.42 212.96,25.42 212.23,26.15 212.23,27.11 211.59,27.74 211.59,29.71 211.97,30.09 211.97,30.79 211.59,31.17 208.86,31.17 208.29,31.74 208.29,32.19 207.82,32.66 207.24,32.66 206.72,33.18 205.83,33.18 205.16,33.86 202.04,33.86 201.75,34.16 201.75,34.73 200.61,35.87 200.61,37.01 199.59,38.03 199.59,38.52 198.93,39.18 198.93,39.19 198.72,39.4 198.71,39.4 195.08,43.03 ; v2(190.95,58.21) 190.95,58.21 190.95,58.25 191.29,57.9 191.29,54.05 191.71,53.63 191.71,49.9 190.8,48.99 190.8,46.15 191.91,45.03 193.6,45.03 194.01,44.62
  IN1 w0.089: 194.01,44.62 194.89,43.74 194.89,43.22 195.08,43.03
  IN4 w0.089: v2(216.92,24.37) 215.07,22.52 215.07,21.53 214.74,21.2 214.3,21.2 213.52,20.42 213.51,20.42 213.17,20.08 213.17,19.6 213.27,19.5 213.27,19.18 211.05,16.96
  IN4 w0.127: v2(209.3,16.16) 209.92,16.78 210.87,16.78 211.05,16.96
  IN6 w0.081: v2(128.61,161.61) 128.61,161.66 127.47,162.8 117.04,162.8 113.73,159.5 113.73,72.56 108.85,67.68 108.85,56.82 111.51,54.16 135.95,54.16 136.86,53.24 147.8,53.24 148.05,53 169.28,53 170.71,54.43 178.08,54.43 178.44,54.79 178.44,55.55 178.14,55.85 178.14,57.92 179.17,58.94 181.64,58.94 184.12,61.42 188.14,61.42 188.34,61.62 188.86,61.62 189.06,61.42 190.19,60.29 190.19,58.96 190.95,58.21 v2(190.95,58.21)
  BOTTOM w0.089: 211.37,17.11 211.42,17.15 211.42,17.19 212.24,18.01 212.4,18.01 212.72,18.01 212.85,18.14 UH1.AY48
  BOTTOM w0.114: RPH5.1 208.62,14.96 209.3,15.65 v2(209.3,16.16) 209.32,16.21 210.49,16.69 210.96,16.69 211.37,17.11
PCH_SPI_0_WP#_R: length 22.2
  IN6 w0.081: v2(208.78,16.5) 208.78,16.13 209.25,15.65 211.89,15.65 212.23,16 212.24,16 212.76,16 213.12,16.36 215.09,16.36 215.11,16.37 218.22,16.37 218.67,15.93 219.52,15.93 220.31,16.71 222.28,16.71 222.49,17.01 v2(222.49,17.07)
  BOTTOM w0.114: v2(208.78,16.5) 208.78,15.73 v1(208.5,15.46) 208.27,15.22 208.27,13.57 208.62,13.22 RPH5.8 ; UH4.3 221.18,18.46 222.49,17.15 v2(222.49,17.07)
PCH_SRTCRST#: length 93.3
  TOP w0.089: v2(214.78,19.45) 214.75,19.49 213.85,19.49 213.52,19.15 RH83.2
  TOP w0.114: v2(287.13,24.41) 287.2,24.48 QE5.3
  IN3 w0.089: 219.18,19.91 219.06,20.03 218.28,20.03 217.78,19.53 217.18,19.53 216.87,19.84 215.57,19.84 215.19,19.45 v2(214.78,19.45)
  IN3 w0.127: 219.18,19.91 219.35,19.74 220.63,19.74 221.11,20.22 222.62,20.22 222.78,20.06 223.53,19.31 223.53,18.68 224.77,17.44 v2(225.32,17.44) 225.55,17.44 226.12,18.01 230.87,18.01 231.19,17.69 232.49,17.69 233.25,16.93 234.81,16.93 235.33,16.93 238.09,19.69 238.26,19.69 238.79,19.69 239.16,20.06 239.89,20.78 239.89,22.17 241.07,23.36 241.07,23.47 241.69,24.09 241.81,24.09 243.02,25.3 247.06,25.3 247.62,25.86 249,27.24 251.25,27.24 252.51,28.5 257.31,28.5 257.95,27.87 260.36,27.87 262.06,26.17 263.91,26.17 264.58,25.5 266.13,25.5 267.81,27.19 268.34,27.19 268.4,27.19 268.4,27.19 272.39,27.19 273.72,25.86 275.24,25.86 275.8,25.31 282.68,25.31 282.86,25.48 284.49,25.48 284.94,25.02 285.5,25.02 285.91,24.62 286.92,24.62 v2(287.13,24.41)
  BOTTOM w0.114: v2(225.32,17.44) 225.32,16.55 227.17,14.7 228.32,14.7 CH52.1
  BOTTOM w0.122: v2(214.78,19.45) 214.83,19.36 214.87,19.35 215.06,18.96 UH1.BD46
PCH_SYS_PWROK_XDP: length 1.3
  BOTTOM w0.114: RH489.2 RH493.2
PCH_TRIGGER: length 5.2
  BOTTOM w0.089: UH1.AK3 208.06,40.07 208.06,40.82 208.18,40.93 208.18,42.74 208.29,42.85 v1(208.29,43.3) 208.71,43.72 208.83,43.72 208.99,43.88
  BOTTOM w0.114: 208.99,43.88 209.51,44.4 RH167.1
PCH_XDP_CLK_N: length 2.6
  TOP w0.107: v2(203.77,39.64) 203.53,39.39 203.53,38.63 T49.1
  BOTTOM w0.107: v2(203.77,39.64) 203.77,39.81 203.37,40.21 UH1.Y3
PCH_XDP_CLK_P: length 1.5
  TOP w0.107: T50.1 202.95,39.65 v2(202.95,39.01)
  BOTTOM w0.107: UH1.Y4 203.2,39.66 203.2,39.26 v2(202.95,39.01)
PCIE_GEN3#_GEN2: length 44.3
  TOP w0.102: UE6.11 335.35,45.33 335.43,45.25 ; UE1.28 317.79,18.71 318.39,18.12 v2(318.39,16.42) ; v2(329.82,34.22) 329.87,34.16 330.6,34.16 v1(331.1,34.66)
  TOP w0.107: 335.43,45.25 336.18,44.5 336.18,39.42 331.52,34.76 331.2,34.76 v1(331.1,34.66)
  IN3 w0.102: v2(329.82,34.22) 329.82,33.01 328.88,32.07 328.88,31.46 327.69,30.28 327.69,24.04 323.92,20.27 323.92,19.52 322.74,18.34 320.85,18.34 318.93,16.42 v2(318.39,16.42)
PCIE_PRX_C_DTX_N15: length 1.5
  BOTTOM w0.107: CL2.1 268.92,164.94 269.4,164.94 269.5,164.84 UL1.29
PCIE_PRX_C_DTX_P15: length 1.4
  BOTTOM w0.107: CL1.1 268.86,165.17 269.46,165.17 269.52,165.24 UL1.30
PCIE_PRX_DTX_N9: length 73.1
  IN6 w0.089: v2(245.25,12.9) 245.37,13.02 245.37,13.3 245.22,13.45 244.69,13.45 244.08,14.07 241.12,14.07 239.33,15.86 236.87,15.86 236.46,16.27 231.51,16.27 230.42,15.17 221.4,15.17 220.77,14.54 208.79,14.54 206.83,16.5 206.57,16.5 205.94,16.5 205.1,17.34 205.1,18.59 205,18.69 203.33,18.69 203,19.02 201.6,19.02 200.34,20.27 199.12,20.27 198.24,21.15 198.24,21.75 197.79,22.2 197.79,22.76 197.79,22.76 197.79,23.06 197.56,23.3 197.34,23.3 197.14,23.5 197.14,23.87 196.97,24.06 196.83,24.08 196.68,23.99 196.64,23.77 v2(196.73,23.61)
  BOTTOM w0.107: v2(196.73,23.61) 196.93,23.81 UH1.G36 ; v2(245.25,12.9) 245.25,9.92 246.11,9.06 249.42,9.06 249.93,9.57 250.82,9.57 252.29,11.04 252.29,12.78 253.02,13.51 JSSD3.5
PCIE_PRX_DTX_N10: length 64.6
  IN6 w0.089: v2(198.26,24.16) 198.19,24.09 198.19,23.39 198.3,23.28 198.3,22.81 198.73,22.38 202.32,22.38 203.15,21.56 204.22,21.56 205.19,20.59 205.19,19.6 205.87,18.92 205.87,17.63 206.21,17.29 206.49,17.29 206.5,17.29 207.07,17.29 209.09,15.26 212.05,15.26 212.39,15.61 212.92,15.61 213.28,15.97 215.26,15.97 215.27,15.98 218.06,15.98 218.5,15.54 219.68,15.54 220.05,15.9 230.12,15.9 231.23,17 239.92,17 242.13,14.79 244.42,14.79 244.81,14.41 247.02,14.41 247.21,14.22 247.21,13.64 247.3,13.55 247.57,13.55 247.65,13.64 247.65,14.21 247.85,14.41 248.87,14.41 249.23,14.04 249.23,13.14 v2(249.45,12.92)
  BOTTOM w0.107: UH1.K37 198.31,24.1 v2(198.26,24.16) ; JSSD3.17 250.02,14.1 249.87,13.95 249.87,13.72 249.65,13.5 249.36,13.5 249.25,13.4 249.25,13.12 249.45,12.92 249.45,12.92 v2(249.45,12.92)
PCIE_PRX_DTX_N11: length 65.1
  IN6 w0.089: v2(247.04,12.92) 246.83,12.71 246.83,12.46 246.65,12.27 240.8,12.27 238.33,14.74 231.59,14.74 230.9,14.06 221.86,14.06 221.15,13.34 215.71,13.34 215.22,12.86 214.01,12.86 213.82,13.04 213.82,13.24 213.73,13.33 213.55,13.33 213.47,13.24 213.47,13.04 213.28,12.86 212.97,12.86 212.78,13.04 212.78,13.33 212.69,13.41 212.51,13.41 212.42,13.33 212.42,13.04 212.24,12.86 211.92,12.86 211.74,13.04 211.74,13.33 211.65,13.41 211.47,13.41 211.38,13.33 211.38,13.04 211.2,12.86 210.42,12.86 209.85,13.42 208.33,13.42 207.54,14.21 205.56,14.21 205.05,14.72 203.78,14.72 203.23,15.27 201.98,15.27 201.24,16.02 198.31,16.02 196.5,17.83 196.5,20.75 196,21.26 196,22.28 196.54,22.83 196.54,22.98 v2(196.48,23.04)
  BOTTOM w0.107: v2(196.48,23.04) 196.88,22.99 UH1.G38 ; v2(247.04,12.92) 246.88,13.07 246.88,13.69 247.02,13.83 JSSD3.29
PCIE_PRX_DTX_N12: length 64.8
  IN6 w0.089: v2(242.78,12.88) 242.8,12.88 243.2,13.28 243.2,13.4 243.09,13.51 240.89,13.51 239.1,15.3 231.36,15.3 230.67,14.61 221.63,14.61 221,13.98 208.56,13.98 206.61,15.93 204.93,15.93 204.75,16.11 204.75,16.79 204.66,16.88 204.39,16.88 204.3,16.79 204.3,16.01 204.12,15.83 203.55,15.83 203.36,16.01 203.36,18.02 202.99,18.39 200.6,18.39 200.42,18.58 200.42,19.36 200.33,19.45 200.06,19.45 199.97,19.36 199.97,18.07 199.79,17.89 199.38,17.89 199.2,18.07 199.2,19.49 199.11,19.57 198.84,19.57 198.75,19.49 198.75,18.45 198.52,18.22 197.3,18.22 197.09,18.42 197.09,20.57 197.53,21.01 197.53,21.37 197.37,21.53 197.19,21.53 v2(196.99,21.33)
  BOTTOM w0.107: v2(196.99,21.33) 197.17,21.14 UH1.H42 ; JSSD3.43 243.53,14.16 243.73,13.96 243.73,13.72 243.6,13.59 243.35,13.59 243.12,13.37 243.12,13.21 242.79,12.88 v2(242.78,12.88)
PCIE_PRX_DTX_N15: length 228.5
  IN1 w0.089: v2(187,29.82) 186.8,29.62 186.8,29.5 187.41,28.88 188.9,28.88 189.49,28.29 189.49,27.44 189.41,27.36 189.41,24.46 191.42,22.44 193.39,22.44 195.31,20.53 195.44,20.53 v2(195.59,20.68)
  IN3 w0.127: v2(267.04,164.75) 267.04,164.8 266.9,164.93 266.67,164.93 266.61,164.87 266.61,162.25 262.06,157.7 237.26,157.7 236.28,158.68 232.04,158.68 231.25,157.89 223.24,157.89 222,156.65 216.23,156.65 215.49,155.91 211.17,155.91 209.35,154.09 209.35,151.44 208.38,150.47 208.38,150.07 207.24,148.94 207.24,145.85 209.09,144 209.09,134.1 209.02,134.03 209.02,132.16 209.37,131.82 209.93,131.82 211.08,130.68 211.08,129.64 209.47,128.03 209.47,124.58 208.6,123.71 206.93,123.71 205.62,122.41 205.62,121.36 205.39,121.13 205.39,120.96 203.05,118.61 203.05,113.44 199.73,110.12 199.73,109.25 198.97,108.49 194.37,108.49 193.54,109.31 191.67,109.31 191.04,108.69 191.04,107.59 188.47,105.02 187.71,104.26 187.71,100.48 188.1,100.1 188.1,89.28 187.14,88.32 186.77,87.95 186.77,70.99 186.42,70.64 186.42,69.38 185.68,68.64 185.68,64.32 186.09,63.91 186.09,61.49 185.05,60.45 185.05,59.32 184.79,59.06 184.79,55.58 185.12,55.24 185.12,54.9 185.99,54.04 185.99,52.69 186.67,52.01 186.67,40.6 187.19,40.08 187.19,39.79 187.57,39.41 187.57,36.37 187.65,36.3 187.65,32.9 186.75,32.01 186.75,30.08 186.84,30 186.84,29.99 v2(187,29.82)
  BOTTOM w0.107: v2(267.04,164.75) 267.18,164.89 267.34,164.89 CL2.2 ; UH1.F44 195.96,20.31 195.59,20.68 v2(195.59,20.68)
PCIE_PRX_DTX_N16: length 167.6
  TOP w0.102: v2(199.24,46.78) 199.07,46.95 198.54,46.95 197.65,46.05 196.76,46.05 196.55,45.84 196.53,45.84 196.39,45.7 ; 192.09,37.55 191.75,37.88 191.75,39.35 192.82,40.41 192.82,40.6 192.82,41.94 191.31,43.45 191.31,44.37 192.65,45.71 195.01,45.71 195.05,45.66
  TOP w0.107: 196.39,45.7 196.33,45.64 196.26,45.64 196.26,45.64 195.15,45.64 195.15,45.64 195.08,45.64 195.05,45.66 ; 192.09,37.55 192.13,37.55 193.22,36.46 193.22,36.46 194.78,34.9 194.78,30.58 195.31,30.05 195.87,30.05 196.16,29.76 196.16,29.52 196.33,29.35 196.33,29.36 v2(196.36,29.36)
  IN4 w0.127: v2(196.36,29.36) 196.2,29.2 196.2,29.11 196.1,29.01 196.1,27.49 194.76,26.15 194.76,23.17 195.51,22.42 195.6,22.42 196,22.42 196.38,22.04 196.38,21.4 196.83,20.95 197.37,20.95 197.92,21.5 197.92,23.22 198.16,23.46 198.16,23.46 198.22,23.52 198.6,23.52 198.76,23.69 v2(198.79,23.69)
  IN6 w0.102: v2(199.24,46.78) 199.41,46.96 199.89,46.96 200.52,47.6 201.65,47.6 203.01,46.24 210.22,46.24 210.87,46.89 213.74,46.89 214.66,45.97 215.33,45.97 215.41,46.05 228.39,46.05 229.5,44.95 232.55,44.95 232.95,45.36 238.63,45.36 240.31,43.68 265.26,43.68 273.47,35.46 277.27,35.46 277.59,35.14 283.26,35.14 283.74,34.67 286.16,34.67 287.99,36.5 294.04,36.5 294.67,35.87 306.78,35.87 308.48,37.57 310.53,37.57 310.7,37.4 310.7,37.39 v2(310.88,37.21)
  BOTTOM w0.107: v2(310.88,37.21) 310.71,37.38 310.44,37.38 310.33,37.27 310.33,36.82 310.63,36.52 310.63,36.21 310.82,36.01 JWLAN.35 ; UH1.L41 198.84,21.7 198.83,21.85 198.48,22.2 198.48,22.21 198.48,22.37 198.17,22.69 198.17,23.15 198.38,23.36 198.47,23.36 198.55,23.44 198.65,23.44 198.79,23.58 v2(198.79,23.69)
PCIE_PRX_DTX_N17: length 155.1
  IN1 w0.089: v2(327.86,39.68) 327.22,40.31 326.55,40.31 325.89,39.65 324.11,39.65 323.62,39.17 323.62,37.46 324.55,36.53 324.87,36.53 325.15,36.24 325.15,35.48 323.38,33.71 311.43,33.71 309.49,31.77 305.26,31.77 304.32,32.71 298.77,32.71 298.4,33.07 295.38,33.07 294.73,32.43 292.7,32.43 289.51,29.24 284.02,29.24 282.96,28.18 278.8,28.18 277.9,29.09 267.06,29.09 266.4,29.75 264.32,29.75 263.9,29.32 248.74,29.32 245.75,26.33 243.75,26.33 240.82,23.4 240.82,22.2 240.24,21.62 240.24,21.25 239.03,20.04 238.21,20.04 235.73,17.56 231.11,17.56 230.81,17.86 226.23,17.86 225.95,18.14 224.05,18.14 223.72,18.47 222.7,18.47 222.48,18.25 220.42,18.25 219.61,19.06 218.55,19.06 218.26,18.77 215.9,18.77 214.98,17.85 214.66,17.85 214.4,18.11 212.98,18.11 212.12,18.97 212.12,20.06 211.58,20.6 210.75,20.6 210.14,21.22 209.21,21.22 209.2,21.21 208.61,21.21 206.54,19.14 206.54,19.04 206.33,18.83 201.64,18.83 200.54,19.93 198.55,19.93 198.37,20.11 198.37,20.23 v2(198.45,20.31)
  BOTTOM w0.107: v2(327.86,39.68) 327.86,39.62 327.35,39.11 326.97,39.11 326.66,39.41 JSSD1.43 ; v2(198.45,20.31) 198.3,20.45 UH1.K43
PCIE_PRX_DTX_N18: length 162
  IN1 w0.089: v2(329.19,41.41) 329.19,41.33 329.09,41.23 329.03,41.23 328.79,40.99 328.75,40.99 328.41,40.65 328.41,39.16 327.47,38.22 327.47,36.21 323.77,32.52 311.87,32.52 309.14,29.78 305.21,29.78 303.46,31.54 300.05,31.54 299.51,31 299.51,30.73 299.16,30.38 292.23,30.38 289.97,28.11 284.64,28.11 283.43,26.9 278.45,26.9 277.38,27.97 265.68,27.97 264.98,27.27 257.51,27.27 257.22,26.98 247.98,26.98 246.21,25.21 245.09,25.21 242.41,22.53 242.41,21.92 241.36,20.87 241.36,20.78 239.49,18.92 238.67,18.92 236.2,16.44 231.27,16.44 230.8,15.98 221.69,15.98 221.37,16.3 219.9,16.3 219.6,16 218.81,16 218.51,16.3 216.42,16.3 216.3,16.42 214.74,16.42 214.36,16.04 212.69,16.04 212.05,16.67 211.92,16.67 211.52,17.07 208.54,17.07 207.69,16.22 203.37,16.22 202.93,15.78 200.98,15.78 200.65,16.12 198.89,16.12 198.07,16.95 198.07,18.98 197.11,19.93 197.11,20.69 197.9,21.48 200.34,21.48 200.61,21.21 200.61,21.2 v2(200.58,21.2)
  BOTTOM w0.107: JSSD1.29 326.56,42.91 326.7,42.76 327.98,42.76 328.48,42.26 328.48,41.56 328.82,41.21 329,41.21 329.19,41.4 v2(329.19,41.41) ; UH1.P41 200.29,21.49 v2(200.58,21.2)
PCIE_PRX_DTX_N19: length 160.8
  IN1 w0.089: v2(324.22,38.32) 324.32,38.22 324.79,38.22 325.89,37.12 325.89,35.19 323.61,32.91 311.65,32.91 308.99,30.24 305.31,30.24 303.62,31.94 299.47,31.94 299.12,31.59 292.89,31.59 289.81,28.51 284.33,28.51 283.12,27.3 278.61,27.3 277.54,28.37 265.52,28.37 265.29,28.13 264.4,28.13 264.33,28.2 260.33,28.2 259.94,27.82 257.49,27.82 257.27,28.03 252.32,28.03 251.75,27.46 251.51,27.46 251.42,27.37 247.82,27.37 246.05,25.61 244.05,25.61 241.54,23.1 241.54,21.9 240.97,21.32 240.97,20.95 239.33,19.31 238.51,19.31 236.04,16.84 231.1,16.84 230.64,16.37 224.79,16.37 223.5,17.67 222.93,17.67 222.78,17.52 219.6,17.52 219.29,17.83 218.59,17.83 218.42,18.01 216.84,18.01 215.92,17.08 214.42,17.08 214.12,17.39 212.91,17.39 212.56,17.39 211.44,18.51 211.44,18.95 211.09,19.3 211.09,19.31 210.88,19.52 210.33,19.52 209.72,18.91 209.12,18.91 208.81,18.6 207.51,18.6 206.99,18.08 206.99,17.55 206.16,16.72 202.01,16.72 201.54,16.25 201.07,16.25 200.69,16.63 199.87,16.63 199.62,16.89 199.62,17.31 v2(199.56,17.37)
  BOTTOM w0.089: 199.31,19.18 199.3,19.16 199.05,18.92 199.05,18.51 199.07,18.49 199.07,18.11 199.09,18.1 199.09,17.97 199.32,17.74 199.33,17.74 199.33,17.74 199.7,17.74 199.77,17.68 199.77,17.58 v2(199.56,17.37)
  BOTTOM w0.107: 199.31,19.18 199.62,19.49 199.62,19.54 199.83,19.75 199.83,20.16 199.74,20.25 199.55,20.25 UH1.M44 ; v2(324.22,38.32) 324.32,38.22 324.57,38.22 324.67,38.33 324.67,39.21 323.85,40.04 323.85,45.29 324.3,45.75 324.31,45.75 324.4,45.84 325.13,45.84 325.2,45.91 JSSD1.17
PCIE_PRX_DTX_N20: length 168.5
  IN1 w0.089: v2(200.17,24.48) 200.17,24.27 200.26,24.18 202.2,24.18 203.59,22.78 204.2,22.53 206.58,22.53 206.58,22.53 207.97,22.53 208.16,22.72 208.16,23.02 209.43,24.29 210.49,24.29 210.91,23.87 212.1,23.87 213.37,22.6 214.58,22.6 215.27,21.9 215.27,21.1 217.08,19.29 217.96,19.29 218.19,19.53 218.19,19.9 218.55,20.25 218.89,20.25 219.12,20.02 220.91,20.02 221.79,20.91 222.91,20.91 223.85,19.97 224.82,19.97 225.18,19.61 225.84,19.61 226.63,18.83 231.21,18.83 231.44,18.6 234.07,18.6 234.09,18.58 235.96,18.58 237.98,20.59 238.8,20.59 239.68,21.48 239.68,21.87 240.26,22.44 240.26,23.63 243.52,26.89 245.52,26.89 249.19,30.56 271.08,30.56 271.27,30.37 277.6,30.37 278.35,29.62 280.58,29.62 281.1,30.15 289.63,30.15 292.47,32.99 294.5,32.99 295.14,33.63 298.94,33.63 299.14,33.84 304.1,33.84 305.61,32.32 309.25,32.32 311.2,34.27 323.12,34.27 323.76,34.9 323.76,35.19 v2(323.55,35.4)
  IN6 w0.089: v2(319.59,47.49) 319.8,47.7 319.8,47.9 319.71,47.98 319.19,47.98 319.1,47.9 319.1,47.42 319.43,47.09 320.96,47.09 321.27,46.78 322.37,46.78 324.16,44.99 324.16,44.97 325.4,43.73 325.4,35.56 324.5,34.66 323.94,34.66 323.76,34.84 323.76,35.19 v2(323.55,35.4)
  BOTTOM w0.107: UH1.R35 v2(200.17,24.48) ; JSSD1.5 325.28,48.91 325.13,48.76 320.29,48.76 319.77,48.24 319.77,47.67 v2(319.59,47.49)
PCIE_PRX_DTX_N21: length 79.8
  IN3 w0.127: v2(269.34,14.61) 269.42,14.69 269.42,14.7 269.47,14.76 269.47,15.04 269.19,15.33 265.59,15.33 264.92,14.66 260.3,14.66 259.52,13.88 252.18,13.88 251.75,13.45 240.64,13.45 239.89,12.71 239.07,11.88 231.64,11.88 230.83,12.69 222.2,12.69 221.79,13.11 219.58,13.11 219.16,13.53 215.77,13.53 215.46,13.84 211.08,13.84 210.94,13.98 209.47,13.98 206.48,16.97 204.27,16.97 202.93,18.31 202.54,18.31 202.16,18.7 201.52,18.7 200.93,19.28 200.93,19.78 201.23,20.08 201.77,20.08 v2(201.82,20.13)
  BOTTOM w0.107: v2(201.82,20.13) 201.54,20.13 201.44,20.23 201.44,20.32 201.18,20.47 201.14,20.62 UH1.T43 ; v2(269.34,14.61) 269.34,14.62 269.34,15.23 270.17,16.06 JSSD2.41
PCIE_PRX_DTX_N22: length 78.7
  IN3 w0.127: v2(202.11,21.76) 202.27,21.38 202.48,21.3 202.8,20.97 202.8,20.29 202.51,19.99 202.51,19.55 202.7,19.36 203.21,19.36 203.72,18.85 204.35,18.85 204.54,18.66 206.24,18.66 207.11,17.79 207.11,17.57 209.83,14.85 214.88,14.85 214.97,14.76 215.77,14.76 216.13,14.39 219.52,14.39 219.84,14.07 222.08,14.07 222.6,13.56 231.19,13.56 232,12.75 237.78,12.75 238.61,13.58 239.53,13.58 240.28,14.32 249.17,14.32 250.59,15.74 258.46,15.74 260.18,17.45 269.48,17.45 269.6,17.58 269.6,17.9 v2(269.4,18.1)
  BOTTOM w0.107: JSSD2.29 271.23,19.06 271.04,18.86 270.04,18.86 269.62,18.45 269.62,18.32 v2(269.4,18.1) ; UH1.U40 v2(202.11,21.76)
PCIE_PRX_DTX_N23: length 77.5
  IN3 w0.127: v2(203.93,20.03) 204.05,20.03 204.21,19.87 204.74,19.87 205.28,20.4 206.35,20.4 207.36,19.39 207.36,19.01 210.03,16.34 210.03,16.23 210.59,15.68 212.48,15.68 212.72,15.91 218.15,15.91 218.92,15.14 219.69,15.14 220.11,14.73 222.38,14.73 222.9,14.21 231.46,14.21 232.15,13.52 237.63,13.52 239.37,15.26 240.2,15.26 242.55,17.61 245.41,17.61 245.89,18.09 248.74,18.09 248.84,18.19 260.98,18.19 262.02,19.23 265.51,19.23 266.45,20.17 269.37,20.17 269.76,20.56 269.76,20.75 269.53,20.98 v2(269.53,20.98)
  BOTTOM w0.107: UH1.W43 202.63,20.57 202.71,20.44 202.71,20.44 203.51,20.44 v2(203.93,20.03) ; v2(269.53,20.98) 269.91,21.37 269.91,21.61 270.16,21.86 271.09,21.86 271.29,22.06 JSSD2.17
PCIE_PRX_DTX_N24: length 83
  IN3 w0.127: v2(270.07,25.23) 269.88,25.05 269.88,24.69 267.7,22.51 266.15,22.51 265.52,21.87 259.02,21.87 256.3,24.58 256.3,24.85 256.3,25.08 255.9,25.47 252.91,25.47 252.33,24.9 249.97,24.9 248.59,23.52 248.03,22.96 245.6,22.96 244.79,22.15 244.79,21.52 244.42,21.14 243.72,21.14 240.17,17.59 240.17,16.67 238.45,14.95 237.59,14.95 236.84,14.2 232.57,14.2 231.76,15.01 222.71,15.01 222.56,15.16 222.02,15.16 221.55,15.62 219.15,15.62 218.42,16.35 213.72,16.35 211.75,18.31 210.65,18.31 210.37,18.59 209.85,18.59 208.91,19.53 208.2,19.53 208.02,19.53 206.32,21.23 205.76,21.23 205.56,21.43 203.76,21.43 203.67,21.34 203.67,21.16 203.83,21 v2(203.86,21)
  BOTTOM w0.089: UH1.Y40 203,22.02
  BOTTOM w0.102: JSSD2.5 271.14,25.06 270.86,24.78 269.99,24.78 269.88,24.89 269.88,25.05 v2(270.07,25.23)
  BOTTOM w0.107: v2(203.86,21) 203.65,21.2 203.65,21.49 203.25,21.89 203.05,21.95 203,22.02
PCIE_PRX_DTX_P9: length 73.1
  IN6 w0.089: v2(196.29,24.31) 196.31,24.31 196.31,24.32 196.41,24.15 196.57,24.11 196.8,24.25 197.06,24.21 197.3,23.93 197.3,23.57 197.41,23.46 197.63,23.46 197.96,23.13 197.96,22.7 197.95,22.69 197.95,22.27 198.4,21.81 198.4,21.22 199.19,20.44 200.41,20.44 201.67,19.18 203.07,19.18 203.4,18.85 205.07,18.85 205.27,18.65 205.27,17.4 206.01,16.67 206.57,16.67 206.9,16.67 208.86,14.7 220.7,14.7 221.33,15.34 230.35,15.34 231.45,16.43 236.53,16.43 236.94,16.02 239.4,16.02 241.19,14.23 244.15,14.23 244.76,13.62 245.29,13.62 245.54,13.37 245.54,13.2 v2(245.84,12.9)
  BOTTOM w0.107: v2(245.84,12.9) 245.46,12.52 245.46,10 246.2,9.26 249.34,9.26 249.85,9.77 250.74,9.77 252.09,11.12 252.09,12.87 252.82,13.6 252.82,13.81 252.53,14.11 JSSD3.7 ; UH1.F36 196.29,23.8 v2(196.29,24.31)
PCIE_PRX_DTX_P10: length 64.7
  IN6 w0.089: v2(197.74,23.97) 197.93,23.97 198.02,23.88 198.02,23.32 198.14,23.21 198.14,22.74 198.66,22.22 202.26,22.22 203.08,21.39 204.16,21.39 205.02,20.52 205.02,19.53 205.7,18.86 205.7,17.56 206.14,17.12 206.56,17.12 206.57,17.12 207,17.12 209.02,15.1 212.12,15.1 212.46,15.44 212.99,15.44 213.35,15.8 215.32,15.8 215.34,15.82 217.99,15.82 218.43,15.37 219.75,15.37 220.11,15.73 230.19,15.73 231.3,16.84 239.86,16.84 242.07,14.63 244.35,14.63 244.74,14.24 246.96,14.24 247.04,14.15 247.04,13.57 247.23,13.39 247.63,13.39 247.82,13.57 247.82,14.14 247.92,14.24 248.8,14.24 249.06,13.97 249.06,13.11 v2(248.87,12.92)
  BOTTOM w0.107: v2(197.74,23.97) 197.68,23.91 197.68,23.5 UH1.J37 ; JSSD3.19 249.53,14.13 249.67,13.99 249.67,13.81 249.56,13.71 249.27,13.71 249.05,13.48 249.05,13.1 248.87,12.92 v2(248.87,12.92)
PCIE_PRX_DTX_P11: length 65.1
  IN6 w0.089: v2(197.11,22.47) 196.97,22.62 196.56,22.62 196.16,22.22 196.16,21.33 196.67,20.82 196.67,17.9 198.38,16.18 201.3,16.18 202.05,15.43 203.3,15.43 203.85,14.89 205.12,14.89 205.63,14.38 207.61,14.38 208.4,13.59 209.92,13.59 210.48,13.02 211.13,13.02 211.22,13.11 211.22,13.39 211.4,13.58 211.72,13.58 211.9,13.39 211.9,13.11 211.99,13.02 212.17,13.02 212.26,13.11 212.26,13.39 212.44,13.58 212.76,13.58 212.94,13.39 212.94,13.11 213.03,13.02 213.21,13.02 213.3,13.11 213.3,13.31 213.49,13.49 213.8,13.49 213.99,13.31 213.99,13.11 214.08,13.02 215.16,13.02 215.64,13.51 221.09,13.51 221.8,14.22 230.84,14.22 231.52,14.91 238.4,14.91 240.87,12.44 246.58,12.44 246.67,12.53 246.67,12.7 v2(246.45,12.92)
  BOTTOM w0.107: UH1.F39 196.46,22.64 v2(197.11,22.47) ; v2(246.45,12.92) 246.68,13.14 246.68,13.65 246.53,13.8 JSSD3.31
PCIE_PRX_DTX_P12: length 64.8
  IN6 w0.089: v2(243.37,12.88) 243.37,13.46 243.16,13.67 240.96,13.67 239.17,15.47 231.29,15.47 230.6,14.78 221.56,14.78 220.93,14.15 208.63,14.15 206.68,16.09 205,16.09 204.91,16.18 204.91,16.86 204.73,17.05 204.32,17.05 204.14,16.86 204.14,16.08 204.05,15.99 203.62,15.99 203.53,16.08 203.53,18.09 203.06,18.56 200.67,18.56 200.58,18.65 200.58,19.43 200.4,19.61 199.99,19.61 199.81,19.43 199.81,18.14 199.72,18.05 199.45,18.05 199.36,18.14 199.36,19.55 199.18,19.74 198.77,19.74 198.59,19.55 198.59,18.52 198.45,18.38 197.37,18.38 197.26,18.49 197.26,20.5 197.7,20.94 197.7,21.44 197.44,21.69 197.19,21.69 v2(196.99,21.9)
  BOTTOM w0.107: UH1.J41 197.31,21.58 v2(196.99,21.9) ; JSSD3.41 244.02,14.01 243.93,13.91 243.93,13.63 243.69,13.39 243.43,13.39 243.32,13.28 243.32,12.92 v2(243.37,12.88)
PCIE_PRX_DTX_P15: length 228.5
  IN1 w0.089: v2(186.42,29.82) 186.64,29.61 186.64,29.43 187.35,28.72 188.83,28.72 189.33,28.22 189.33,27.51 189.25,27.43 189.25,24.39 191.35,22.28 193.32,22.28 195.24,20.37 195.31,20.37 v2(195.53,20.14)
  IN3 w0.127: v2(267.04,165.33) 266.86,165.15 266.58,165.15 266.39,164.96 266.39,162.34 261.97,157.92 237.35,157.92 236.37,158.9 231.95,158.9 231.16,158.11 223.15,158.11 221.91,156.86 216.14,156.86 215.4,156.13 211.08,156.13 209.13,154.18 209.13,151.53 208.16,150.56 208.16,150.16 207.02,149.03 207.02,145.76 208.88,143.9 208.88,134.19 208.81,134.12 208.81,132.07 209.28,131.6 209.84,131.6 210.86,130.58 210.86,129.73 209.25,128.12 209.25,124.67 208.51,123.93 206.84,123.93 205.4,122.5 205.4,121.45 205.17,121.22 205.17,121.05 202.83,118.7 202.83,113.53 199.51,110.21 199.51,109.34 198.88,108.71 194.46,108.71 193.63,109.53 191.58,109.53 190.83,108.78 190.83,107.68 188.38,105.23 187.5,104.35 187.5,100.39 187.88,100.01 187.88,89.42 187.04,88.57 186.52,88.05 186.52,71.1 186.16,70.74 186.16,69.48 185.67,68.99 185.67,68.94 185.46,68.73 185.46,64.23 185.87,63.82 185.87,61.59 184.83,60.54 184.83,59.41 184.57,59.16 184.57,55.49 184.91,55.15 184.91,54.81 185.77,53.95 185.77,52.6 186.45,51.92 186.45,40.51 186.97,39.99 186.97,39.7 187.35,39.32 187.35,36.28 187.43,36.2 187.43,32.99 186.53,32.1 186.53,29.94 v2(186.42,29.82)
  BOTTOM w0.107: v2(267.04,165.33) 267.2,165.17 267.35,165.17 CL1.2 ; UH1.E45 195.81,19.86 v2(195.53,20.14)
