# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
JKSO3: length 80.7
  TOP w0.102: v2(229.75,11.49) 229.75,12.9 232.51,15.66 232.51,16.02 233.61,17.12 235.34,17.12 235.99,17.77 235.99,20.87 235.95,20.91 235.95,22.45 236.5,23 236.5,23 237.72,24.23 237.99,24.49 237.99,24.68 237.99,25.25 237.99,25.25 237.99,25.78 237.75,26.02 237.75,26.79 238.64,27.68 238.64,30.42 238.83,30.62 238.83,31.99 238.03,32.8 238.03,32.99 238.03,33 238.03,34.91 236.07,36.87 v3(227.36,36.87) 224.28,36.87 222.86,35.46 222.86,31.71 223.15,31.42 224.35,31.42 224.64,31.14 QE55.3
  TOP w0.107: QE52.6 229.64,24.01 229.43,23.8 229.43,22.26 229.13,21.96 227.73,21.96 227.28,21.51 227.28,21.2 227.01,20.94 227.01,20.47 226.59,20.06 224.34,20.06 223.95,19.67 223.95,17.67 223.98,17.64 223.98,16.2 222.77,14.99 222.77,12.75 223.01,12.51 v2(223.01,11.05)
  BOTTOM w0.102: v2(223.01,11.05) 223.38,11.05 224.19,11.87 224.92,11.87 225.31,11.48 225.31,10.91 225.62,10.6 228.86,10.6 v2(229.75,11.49)
  BOTTOM w0.107: JKB.5 221.47,10.17 221.58,10.28 221.94,10.28 222.07,10.4 222.19,10.4 222.31,10.53 222.7,10.53 223.01,10.84 v2(223.01,11.05)
JKSO4: length 58.8
  TOP w0.102: v2(221.97,8.31) 222.15,8.49 224.86,8.49 226.21,9.83 227.96,9.83 229.19,11.06 229.19,12.66 232.29,15.76 232.29,16.18 233.46,17.35 235.25,17.35 235.76,17.86 235.76,20.77 235.72,20.81 235.72,22.54 236.27,23.1 236.27,23.1 237.63,24.45 237.63,24.45 237.76,24.59 237.76,24.78 237.76,25.16 237.76,25.69 237.52,25.93 237.52,26.89 238.41,27.77 238.41,30.52 238.6,30.71 238.6,31.9 237.8,32.71 237.8,33.09 237.8,34.82 235.97,36.64 230.21,36.64 229.92,36.35 v1(229.92,35.77) QE53.6 229.58,33.72 229.42,33.57 229.42,32.26 229.62,32.06 229.62,31.49 229.43,31.3 228.35,31.3 227.91,31.74 226.03,31.74 225.78,31.49 224.67,31.49 224.54,31.61 QE56.6
  BOTTOM w0.102: v2(221.97,8.31) JKB.4
JRTC1: length 2.4
  TOP w0.102: PR2.1 v1(292.81,41.46)
  TOP w0.254: PR2.1 293.53,41.88 PD5.2
JTAG_TCLK: length 4.1
  BOTTOM w0.089: T10.1 234.58,120.22 235.62,119.17 235.62,117.9 235.41,117.69 235.41,117.42 235.07,117.08 UG9.BK24
JTAG_TDI: length 4.9
  BOTTOM w0.089: UG9.BM23 234.37,118.88 232.37,120.88 232.37,121.42 T12.1
JTAG_TDO: length 3.1
  BOTTOM w0.089: T13.1 234.76,119.04 234.76,118.56 UG9.BM24
JTAG_TMS: length 4.3
  BOTTOM w0.089: UG9.BL23 234.37,117.72 234.03,118.06 234.03,118.48 231.97,120.54 T11.1
JTAG_TRST#: length 5.8
  TOP w0.089: v2(233.59,120.97) 233.09,120.97 v3(232.85,121.21)
  BOTTOM w0.089: RG518.1 233.12,121.44 v2(233.59,120.97) 233.92,120.64 233.92,120.22 235.38,118.76 235.38,118.08 235.07,117.77 UG9.BL24
KB_LED_B1_DRV#: length 25
  TOP w0.102: v2(168.16,10.85) v1(168.16,13.68) 168.16,14.33 174.9,21.07 183.07,21.07 183.49,21.5 UE4.5
  BOTTOM w0.102: JKBBL.5 167.82,10.51 v2(168.16,10.85)
KB_LED_B2_DRV#: length 30.8
  TOP w0.102: UE4.9 186.1,19.58 186,19.69 184.51,19.69 183.87,20.34 175.42,20.34 169.53,14.44 v1(169.53,12.04) 169.53,11.19 169.64,11.08 169.64,8.41 169.18,7.95 166.81,7.95 v2(166.32,8.44)
  BOTTOM w0.102: v2(166.32,8.44) JKBBL.8
KB_LED_B3_DRV#: length 34.1
  TOP w0.102: v2(170.57,10.91) 170.57,10.91 170.57,14.5 175.72,19.65 183.26,19.65 184.18,18.72 v1(184.18,18.61) 184.84,17.95 187.13,17.95 187.27,17.81 187.84,17.81 188.1,18.06 188.1,18.3 188.6,18.81 UE4.14
  BOTTOM w0.102: v2(170.57,10.91) 170.57,11.55 170.14,11.98 165.6,11.98 164.82,11.2 JKBBL.11
KB_LED_B4_DRV#: length 41.9
  TOP w0.102: v2(163.32,8.44) 164.49,7.26 170.48,7.26 v1(172.72,9.51) 172.82,9.61 172.82,15.72 176.06,18.96 182.78,18.96 183.26,18.49 183.26,18.42 185.22,16.46 188.77,16.46 189.59,17.29 189.59,18.39 189.94,18.73 189.94,19.12 190.23,19.41 190.79,19.41 190.89,19.51 190.89,19.89 190.79,19.99 UE4.17
  BOTTOM w0.102: v2(163.32,8.44) JKBBL.14
KB_LED_B5_DRV#: length 305.9
  TOP w0.102: v2(306.52,41.46) 306.72,41.26 UE8.21 ; v2(73.45,18.52) v1(74.27,18.52)
  IN2 w0.102: v2(73.45,18.52) 73.61,18.37 96.6,18.37 100.15,21.91 116.21,21.91 125.6,31.3 182.31,31.3 183.27,32.25 184.42,32.25 184.86,32.69 189.36,32.69 189.77,33.1 189.91,33.1 192.65,35.84 196.23,35.84 198.21,37.82 198.21,39.2 198.42,39.41 198.84,39.41 199.18,39.07 202.09,39.07 202.51,39.49 203.08,39.49 203.46,39.11 203.46,38.66 204.35,37.77 206.96,37.77 207.62,38.44 207.62,38.44 207.84,38.66 207.84,38.66 207.84,38.66 208.16,38.66 208.29,38.54 208.73,38.54 209.5,39.3 212.51,39.3 212.64,39.17 213.87,39.17 214.96,40.25 219.17,40.25 219.46,40.55 222.42,40.55 224.36,38.6 230.86,38.6 231.22,38.95 235.17,38.95 235.59,38.54 237.62,38.54 239.14,37.01 240.03,37.01 241.78,35.26 242.35,35.26 242.6,35.01 242.6,32.8 242.54,32.73 242.54,32.02 242.67,31.88 243.17,31.39 248.78,31.39 249.45,30.71 257.31,30.71 257.57,30.46 265.55,30.46 266.52,29.48 272.57,29.48 273.6,28.45 276.68,28.45 282.77,22.36 285.35,22.36 286.27,23.28 287.68,23.28 288.21,22.76 288.21,22.21 288.34,22.07 289.58,20.83 290.57,20.83 291.13,20.27 293.15,20.27 293.31,20.11 296.71,20.11 297.02,19.79 297.02,19.65 297.32,19.36 299.23,19.36 299.86,19.99 299.86,20.48 300.12,20.74 301.63,20.74 301.76,20.86 301.86,20.86 302.1,21.1 307.13,21.1 310.52,24.5 310.52,25.26 310.07,25.72 v2(310.07,26.41)
  IN3 w0.102: v2(310.07,26.41) 310.07,27.4 307.86,29.61 307.86,31.16 306.78,32.24 306.78,33.39 304.3,35.87 304.3,39.36 306.4,41.46 v2(306.52,41.46)
  BOTTOM w0.107: JKB3.2 64.43,8.85 64.59,8.69 72.65,8.69 73.53,9.57 73.53,11.98 73.99,12.44 73.99,17.99 v2(73.45,18.52)
KB_LED_G1_DRV#: length 28.1
  TOP w0.102: UE4.4 183.67,21.99 183.12,21.45 181.87,21.45 v1(181.85,21.44) 181.3,21.44 181.29,21.45 179.42,21.45 179.41,21.44 174.93,21.44 167.73,14.23 167.73,9.18 v2(168.32,8.58)
  BOTTOM w0.102: v2(168.32,8.58) JKBBL.4
KB_LED_G2_DRV#: length 27.1
  TOP w0.102: UE4.8 184.53,19.99 183.96,20.56 175.19,20.56 v1(171.28,16.66) 169.03,14.4 169.03,12.72 169.02,12.72 169.02,11.06 v2(169.24,10.85)
  BOTTOM w0.102: v2(169.24,10.85) 168.56,11.52 167.37,11.52 166.82,10.98 JKBBL.7
KB_LED_G3_DRV#: length 33.1
  TOP w0.102: UE4.11 187.1,18.95 186.73,18.57 186.61,18.57 186.22,18.19 185.18,18.19 183.5,19.88 175.62,19.88 170.34,14.6 170.34,11.25 169.97,10.88 v1(169.97,10.1) 169.97,8.42 169.28,7.72 166.03,7.72 v2(165.32,8.44)
  BOTTOM w0.102: v2(165.32,8.44) JKBBL.10
KB_LED_G4_DRV#: length 36.7
  TOP w0.102: v2(171.47,11.11) v1(171.47,13.01) 171.47,14.73 175.93,19.19 182.87,19.19 183.49,18.58 183.49,18.52 185.29,16.72 188.7,16.72 189.37,17.38 189.37,18.54 189.6,18.78 UE4.16
  BOTTOM w0.102: JKBBL.13 163.82,11.08 164.94,12.21 170.37,12.21 v2(171.47,11.11)
KB_LED_G5_DRV#: length 308.9
  TOP w0.102: UE8.20 v2(307.22,42.92) ; v2(74.23,19.39) v1(75.92,19.39)
  IN2 w0.089: 195.22,37.53 193.93,36.24 192.37,36.24
  IN2 w0.102: 195.22,37.53 195.78,37.53 197.35,39.11 197.58,39.11 198.71,40.24 200.42,40.24 200.42,40.25 203.99,40.25 204.24,40 207.82,40 208.02,40.2 208.9,40.2 208.96,40.14 214.14,40.14 214.63,40.63 218.89,40.63 219.27,41 222.6,41 224.55,39.06 230.68,39.06 231.03,39.41 235.36,39.41 235.78,38.99 237.81,38.99 239.33,37.47 240.22,37.47 241.82,35.87 242.39,35.87 243.1,35.16 243.1,32.65 243,32.54 243,32.21 243.36,31.84 248.97,31.84 249.64,31.17 257.5,31.17 257.76,30.92 265.74,30.92 266.71,29.94 272.76,29.94 273.79,28.91 276.9,28.91 278.39,27.41 281.69,27.41 284.33,24.77 284.95,24.77 285.97,23.74 287.87,23.74 288.67,22.95 288.67,22.4 289.77,21.29 290.38,21.29 290.38,21.29 290.76,21.29 290.89,21.29 291.45,20.73 293.33,20.73 293.5,20.56 296.9,20.56 296.96,20.5 296.98,20.5 296.98,20.5 298.53,20.5 298.53,20.5 298.78,20.5 299.47,21.2 301.44,21.2 301.57,21.32 301.67,21.32 303.01,22.66 303.2,22.66 307.91,22.66 309.43,24.18 309.43,26.71 309.8,27.08 310.73,27.08 311.35,26.46 v2(311.35,26.34) ; v2(74.23,19.39) 74.8,19.39 75.36,18.82 96.41,18.82 99.96,22.37 114.32,22.37 115.57,23.62 115.57,24.86 122.52,31.8 182.18,31.8 183.89,33.52 184.74,33.52 185.08,33.18 189.2,33.18 189.58,33.56 189.69,33.56 192.37,36.24
  IN3 w0.102: v2(311.35,26.34) 311.35,26.46 310.97,26.84 310.97,27.74 308.45,30.25 308.45,33.82 307.96,34.32 307.96,40.54 308.62,41.21 308.62,42.34 308.05,42.92 v2(307.22,42.92)
  BOTTOM w0.107: JKB3.3 63.93,7.77 64.28,8.12 72.75,8.12 74,9.37 74,11.73 74.53,12.26 74.53,19.09 v2(74.23,19.39)
KB_LED_R1_DRV#: length 28
  TOP w0.102: v2(167.27,10.85) 167.27,14.11 173.73,20.57 v1(173.73,20.71) 174.8,21.77 183.12,21.77 183.84,22.5 UE4.3
  BOTTOM w0.102: v2(167.27,10.85) 167.67,11.26 168.33,11.26 168.82,10.76 JKBBL.3
KB_LED_R2_DRV#: length 28.5
  TOP w0.102: UE4.6 184.81,20.99 184.54,21.26 183.99,21.26 v1(183.64,20.92) 183.55,20.82 174.97,20.82 168.79,14.64 168.79,12.02 168.79,12.01 168.79,8.48 168.49,8.18 167.58,8.18 v2(167.33,8.44)
  BOTTOM w0.102: v2(167.33,8.44) 167.32,8.43 JKBBL.6
KB_LED_R3_DRV#: length 29.3
  TOP w0.102: UE4.10 186.6,18.89 186.18,18.47 185.23,18.47 183.59,20.11 175.53,20.11 169.93,14.52 v1(169.93,14.19) v2(169.93,11.42)
  BOTTOM w0.102: JKBBL.9 165.82,11.12 166.45,11.75 169.6,11.75 v2(169.93,11.42)
KB_LED_R4_DRV#: length 38.2
  TOP w0.102: v2(164.32,8.44) 165.26,7.49 170.38,7.49 171.06,8.17 v1(171.06,8.6) 171.06,14.66 175.83,19.42 182.97,19.42 183.71,18.67 183.71,18.61 185.37,16.96 188.62,16.96 189.1,17.44 UE4.15
  BOTTOM w0.102: v2(164.32,8.44) JKBBL.12
KB_LED_R5_DRV#: length 309.5
  TOP w0.102: v1(307.62,41.91) v2(307.62,41.39) 307.72,41.3 UE8.19
  IN2 w0.102: v2(310.74,26.34) 310.74,26.46 310.35,26.85 309.9,26.85 309.66,26.61 309.66,24.09 308,22.43 303.11,22.43 301.77,21.09 301.66,21.09 301.53,20.97 300.03,20.97 299.63,20.57 299.63,20.09 299.2,19.65 297.35,19.65 297.25,19.75 297.25,19.89 296.8,20.34 293.41,20.34 293.24,20.5 291.22,20.5 290.66,21.06 290.47,21.06 289.68,21.06 288.44,22.3 288.44,22.85 287.78,23.51 286.18,23.51 285.25,22.58 282.87,22.58 276.78,28.68 273.69,28.68 272.66,29.71 266.62,29.71 265.64,30.69 257.66,30.69 257.41,30.94 249.55,30.94 248.88,31.61 243.27,31.61 242.77,32.11 242.77,32.64 242.83,32.7 242.83,35.1 242.45,35.49 241.88,35.49 240.13,37.24 239.24,37.24 237.71,38.76 235.68,38.76 235.26,39.18 231.13,39.18 230.77,38.83 224.46,38.83 222.51,40.78 219.37,40.78 219.03,40.44 214.77,40.44 214.23,39.9 208.93,39.9 208.82,40.01 208.1,40.01 207.51,39.42 207.51,38.83 206.71,38.03 204.86,38.03 204.29,38.6 204.29,39.68 203.91,40.05 202.71,40.05 202.7,40.05 198.79,40.05 198.01,39.28 198.01,37.9 196.16,36.05 192.5,36.05 189.78,33.33 189.67,33.33 189.29,32.95 184.99,32.95 184.64,33.29 183.98,33.29 182.22,31.52 125.5,31.52 116.12,22.14 100.05,22.14 96.5,18.6 74.2,18.6 v2(73.81,18.98)
  IN3 w0.102: v2(307.62,41.39) 307.18,40.95 306.27,40.95 304.75,39.42 304.75,36.06 307.01,33.8 307.01,32.33 308.11,31.23 308.11,29.77 310.74,27.14 v2(310.74,26.34)
  BOTTOM w0.107: JKB3.4 63.43,8.84 63.81,8.46 72.75,8.46 73.76,9.47 73.76,11.88 74.26,12.37 74.26,18.54 v2(73.81,18.98)
KB_RST#: length 110.8
  TOP w0.102: RE646.1 305.23,28.06 305.67,28.06 305.67,28.06 305.94,28.06 306.22,27.78 306.22,24.68 303.69,22.15 303.69,20.59 302.95,19.85 302.95,19.81 v2(302.71,19.57)
  IN6 w0.102: v2(220.23,21.77) 220.62,22.16 221.23,22.16 221.37,22.03 222.8,22.03 224.1,20.73 224.84,20.73 225.28,21.17 225.28,21.18 225.52,21.42 225.52,21.42 225.61,21.5 226.72,21.5 227.47,20.76 228.42,20.76 228.88,21.21 229.39,21.21 229.44,21.16 231.09,21.16 231.21,21.28 234.7,21.28 236.82,19.16 242.69,19.16 242.97,19.43 244.32,19.43 244.56,19.67 244.56,19.94 245.97,21.35 245.97,22.76 249.96,26.75 256.28,26.75 260.91,22.12 264.8,22.12 265.34,22.66 266.76,22.66 267.34,22.08 271.89,22.08 272.86,21.1 275.95,21.1 276.35,20.7 293.16,20.7 293.52,20.34 297.8,20.34 298.79,19.35 301.37,19.35 301.39,19.33 302.47,19.33 v2(302.71,19.57)
  BOTTOM w0.102: RH518.1 220.23,22.2 v2(220.23,21.77) 220.37,21.63 v1(220.77,21.63)
  BOTTOM w0.122: UH1.BE39 215.32,22.64 215.42,22.54 216.05,22.54 216.51,22.09 217.35,22.09 217.42,22.02 217.74,22.02 218.73,23.02 219.05,23.02 219.07,22.99 219.44,22.99 RH518.1
KSI0: length 205.5
  TOP w0.102: UE5.55 290.37,15.21 290.03,15.56 v1(288.6,15.56) 286.66,15.56 283.79,18.43 283.79,18.79 281.14,21.43 281.14,27.79 281.29,27.94 281.29,31.45 280.52,32.22 280.52,32.24 280.51,32.25 280.51,33.73 279.81,34.43 279.81,35.66 280.02,35.88 v2(280.02,38.57)
  TOP w0.107: RE630.1 143.37,14.05 v2(143.26,14.16)
  IN1 w0.102: v2(228.96,33.11) 229.02,33.16 232.65,33.16 234.22,31.59 235.24,31.59 235.35,31.7 235.35,32.99 236.89,34.53 236.89,37.93 240.26,41.3 243.62,41.3 245.34,43.03 247.56,43.03 250.56,46.03 266.27,46.03 273.94,38.36 278.65,38.36 279.27,38.98 279.62,38.98 v2(280.02,38.57)
  IN4 w0.089: 217.84,16.87 217.87,16.9 217.87,17.2 217.75,17.32 217.75,17.83 217.37,18.22 216.1,18.22 215.27,17.39 213.91,17.39 213.48,16.96 ; 206.79,17.35 205.47,17.35 204.28,18.54 202.53,18.54 202.27,18.8 196.55,18.8 195.71,17.95 195.65,17.95
  IN4 w0.102: 213.48,16.96 212.73,16.21 212.36,16.21 211.64,15.5 208.64,15.5 206.79,17.35 ; 195.65,17.95 195.64,17.95 195.22,17.95 195.21,17.95 195.15,17.95 192.86,20.25 190.69,20.25 189.59,19.15 189.59,17.63 188.78,16.82 185.6,16.82 184.88,17.53 181.03,17.53 180.6,17.96 148.27,17.96 145.42,15.12 144.28,15.12 143.33,14.16 v2(143.26,14.16) ; v2(228.96,33.11) 228.93,33.11 228.58,32.76 228.58,30.64 227.92,29.98 227.92,27.56 226.82,26.46 225.78,26.46 224.79,25.46 224.79,24.94 224.04,24.19 224.04,24.19 223.67,23.82 223.67,22.23 223.35,21.91 222.37,21.91 219.94,19.48 219.67,19.21 219.67,18.27 219.6,18.2 219.6,16.69 219.31,16.4 218.98,16.4 218.94,16.44 218.94,16.44 218.81,16.57 218.67,16.7 218,16.7 217.84,16.87
  BOTTOM w0.102: v2(228.96,33.11) 228.93,33.14 228.63,33.14 QE42.3 228.04,34.58 RE469.2
KSI0_R: length 8.3
  TOP w0.102: RE630.2 143.33,12.8 142.86,13.27 142.86,14.63 v3(142.93,14.71)
  TOP w0.107: RE630.2 143.22,12.65 142.32,12.65 v2(141.47,11.8)
  BOTTOM w0.107: JKB2.5 141.38,11.89 v2(141.47,11.8) 141.38,11.71 JKB2.6
KSI1: length 205.1
  TOP w0.102: UE5.56 290.44,14.81 290.04,15.22 286.67,15.22 283.56,18.33 283.56,18.69 280.92,21.34 280.92,27.89 281.06,28.04 281.06,31.35 280.28,32.14 280.28,33.63 280.25,33.66 280.25,33.66 279.58,34.33 279.58,35.76 279.79,35.97 279.79,38.22 v2(279.44,38.57)
  TOP w0.107: RE632.1 v2(144.53,14.16)
  IN1 w0.102: v2(279.44,38.57) 278.99,38.13 273.84,38.13 266.17,45.8 250.65,45.8 247.65,42.8 245.44,42.8 243.71,41.08 240.35,41.08 237.12,37.84 237.12,34.44 235.58,32.9 235.58,31.61 235.33,31.36 234.13,31.36 232.81,32.68 229.15,32.68 229.05,32.58 229.05,32.57 v2(228.99,32.5)
  IN4 w0.089: 195.14,17.76 195.89,17.76 196.65,18.52 202.29,18.52 202.45,18.36 203.43,18.36 204.72,17.07
  IN4 w0.102: v2(228.99,32.5) 228.99,32.5 229.46,32.04 229.46,31.19 228.15,29.88 228.15,27.36 227.02,26.23 225.88,26.23 225.01,25.37 225.01,24.84 224.14,23.97 224.13,23.97 223.89,23.73 223.89,22.14 223.44,21.68 222.47,21.68 220.04,19.25 220.04,19.25 219.9,19.12 219.9,18.18 219.83,18.11 219.83,16.6 219.45,16.22 219.45,16.22 219.41,16.17 218.88,16.17 218.58,16.48 217.81,16.48 217.58,16.7 216.58,16.7 216.34,16.95 214.54,16.95 214.03,16.44 213.56,16.44 213.11,15.99 212.46,15.99 211.74,15.27 208.34,15.27 206.54,17.07 204.72,17.07 ; 195.14,17.76 195.07,17.76 192.82,20.02 190.78,20.02 189.82,19.06 189.82,17.54 188.88,16.59 185.5,16.59 184.79,17.3 180.94,17.3 180.51,17.73 153.19,17.73 152.91,17.45 148.08,17.45 145.52,14.89 145.14,14.89 144.53,14.28 v2(144.53,14.16)
  BOTTOM w0.102: QE42.6 229.07,32.42 v2(228.99,32.5) 229.42,32.94 229.42,33.95 229.98,34.51 RE470.2 v1(229.98,35.83)
KSI1_R: length 5.4
  TOP w0.107: RE632.2 144.53,12.68 144.01,12.15 143.82,12.15 v2(143.47,11.8)
  BOTTOM w0.107: JKB2.10 143.38,11.71 v2(143.47,11.8) 143.38,11.89 JKB2.9
KSI2: length 200.5
  TOP w0.102: v2(279.38,36.65) 279.35,36.62 279.35,34.23 280.05,33.53 280.05,32.03 280.65,31.42 280.65,31.41 280.83,31.23 280.83,28.13 280.69,27.98 280.69,21.24 283.33,18.6 283.33,18.23 286.58,14.98 289.94,14.98 290.51,14.41 UE5.57 ; v2(145.87,14.16) 145.15,14.88 v1(144.69,14.88)
  TOP w0.107: v2(145.87,14.16) RE634.1
  IN1 w0.102: v2(229.02,30.03) 232.48,30.03 234.18,28.32 235.09,28.32 237.8,31.04 237.8,35.47 238.51,36.18 238.51,37.07 240.29,38.85 244.68,38.85 245.5,39.67 245.5,41.01 246.6,42.12 247.94,42.12 250.94,45.11 265.89,45.11 273.56,37.44 278.59,37.44 v2(279.38,36.65)
  IN4 w0.089: 195.27,17.53 195.98,17.53 196.72,18.27 202.17,18.27 202.25,18.18 203.22,18.18 203.27,18.13
  IN4 w0.102: v2(229.02,30.03) 228.38,29.39 228.38,27.26 227.12,26 225.97,26 225.24,25.27 225.24,24.25 224.88,23.88 224.88,22.61 223.72,21.45 222.56,21.45 220.23,19.12 220.23,18.15 220.06,17.99 220.06,16.5 219.5,15.95 218.79,15.95 218.48,16.25 218,16.25 217.71,16.25 217.48,16.48 216.49,16.48 216.25,16.72 214.64,16.72 214.13,16.21 213.65,16.21 213.2,15.76 212.55,15.76 211.83,15.04 208.24,15.04 206.41,16.87 204.53,16.87 203.27,18.13 ; 195.27,17.53 194.94,17.53 192.68,19.79 190.88,19.79 190.09,19 190.09,17.48 189.11,16.49 188.97,16.36 185.41,16.36 184.69,17.07 180.85,17.07 180.41,17.5 153.29,17.5 150.39,14.61 146.32,14.61 v2(145.87,14.16)
  BOTTOM w0.102: v2(229.02,30.03) 228.5,30.03 QE41.3 228.04,30.94 228.13,31.03 RE464.2
KSI2_R: length 5
  TOP w0.102: v2(145.47,11.8) 145.87,12.2 RE634.2
  BOTTOM w0.107: JKB2.13 145.38,11.89 v2(145.47,11.8) 145.38,11.71 JKB2.14
KSI3: length 198.5
  TOP w0.102: v2(146.5,14.16) v1(146.5,14.71) ; UE5.58 290.58,14.01 289.85,14.75 286.48,14.75 283.1,18.13 283.1,18.5 280.74,20.87 280.74,20.87 280.61,21 280.46,21.15 280.46,28.08 280.61,28.23 280.61,31.14 278.75,33 v2(278.75,36.65)
  TOP w0.107: RE635.1 v2(146.5,14.16)
  IN1 w0.102: v2(278.75,36.65) 278.18,37.21 273.46,37.21 265.79,44.89 251.03,44.89 248.04,41.89 246.7,41.89 245.73,40.92 245.73,39.58 244.77,38.62 240.39,38.62 238.74,36.98 238.74,36.09 238.03,35.38 238.03,30.94 235.18,28.1 233.6,28.1 232.31,29.39 v2(229.05,29.39)
  IN4 w0.102: v2(229.05,29.39) 228.96,29.39 228.61,29.04 228.61,27.17 227.21,25.77 226.07,25.77 225.5,25.2 225.5,24.18 225.1,23.79 225.1,21.9 224.76,21.55 224.76,20.92 223.58,19.74 222.71,19.74 222.2,19.23 221.21,19.23 220.48,18.5 220.48,18.02 220.29,17.83 220.29,16.41 219.6,15.72 218.69,15.72 218.6,15.81 217.68,15.81 217.31,15.44 217.31,14.61 215.56,12.87 210.08,12.87 209.53,13.42 209.23,13.72 206.1,13.72 205.53,14.29 204,14.29 204,14.29 203.86,14.29 203.12,13.55 200.64,13.55 200.38,13.29 192.41,13.29 191.79,12.67 188.18,12.67 187.27,13.58 186,13.58 182.74,16.84 180.75,16.84 180.32,17.28 153.38,17.28 150.26,14.16 v2(146.5,14.16)
  BOTTOM w0.102: RE463.2 229.98,31.17 229.42,30.62 229.42,29.85 229.05,29.48 v2(229.05,29.39) 229.05,29.33 229.2,29.19 QE41.6
KSI3_R: length 5.8
  TOP w0.102: RE635.2 146.5,11.83 v2(146.47,11.8) 146.5,11.77 146.5,11.28 v1(146.81,10.98)
  BOTTOM w0.107: JKB2.15 146.38,11.89 v2(146.47,11.8) 146.38,11.71 JKB2.16
KSI4: length 208.4
  TOP w0.107: RE633.1 v2(145.17,14.16) ; v2(289.18,13.45) 289.18,13.58 289.57,13.97 v3(289.61,13.97) 290.11,13.97 290.47,13.61 UE5.59
  IN1 w0.102: v2(229.02,26.79) 232.74,26.79 234.65,24.88 235.3,24.88 235.4,24.98 235.4,25.59 238.72,28.91 238.72,33.99 242.46,37.74 244.85,37.74 246.89,39.77 248.36,39.77 249.44,40.84 249.44,42.32 251.32,44.2 265.51,44.2 273.18,36.53 277.47,36.53 278.21,35.79 284.35,35.79 284.83,36.27 285.18,36.27 v2(285.63,35.82)
  IN4 w0.102: v2(229.02,26.79) 228.61,26.79 228.25,26.43 228.25,26.43 227.36,25.54 227.18,25.54 225.47,23.83 225.33,23.69 225.33,21.8 224.99,21.46 224.99,20.83 222.4,18.24 221.2,18.24 220.52,17.56 220.52,16.31 219.69,15.49 218.6,15.49 218.5,15.58 217.77,15.58 217.53,15.35 217.53,14.52 215.65,12.64 209.99,12.64 209.3,13.33 200.74,13.33 200.47,13.06 192.5,13.06 191.88,12.44 188.09,12.44 187.18,13.35 185.66,13.35 182.39,16.61 180.66,16.61 180.22,17.05 153.48,17.05 149.87,13.43 145.27,13.43 145.17,13.54 v2(145.17,14.16)
  BOTTOM w0.102: RE459.2 228.13,27.77 228.04,27.68 QE40.3 228.56,27.25 v2(229.02,26.79) ; 287.31,12.01 286.07,10.77 RE666.1
  BOTTOM w0.107: 287.31,12.01 288.76,13.45 v2(289.18,13.45) 289.19,13.45 289.63,13.01 289.94,13.01 291.09,14.15 291.09,28.94 288.38,31.64 287.78,31.64 286.21,33.21 286.21,33.32 285.5,34.03 285.5,35.7 v2(285.63,35.82)
KSI4_R: length 6.7
  TOP w0.102: v2(144.47,11.8) 144.47,10.79 v1(144.9,10.35)
  TOP w0.107: v2(144.47,11.8) 144.47,12.09 145.17,12.79 RE633.2
  BOTTOM w0.107: JKB2.12 144.38,11.71 v2(144.47,11.8) 144.38,11.89 JKB2.11
KSI5: length 209.5
  TOP w0.102: v2(285,35.82) 285,36.07 v3(285.68,36.76) ; v2(143.9,14.16) 143.95,14.11 RE631.1
  TOP w0.107: v2(289.81,13.45) 290.23,13.45 290.47,13.21 UE5.60
  IN1 w0.102: v2(229.02,26.2) 233,26.2 234.64,24.57 235.47,24.57 235.63,24.73 235.63,25.5 238.95,28.81 238.95,32.58 239.54,33.18 240.14,33.18 241.28,34.32 241.28,34.88 242.37,35.97 243.67,35.97 244.65,36.94 244.65,36.96 245.58,37.89 247.5,37.89 249.67,40.05 249.67,42.22 251.42,43.97 265.41,43.97 273.09,36.3 277.37,36.3 278.11,35.56 284.73,35.56 v2(285,35.82)
  IN4 w0.102: v2(143.9,14.16) 143.9,13.31 144,13.21 149.96,13.21 153.57,16.82 180.13,16.82 180.56,16.39 182.3,16.39 185.68,13.01 187.02,13.01 188.93,11.09 190.86,11.09 192.6,12.83 200.57,12.83 200.83,13.1 209.21,13.1 209.89,12.41 215.75,12.41 218.6,15.26 219.79,15.26 220.75,16.22 220.75,17.47 221.29,18.01 222.5,18.01 225.24,20.76 225.24,21.39 225.56,21.71 225.56,23.6 227.28,25.31 227.45,25.31 228.34,26.2 v2(229.02,26.2)
  BOTTOM w0.102: QE40.6 229.27,25.95 v2(229.02,26.2) 229.42,26.61 229.42,27.5 229.98,28.06 RE457.2 ; 287.22,12.24 286.98,12 RE667.1
  BOTTOM w0.107: 287.22,12.24 288.83,13.86 289.4,13.86 v2(289.81,13.45) 290.85,14.49 290.85,28.02 285.97,32.89 285.97,33.22 285,34.19 v2(285,35.82)
KSI5_R: length 7.6
  TOP w0.102: v2(142.47,11.8) 143.04,11.23 v3(143.04,10.33)
  TOP w0.107: v2(142.47,11.8) 142.47,12.04 142.81,12.37 143.65,12.37 143.95,12.68 RE631.2
  BOTTOM w0.107: JKB2.8 142.38,11.71 v2(142.47,11.8) 142.38,11.89 JKB2.7
KSI6: length 112.4
  TOP w0.102: v2(286.99,34.15) v3(286.99,34.96)
  TOP w0.107: v2(289.17,12.56) 289.61,13.01 290.06,13.01 290.26,12.81 UE5.61
  IN1 w0.102: v2(228.7,23.92) 228.7,23.92 229.52,23.92 229.89,23.55 234.01,23.55 234.41,23.14 235.26,23.14 235.95,23.43 242.31,29.79 242.31,31.86 243.24,32.78 246.93,32.78 250.59,36.45 250.59,41.85 251.79,43.05 265.04,43.05 273.45,34.65 279.59,34.65 280.04,34.19 285.35,34.19 285.72,34.56 286.59,34.56 v2(286.99,34.15)
  BOTTOM w0.102: v2(228.7,23.92) 228.7,23.92 228.13,23.92 QE39.3 228.04,24.86 RE452.2 ; RE664.1 287.24,10.35 287.24,11.28 287.48,11.52
  BOTTOM w0.107: 287.48,11.52 288.53,12.56 v2(289.17,12.56) 289.58,12.15 290.1,12.15 291.55,13.61 291.55,29.59 288.94,32.21 288.43,32.21 286.99,33.65 v2(286.99,34.15)
KSI7: length 100.4
  TOP w0.102: v3(285.87,33.62) v2(286.41,34.15)
  TOP w0.107: UE5.62 289.97,12.41 v2(289.82,12.56)
  IN1 w0.102: v2(229.02,23.43) 229.69,23.43 229.8,23.32 233.91,23.32 234.32,22.91 235.31,22.91 236.05,23.2 244.69,31.84 245.09,31.84 246.4,31.84 248.65,34.09 250.96,34.09 251.18,33.87 261.43,33.87 262.92,35.37 272.4,35.37 273.36,34.41 279.5,34.41 279.95,33.96 286.22,33.96 v2(286.41,34.15)
  BOTTOM w0.102: 288.38,31.97 287.91,31.97 286.5,33.39 286.5,34.07 v2(286.41,34.15) ; QE39.6 229.7,22.71 229.02,23.39 v2(229.02,23.43) 229.02,23.57 229.15,23.7 229.15,23.7 229.42,23.97 229.42,24.26 229.98,24.82 RE451.2 ; 287.41,11.77 287.02,11.38 287.02,10.75 285.8,9.53 RE665.1
  BOTTOM w0.107: 288.38,31.97 291.32,29.04 291.32,13.86 290.03,12.56 v2(289.82,12.56) 289.75,12.56 289.34,12.97 288.61,12.97 287.41,11.77
KSI8: length 81.9
  TOP w0.102: UE5.47 290.5,18.41 290.33,18.24 288.6,18.24 287.3,19.54 287.25,19.54 287.25,19.54 286.87,19.54 285.67,20.74 285.29,20.74 284.86,20.74 282.97,22.62 282.97,25.07 v1(283.09,25.18) 283.16,25.26 283.16,34.4 v2(282.96,34.6)
  IN3 w0.102: v2(234.95,33.26) 235.08,33.13 235.11,33.16 240.48,33.16 240.85,33.53 244.13,33.53 245.15,34.55 246.33,34.55 246.73,34.95 247.32,34.95 250.71,38.34 250.71,41.55 251.76,42.6 266.46,42.6 273.25,35.81 273.81,35.81 273.82,35.81 277.06,35.81 277.86,35 282.56,35 v2(282.96,34.6)
  BOTTOM w0.102: v2(234.95,33.26) 234.49,33.72 QE29.3 233.95,34.15 234.03,34.24 RE398.2
KSI9: length 83.3
  TOP w0.102: UE5.48 288.36,18.01 v1(287.81,18.56) 287.52,18.56 285.58,20.51 285.19,20.51 285.19,20.51 284.96,20.51 284.96,20.51 284.76,20.51 282.74,22.53 282.74,25.31 282.93,25.49 282.93,34.05 v2(282.38,34.6)
  IN3 w0.102: v2(234.95,32.68) 235.2,32.93 240.71,32.93 241.08,33.3 245.4,33.3 246.83,34.73 247.41,34.73 250.94,38.25 250.94,41.45 251.85,42.37 266.37,42.37 273.16,35.58 273.91,35.58 275.01,35.58 276.4,34.19 281.97,34.19 v2(282.38,34.6)
  BOTTOM w0.102: RE400.2 235.89,34.51 235.36,33.98 235.36,33.1 235.34,33.08 235.34,33.07 v2(234.95,32.68) 235.2,32.42 QE29.6
KSI10: length 90.5
  TOP w0.102: UE5.49 288.15,17.61 285.48,20.28 285.1,20.28 285.06,20.28 285.06,20.28 284.67,20.28 282.52,22.43 282.52,27.23 282.66,27.37 282.66,32.01 281.92,32.76 281.92,36.79 v2(281.63,37.07)
  IN1 w0.102: v2(281.63,37.07) 280.81,37.9 273.75,37.9 266.08,45.57 250.75,45.57 247.75,42.57 245.53,42.57 243.63,40.67 243.63,40.17 243.65,40.15 243.65,39.56 243.4,39.31 239.61,39.31 237.35,37.05 237.35,34.34 235.81,32.81 235.81,30.89 v2(234.95,30.03)
  BOTTOM w0.102: v1(232,31.12) 232.03,31.14 233.04,31.14 233.32,31.42 RE475.2 234.03,31 233.95,30.92 QE43.3 234.49,30.49 v2(234.95,30.03)
KSI11: length 90.2
  TOP w0.102: v2(281.02,37.07) 281.68,36.41 281.68,32.67 282.43,31.92 282.43,27.47 282.42,27.45 282.29,27.32 282.29,22.34 284.57,20.05 284.58,20.05 285.15,20.05 285.19,20.05 285.39,20.05 288.22,17.21 v1(289.23,17.21) UE5.50
  IN1 w0.102: v2(234.95,29.44) 235.52,29.44 237.58,31.5 237.58,36.95 239.7,39.08 244.04,39.08 244.58,39.62 244.58,41.05 245.88,42.35 247.85,42.35 250.84,45.34 265.98,45.34 273.65,37.67 280.42,37.67 v2(281.02,37.07)
  BOTTOM w0.102: RE477.2 235.89,31.27 235.36,30.74 235.36,29.86 235.34,29.84 235.34,29.84 v2(234.95,29.44) 235.2,29.19 QE43.6
KSI12: length 90.6
  TOP w0.102: v2(280.43,37.05) 281.45,36.03 281.45,32.58 282.21,31.82 282.21,27.56 282.06,27.42 282.06,22.24 284.72,19.58 284.72,18.8 285.42,18.1 285.56,18.1 v1(285.57,18.09) 286.85,16.81 UE5.51
  IN1 w0.102: v2(234.95,26.98) 235.14,26.98 235.66,27.5 235.66,28.25 238.26,30.85 238.26,35.28 238.97,35.99 238.97,36.88 240.48,38.4 244.87,38.4 246.71,40.23 246.71,41.28 247.09,41.66 248.13,41.66 251.13,44.66 265.7,44.66 273.37,36.99 277.66,36.99 278.4,36.25 279.63,36.25 v2(280.43,37.05)
  BOTTOM w0.102: v2(234.95,26.98) 234.44,26.98 234.17,27.25 QE44.3 233.95,27.68 234.03,27.77 RE481.2
KSI13: length 91.3
  TOP w0.102: v2(280.45,36.42) 281.21,35.65 281.21,32.49 281.98,31.73 281.98,27.66 281.83,27.51 281.83,22.15 284.49,19.49 284.49,18.71 286.71,16.48 v1(287.05,16.48) 290.35,16.48 290.42,16.41 UE5.52
  IN1 w0.102: v2(280.45,36.42) 280.05,36.02 278.3,36.02 277.56,36.76 273.27,36.76 265.6,44.43 251.23,44.43 249.21,42.41 249.21,40.94 248.26,40 246.79,40 244.76,37.96 242.34,37.96 238.49,34.11 238.49,29 235.69,26.2 235.14,26.2 v2(234.96,26.38)
  BOTTOM w0.102: RE483.2 235.89,28.03 235.36,27.5 235.36,26.78 v2(234.96,26.38) 235.39,25.95 QE44.6
KSI14: length 90.3
  TOP w0.102: UE5.53 290.44,16.01 290.3,16.15 286.72,16.15 284.26,18.61 284.26,19.25 v1(283.37,20.14) 281.6,21.91 281.6,27.6 281.75,27.75 281.75,31.64 280.98,32.4 280.98,34.42 v2(280.81,34.6)
  IN1 w0.102: v2(280.81,34.6) 280.3,35.1 277.92,35.1 277.18,35.84 272.9,35.84 265.23,43.51 251.6,43.51 250.14,42.04 250.14,39.88 245.75,35.5 245.75,33.82 245.58,33.65 243.45,33.65 241.85,32.05 241.85,29.98 239.87,27.99 238.45,27.99 237,26.54 237,25.13 236.15,24.28 235.31,24.28 v2(234.58,23.55)
  BOTTOM w0.102: RE487.2 234.03,24.46 233.95,24.38 QE45.3 234.37,24.01 234.58,23.8 v2(234.58,23.55)
KSI15: length 90.7
  TOP w0.102: v2(280.22,34.6) 280.75,34.07 280.75,32.31 281.52,31.54 281.52,27.85 281.37,27.7 281.37,21.67 v1(281.79,21.25) 284.01,19.03 284.01,18.54 286.62,15.93 289.99,15.93 290.3,15.61 UE5.54
  IN1 w0.102: v2(235.18,23.55) 235.68,24.05 236.25,24.05 237.23,25.03 237.23,26.45 238.55,27.77 239.96,27.77 242.08,29.89 242.08,31.95 243.55,33.42 245.67,33.42 245.98,33.73 245.98,35.4 250.36,39.78 250.36,41.95 251.7,43.28 265.13,43.28 272.8,35.61 277.09,35.61 277.83,34.87 279.94,34.87 v2(280.22,34.6)
  BOTTOM w0.102: RE489.2 235.89,24.79 235.18,24.09 v2(235.18,23.55) 235.18,22.81 235.28,22.71 QE45.6
KSI16: length 81.1
  TOP w0.102: UE5.45 290.66,19.21 290.14,18.7 288.79,18.7 287.76,19.73 287.49,19.99 287.06,19.99 285.83,21.23 285.47,21.23 v1(285.38,21.31) 284.24,22.45 284.24,24.95 283.69,25.5 283.69,34.85 283.09,35.44 283.09,36.94 v2(281.46,38.57)
  TOP w0.107: v2(235.89,35.23) RE493.2 235.89,34.2 235.85,34.16 QE46.3
  IN3 w0.102: v2(235.89,35.23) 237.85,35.23 238.74,36.12 242.45,36.12 244.05,37.72 245.47,37.72 246.13,38.38 246.88,38.38 249.44,40.94 249.44,42.08 251.23,43.87 266.99,43.87 273.78,37.08 279.89,37.08 280.25,37.44 280.33,37.44 v2(281.46,38.57)
KSI17: length 86.8
  TOP w0.102: v2(280.81,38.57) 280.81,38.48 282.15,37.14 282.15,36.06 283.46,34.74 283.46,25.09 283.2,24.83 283.2,22.93 v1(283.8,22.34) 285.17,20.97 285.38,20.97 285.76,20.97 286.97,19.76 287.16,19.76 287.4,19.76 287.53,19.63 288.69,18.47 290.24,18.47 290.58,18.81 UE5.46
  TOP w0.107: QE46.6 234.32,32.42 234.51,32.61 234.51,33.42 v2(234.95,33.85) 234.83,33.96 234.45,33.96 234.03,34.38 RE494.2
  IN1 w0.102: v2(280.81,38.57) 280.81,39.49 279.71,40.59 273.69,40.59 268.02,46.26 250.46,46.26 247.47,43.26 245.25,43.26 243.52,41.53 240.16,41.53 235.35,36.72 235.35,34.26 v2(234.95,33.85)
KSI18: length 102.4
  TOP w0.102: v2(236.43,31.55) 236.43,31.54 236.84,31.13 v1(237.59,31.13)
  TOP w0.107: v2(299.51,12.01) 299.54,11.99 UE5.81 ; QE47.3 235.85,30.92 235.89,30.96 RE500.2 236.01,31.55 v2(236.43,31.55)
  IN3 w0.102: v2(299.51,12.01) 299.09,12.43 299.09,12.88 300.49,14.28 303.08,14.28 303.28,14.47 303.28,16.45 303.91,17.08 303.91,21.04 302.99,21.96 302.99,24.43 301.16,26.27 294.06,26.27 287.93,32.4 276.89,32.4 274.63,34.67 274.29,34.67 272.78,34.67 266.78,40.67 265.84,40.67 265.05,41.46 252.23,41.46 251.85,41.08 251.85,37.02 250.87,36.05 250.87,35.43 246.76,31.32 241.03,31.32 240.33,32.02 236.9,32.02 v2(236.43,31.55)
KSI19: length 106.6
  TOP w0.102: RE499.2 233.33,31.42 v1(233.26,31.35)
  TOP w0.107: v2(299.97,12.38) 299.94,12.34 UE5.82 ; QE47.6 234.32,29.19 234.51,29.38 234.51,30.18 v2(234.95,30.61) 234.83,30.72 234.45,30.72 234.12,31.05 RE499.2
  IN3 w0.102: v2(234.95,30.61) 234.95,30.64 236.55,32.25 240.43,32.25 241.12,31.55 246.66,31.55 250.55,35.44 250.55,36.05 251.62,37.12 251.62,41.17 252.14,41.68 266.08,41.68 272.87,34.9 274.19,34.9 274.19,34.9 274.72,34.9 276.99,32.63 288.02,32.63 294.15,26.5 297.21,26.5 298.14,27.42 300.33,27.42 303.22,24.53 303.22,22.05 304,21.27 304.14,21.14 304.14,16.98 303.5,16.35 303.5,14.38 303.17,14.05 300.59,14.05 300,13.47 300,12.41 v2(299.97,12.38)
KSI20: length 110.5
  TOP w0.102: 301.14,10.84 301.3,11 301.3,11.79 301.07,12.03 300.44,12.03 v2(300.44,12.03) ; UE5.85 v1(301.14,8.42)
  TOP w0.107: 301.14,10.84 UE5.85 ; v2(236.43,28.25) 235.95,28.25 RE505.2 235.89,27.74 235.85,27.7 QE48.3
  IN3 w0.102: v2(236.43,28.25) 234.88,28.25 234.54,28.59 234.54,30.78 234.99,31.23 235.21,31.23 236.46,32.48 240.52,32.48 241.22,31.78 246.57,31.78 250.33,35.53 250.33,36.31 251.39,37.38 251.39,41.27 252.04,41.91 266.18,41.91 272.97,35.12 274.1,35.12 274.82,35.12 277.08,32.86 288.12,32.86 293.59,27.38 297.68,27.38 297.95,27.65 300.42,27.65 303.45,24.62 303.45,22.15 304.1,21.5 304.37,21.23 304.37,16.89 303.73,16.26 303.73,14.28 303.27,13.82 300.68,13.82 300.44,13.58 v2(300.44,12.03)
KSI21: length 108.6
  TOP w0.107: v2(301.1,12.44) 301.24,12.44 301.54,12.14 UE5.86 ; QE48.6 234.32,25.95 234.43,26.05 234.43,27.07 v2(234.95,27.59) 234.72,27.81 234.14,27.81 234.03,27.92 RE506.2
  IN3 w0.102: v2(301.1,12.44) 301.1,12.44 301.1,13.49 301.2,13.59 302.99,13.59 303.36,13.59 303.96,14.19 303.96,16.16 304.59,16.79 304.59,22.57 303.68,23.49 303.68,24.72 300.52,27.88 297.86,27.88 297.59,27.61 293.68,27.61 288.21,33.09 277.18,33.09 274.91,35.35 274,35.35 273.06,35.35 266.27,42.14 251.95,42.14 251.16,41.36 251.16,38.15 247.51,34.5 246.92,34.5 245.5,33.07 241.17,33.07 240.81,32.71 236.36,32.71 235.12,31.46 234.9,31.46 234.31,30.87 234.31,28.34 234.95,27.7 v2(234.95,27.59)
KSO0: length 92.7
  TOP w0.102: v2(284.23,39.64) 284.26,39.61 284.26,35.6 284.49,35.37 v1(284.49,30.32) 285.29,29.52 285.29,25.78 285.16,25.65 285.16,22.98 285.92,22.23 286.12,22.23 286.37,21.98 286.73,21.61 UE5.39 ; RE513.1 231.5,27.52 231.94,27.96 231.94,32.19 232.42,32.67 232.42,34.82 232.78,35.18 v2(232.78,35.44)
  IN1 w0.102: v2(284.23,39.64) 283.8,39.21 282.69,39.21 280.86,41.04 273.88,41.04 268.21,46.71 250.2,46.71 247.2,43.72 245.06,43.72 243.33,41.99 239.97,41.99 234.49,36.5 233.72,36.5 233.05,35.84 233.05,35.72 v2(232.78,35.44)
KSO1: length 80.3
  TOP w0.102: RE516.1 223.4,24.6 223.08,24.92 223.08,24.98 v2(223.08,24.98) ; v2(284.55,26.66) 284.91,26.3 v1(284.91,26.3) 284.93,26.28 284.93,22.89 285.82,22 286.03,22 286.81,21.21 UE5.40
  IN1 w0.102: v2(230.21,21.78) 230.06,21.93 228.38,21.93 228.19,22.13 225.97,22.13 224.99,23.1 224.02,23.1 223.39,23.73 223.39,24.62 223.08,24.92 223.08,24.98 v2(223.08,24.98)
  IN3 w0.102: v2(284.55,26.66) 284.46,26.57 278.93,26.57 277.43,28.07 267.55,28.07 265.86,29.76 260.07,29.76 260.06,29.75 249.46,29.75 248,28.29 247.8,28.29 245.98,26.47 242.28,26.47 237.59,21.78 235.63,21.78 235.21,21.36 230.63,21.36 v2(230.21,21.78)
KSO2: length 91.4
  TOP w0.102: v2(231.72,35.92) 231.72,35.54 231.91,35.35 231.91,32.81 231.47,32.36 231.47,31.23 231,30.76 ; UE5.41 286.89,20.81 285.93,21.77 285.72,21.77 284.7,22.78 284.7,25.13 284.15,25.69 284.15,35.38 284.03,35.5 284.03,39.08 v1(283.89,39.22) v2(283.47,39.64)
  TOP w0.107: 231,30.76 RE520.1
  IN1 w0.102: v2(231.72,35.92) 231.72,36.95 233.37,38.6 235.94,38.6 239.78,42.45 243.14,42.45 244.87,44.17 246.88,44.17 250.48,47.77 252.91,47.77 253.5,47.17 268.4,47.17 273.99,41.58 281.57,41.58 283.47,39.67 v2(283.47,39.64)
KSO3: length 111.2
  TOP w0.102: v2(233.3,35.09) 232.82,34.9 232.65,34.73 232.65,32.57 232.18,32.11 232.18,25.64 v3(231.94,25.4) RE524.1
  TOP w0.107: UE5.42 292.46,20.41 292.57,20.31 292.57,13.38 v2(292.8,13.15)
  IN1 w0.097: v2(287.47,39.04) 286.97,39.55 284.74,39.55
  IN1 w0.102: 284.74,39.55 284.17,38.98 282.58,38.98 280.75,40.81 273.79,40.81 268.11,46.49 250.29,46.49 247.3,43.49 245.15,43.49 243.43,41.76 240.07,41.76 234.58,36.27 233.82,36.27 233.3,35.75 v2(233.3,35.09)
  BOTTOM w0.107: v2(287.47,39.04) 287.66,38.86 287.66,33.82 291.79,29.69 291.79,15.22 292.8,14.21 v2(292.8,13.15)
KSO4: length 87.6
  TOP w0.102: UE5.43 290.31,20.01 290.01,20.31 v1(288.03,20.31) 287.07,20.31 285.85,21.53 285.63,21.53 284.47,22.69 284.47,25.04 283.92,25.6 283.92,35.28 283.8,35.4 283.8,38.67 v2(282.83,39.64)
  TOP w0.107: v2(230.84,35.56) 230.32,35.04 230.32,34.51 RE528.1
  IN1 w0.102: v2(282.83,39.64) 281.18,41.3 273.95,41.3 268.3,46.94 250.1,46.94 247.11,43.95 244.97,43.95 243.24,42.22 239.88,42.22 234.54,36.88 233.26,36.88 231.8,35.42 230.98,35.42 v2(230.84,35.56)
KSO5: length 166.1
  TOP w0.107: UE5.44 290.09,19.61 v1(289.96,19.74) 289.86,19.74 289.63,19.51 v2(289.63,19.31)
  IN4 w0.102: v2(140.47,11.8) 141.56,10.71 147.79,10.71 153.67,16.59 175.34,16.59 176.96,14.98 182.59,14.98 187.16,10.4 191.14,10.4 191.55,10.81 192.88,12.14 202.81,12.14 203.08,12.41 206.64,12.41 207.69,11.36 208.29,11.36 209.37,10.28 215.15,10.28 218.21,13.34 220.52,13.34 221.71,14.53 250.78,14.53 251.3,15.05 260.57,15.05 260.78,15.27 264.03,15.27 264.99,16.23 276.34,16.23 277.12,17.01 282.39,17.01 284.7,19.31 v2(289.63,19.31)
  BOTTOM w0.107: JKB2.4 140.38,10.13 140.47,10.23 v2(140.47,11.8) 140.38,11.89 JKB2.3
LAN_ACTIVITY#: length 59.7
  TOP w0.102: CL27.1 243.96,171.83 244.83,170.97 v1(245.09,170.97) JLAN.10
  IN1 w0.102: v2(273.99,167.1) 272.75,165.87 270.79,165.87 269.74,164.82 269.74,163.81 268.97,163.03 268.97,161.26 266.52,158.8 260.8,158.8 259.09,160.52 v2(242.71,160.52)
  IN2 w0.102: v2(242.71,160.52) 242.71,165.34 243.94,166.58 243.94,170.2 244.71,170.97 JLAN.10
  BOTTOM w0.102: v2(273.99,167.1) 273.4,166.51 UL1.38
LAN_LED2#: length 18.7
  TOP w0.508: JLAN.13 263.56,170.97 266.12,168.41 v1(266.12,167.31) 266.12,162.67 264.96,161.51 264.96,161.5 264.36,160.9 CL29.1 264.63,160.21 265.13,159.71 265.13,158.94 264.63,158.44 RL15.1
LAN_LED2#_R: length 10.1
  TOP w0.508: RL15.2 264.51,157.37 v2(264.99,157.37)
  BOTTOM w0.203: UL1.23 269.17,162.44 268.96,162.65 268.36,162.65
  BOTTOM w0.508: v2(264.99,157.37) 264.99,159.6 v1(265.15,159.76) 265.15,160.38 265.11,160.42 265.11,161.28 266.48,162.65 268.36,162.65
LAN_LINK#: length 21.9
  TOP w0.102: RL13.1 262.51,158.44 262.17,158.77 262.17,159.99 262.39,160.21 CL28.1 263.47,160.62 264.31,161.46 264.31,161.47 265.69,162.85 265.69,168.14 263.85,169.98 v1(262.8,169.98) 259.79,169.98 258.8,170.97 JLAN.11
LAN_LINK#_R: length 20.3
  TOP w0.102: v2(274.57,167.08) 274.33,166.84 RL4.2 275.05,166.4 277.06,164.39 277.06,163.73 277.55,163.24 277.55,163.09 278.58,162.06 v1(278.58,161.28) 278.58,160.65 276.08,158.14 270.94,158.14 QL3.2
  BOTTOM w0.102: v2(274.57,167.08) 274.14,166.65 274.04,166.65 273.8,166.41 UL1.39
LAN_MDIN0: length 38.6
  IN6 w0.076: v2(246.76,159.41) 246.73,159.41 246.48,159.16 246.48,158.77 247.18,158.08 253.34,158.08 254.16,157.26 264.44,157.26 264.75,156.95 271.42,156.95 272.16,156.21 274.66,156.21 275.02,156.57 275.02,156.86 274.82,157.05 v2(274.79,157.05)
  BOTTOM w0.089: v2(246.76,159.41) 246.74,159.41 246.42,159.08 246.42,158.51 246.51,158.42 247.02,158.42 247.11,158.33 TL1.11 ; UL1.12 273.8,160.29 273.88,160.21 273.88,158.24 274.6,157.52 274.87,157.52 274.96,157.43 274.96,157.22 v2(274.79,157.05)
LAN_MDIN1: length 31
  IN1 w0.076: v2(251.9,159.41) 251.82,159.41 251.71,159.29 251.71,159.24 251.53,159.07 251.53,158.99 252.42,158.11 265.95,158.11 266.97,157.08 271.06,157.08 271.78,156.36 273.12,156.36 273.18,156.42 273.18,156.58 v2(272.82,156.94)
  BOTTOM w0.089: UL1.15 272.6,160.34 272.68,160.27 272.68,158.4 272.9,158.18 272.9,157.02 v2(272.82,156.94) ; TL1.7 252.19,158.27 252.1,158.36 251.64,158.36 251.55,158.45 251.55,159.08 251.88,159.41 v2(251.9,159.41)
LAN_MDIN2: length 24.3
  IN6 w0.076: v2(270.07,158.3) 269.85,158.07 269.28,158.07 269.09,157.88 268.29,157.88 268.11,158.07 254.68,158.07 254.02,158.73 254.02,159.07 254.36,159.41 v2(254.38,159.41)
  BOTTOM w0.089: UL1.18 271.4,160.34 271.48,160.25 271.48,158.75 v4(271.05,158.32) 270.78,158.05 270.32,158.05 v2(270.07,158.3) ; TL1.5 254.73,158.21 254.58,158.36 254.14,158.36 254.04,158.46 254.04,159.08 254.36,159.41 v2(254.38,159.41)
LAN_MDIN3: length 16.5
  IN6 w0.076: v2(268.71,158.88) 259.37,158.88 259.29,158.96 259.29,159.24 v2(259.46,159.41)
  BOTTOM w0.089: UL1.21 269.91,161.64 269.3,161.64 268.82,161.15 268.82,158.98 v2(268.71,158.88) ; TL1.1 259.81,158.3 259.74,158.36 259.34,158.36 259.12,158.58 259.12,159.06 v2(259.46,159.41)
LAN_MDIP0: length 38.6
  IN6 w0.076: v2(275.38,157.05) 275.24,156.92 275.24,156.48 274.75,155.99 272.07,155.99 271.33,156.73 264.66,156.73 264.35,157.04 254.06,157.04 253.24,157.86 247.08,157.86 246.26,158.68 246.26,159.25 246.26,159.25 246.26,159.32 v2(246.18,159.41)
  BOTTOM w0.089: v2(275.38,157.05) 275.21,157.22 275.21,157.53 274.98,157.76 274.7,157.76 274.12,158.34 274.12,160.21 274.2,160.29 UL1.11 ; v2(246.18,159.41) 246.18,158.53 245.84,158.19 TL1.12
LAN_MDIP1: length 31
  IN1 w0.076: v2(251.31,159.41) 251.31,159.24 251.31,158.9 252.33,157.88 265.85,157.88 266.88,156.86 270.96,156.86 271.69,156.14 273.21,156.14 273.4,156.32 v2(273.4,156.94)
  BOTTOM w0.089: TL1.8 250.92,158.25 251.31,158.65 v2(251.31,159.41) ; v2(273.4,156.94) 273.14,157.2 273.14,158.28 272.92,158.5 272.92,160.21 273,160.29 UL1.14
LAN_MDIP2: length 24.2
  IN6 w0.076: v2(270.07,157.71) 269.94,157.85 269.94,157.84 269.37,157.84 269.19,157.66 268.2,157.66 268.02,157.84 254.59,157.84 253.8,158.63 v2(253.8,159.41)
  BOTTOM w0.089: v2(270.07,157.71) 270.17,157.81 270.88,157.81 271.73,158.65 271.73,160.26 271.8,160.34 UL1.17 ; TL1.6 253.46,158.25 253.8,158.59 v2(253.8,159.41)
LAN_MDIP3: length 16.4
  IN6 w0.076: v2(268.71,158.29) 268.35,158.65 259.28,158.65 259.07,158.86 259.07,159.22 v2(258.88,159.41)
  BOTTOM w0.089: TL1.2 258.54,158.31 258.88,158.66 v2(258.88,159.41) ; UL1.20 270.6,160.53 269.8,159.73 269.8,159.19 269.6,158.99 269.38,158.99 269.11,158.73 269.11,158.71 268.88,158.48 268.86,158.48 268.81,158.42 268.81,158.39 v2(268.71,158.29)
LCD_TEST: length 307.8
  TOP w0.107: JEDP.31 166.62,181.08 v2(166.94,180.76) ; UE5.72 295.94,10.84 295.84,10.94 295.84,15.24 295.96,15.36 295.96,18.77 296.36,19.17 v2(296.36,19.23)
  IN4 w0.102: v2(296.62,32.25) 296.2,31.83 292.65,31.83 291.92,31.1 284.53,31.1 283.38,32.25 276.64,32.25 274.89,30.5 269.1,30.5 266.09,27.49 265.2,27.49 264.21,26.5 261.4,26.5 259.83,24.92 258.4,24.92 257.85,25.47 257.85,25.55 256.19,27.21 248.7,27.21 247.81,28.1 247.81,29.4 246.92,30.29 243.29,30.29 241.63,31.96 241.63,35.11 238.35,38.38 236.69,38.38 235.35,39.73 233.81,39.73 232.45,41.09 232.05,41.49 230.78,41.49 229.97,41.49 229.23,40.76 227.19,40.76 226.81,40.38 224.32,40.38 223.25,41.44 219.08,41.44 219.04,41.41 219,41.41 218.97,41.37 218.94,41.37 218.59,41.01 218.59,40.96 218.41,40.78 214.19,40.78 213.89,41.09 211.73,41.09 210.52,42.3 210.52,43.56 209.35,44.73 209.22,44.86 208.87,44.86 207.88,45.86 203.14,45.86 193.07,55.93 189.75,55.93 188.41,57.27 187.02,57.27 186.31,57.98 186.31,62.32 186.52,62.53 186.52,62.91 189.35,65.74 189.35,68.55 188.88,69.03 188.88,69.98 188.19,70.67 188.19,78.1 187.63,78.66 187.63,82.15 187.97,82.48 187.97,95.27 185.24,98 185.24,100.85 185.11,100.98 185.11,105.38 185.19,105.46 185.19,108.36 186.27,109.45 186.27,110.99 186.79,111.5 186.79,115.9 187.96,117.07 187.96,120.94 193.56,126.54 193.56,127.14 194.17,127.75 194.17,128.54 194.8,129.17 194.8,147.22 194.26,147.76 191.31,150.71 191.31,152.63 189.86,154.08 189.86,156.21 188.42,157.65 185.17,157.65 184.65,158.17 182.32,158.17 180.56,159.92 178.98,159.92 178.67,160.24 177.1,160.24 175.52,161.83 170.72,161.83 170.05,162.5 170.05,170.51 169.43,171.13 169.43,174.73 168.16,176 168.16,179.54 v2(166.94,180.76)
  BOTTOM w0.102: v2(296.62,32.25) v1(296.62,31.65) 296.62,31.23 294.81,29.42 294.81,20.86 296.36,19.31 v2(296.36,19.23)
LDO2-CAP: length 5.2
  BOTTOM w0.203: CA28.1 32.55,26.68 31.98,27.25 v1(31.98,27.65) 31.98,28.15 32.02,28.19 UA1.22
  BOTTOM w0.254: RA12.2 32.28,24.5 32.71,24.93 CA29.1 32.71,26.49 CA28.1
LDO_EN: length 273.5
  TOP w0.102: v2(138.93,4.47) 139.21,4.19 v1(139.39,4.19) 140.04,4.19 DK3.3 139.7,5.06 v2(138.95,5.06) ; v2(319.73,62.03) 319.29,62.47 318.37,62.47 317.76,61.87 UE10.15
  IN6 w0.102: v2(311.6,45.01) 311.6,44.44 309.63,42.47 297.19,42.47 296.49,41.77 291.54,41.77 290.71,40.95 282.33,40.95 280.42,39.04 278.57,39.04 276.98,40.63 272.06,40.63 266.66,46.03 247.68,46.03 245.84,47.87 231.4,47.87 230.64,48.63 226.83,48.63 226.51,48.95 223.84,48.95 223.21,48.31 218.45,48.31 218,48.76 218,48.9 216.9,50 216.43,50 216.15,50.28 213.99,50.28 213.81,50.28 213.48,50.61 213.47,50.61 210.07,54.01 210.07,54.02 210.07,54.03 210.07,54.21 210.07,54.21 210.07,55.74 208.42,57.39 202.26,57.39 199.23,54.37 196.58,54.37 195.24,55.71 189.07,55.71 188.58,55.21 188.11,55.21 186.32,53.42 186.32,44.62 179.47,37.77 174.7,37.77 v2(174.25,38.22)
  BOTTOM w0.102: v2(138.93,4.47) 138.93,3.06 139.72,2.28 140.04,2.28 140.08,2.23 JPK.18 ; v2(319.73,62.03) 318.78,62.03 315.73,58.98 315.73,57.2 315.22,56.7 315.22,49.01 311.6,45.39 v2(311.6,45.01) ; v2(174.25,38.22) 174.2,38.27 147.96,38.27 144.09,34.41 132.53,34.41 127.77,29.65 127.77,21.96 131.23,18.5 131.23,13.8 138.18,6.85 138.18,5.71 138.83,5.06 v2(138.95,5.06)
LG_3V: length 16.4
  IN1 w1.016: 56.4,43.68 56.4,42.92 51,37.52 51,34.28 49.73,33.01 47.74,33.01
  BOTTOM w0.102: v2(55.57,45.21) 55.57,45.1 v1(56.21,44.47)
  vias: v2(46.17,33.26) v2(46.17,32.67) v2(55.13,45.65)
LG_5V: length 7.4
  TOP w0.102: v1(48.9,37.32) 48.46,37.32 v2(48.4,37.39)
  IN1 w1.016: 48.11,38.76 48.11,39.96 52.15,44
  vias: v2(47.95,37.84) v2(52.59,45.59) v2(52.59,44.95)
LG_+1VALWP: length 9.5
  IN1 w1.016: 247.58,19.66 249.08,19.66 250.26,18.48 253.87,18.48 255.8,20.41
  vias: v1(246.47,18.22) v2(246.69,19.21) v2(247.06,18.72) v2(256.55,21) v2(256.68,20.4)
LID_SW#: length 42.4
  TOP w0.102: DE1.1 312.88,23.87 v3(311.79,22.78)
  TOP w0.203: UE5.115 308.33,18.81 308.59,18.55 309.01,18.55 RE70.2 CE43.1
  TOP w0.254: JIO.20 326.99,21.16 327.28,21.44 327.28,22.74 326.78,23.23 326.78,27.17 326.08,27.87 v2(325.83,27.87) ; DE1.1 314.18,23.87 v2(314.65,24.34) ; CE43.1 308.55,19.53 v2(308.39,19.37)
  IN1 w0.254: v2(325.83,27.87) 325.84,27.86 325.84,27.5 325.47,27.13 324.15,27.13 323.07,28.21 322.08,28.21 321.84,28.45 317.44,28.45 315.17,26.18 315.17,24.86 v2(314.65,24.34) 314.13,23.82 314.13,22.53 313.38,21.78 313.38,19.57 311.96,18.15 309.81,18.15 308.59,19.37 v2(308.39,19.37)
LINE1_JD: length 39.2
  TOP w0.107: v2(39.56,31.81) 39.5,31.87 38.89,31.87 RA36.2
  IN2 w0.254: v2(39.56,31.81) 39.37,31.99 38.81,31.99 38.05,32.76 38.05,35.49 36.63,36.9 34,36.9 32.8,38.11 27.71,38.11 27.42,37.82 26.47,37.82 22.87,34.22 22.87,32.69 21.03,30.85 19.5,30.85 17.6,28.95 15.76,28.95 15.11,28.3 JACK2.5
  BOTTOM w0.102: v2(39.56,31.81) 39.56,32.32 v1(41,33.76)
LINE1_L:
  vias: v1(24.18,31.94)
LINE1_R:
  vias: v1(27.54,31.73)
LINE1_VREFO_L: length 11.5
  TOP w0.102: v2(27.78,34.18) 27.78,33.82 v1(27.56,33.59)
  TOP w0.254: v2(25.92,27.8) 25.92,28.12 25.66,28.37 RA41.1
  IN6 w0.203: v2(27.78,34.18) 25.75,34.18 25.18,33.6 25.18,28.99 25.92,28.25 v2(25.92,27.8)
  BOTTOM w0.203: UA1.40 27.85,34.11 v2(27.78,34.18)
LINE1_VREFO_R: length 12.2
  TOP w0.127: RA40.1 26.3,26.91 v1(26.39,26.83)
  TOP w0.254: RA40.1 25.29,26.99 v2(25.29,27.82)
  IN6 w0.254: v2(24.58,33.61) 24.67,33.52 24.67,28.86 25.29,28.24 v2(25.29,27.82)
  BOTTOM w0.203: UA1.39 28.22,33.71 28.21,33.7 24.67,33.7 v2(24.58,33.61)
LINE-IN-L: length 7
  TOP w0.254: RA38.1 22.84,22.52 v1(25.11,20.25) 25.35,20.01 v2(25.35,19.55)
  BOTTOM w0.254: v2(25.35,19.55) 25.35,19.35 RA35.2 25.99,18.6 25.41,18.6 25.14,18.86 LA9.2
LINE-IN-R: length 3.5
  TOP w0.102: v2(18.58,23.37) 18.16,23.37 v1(18.06,23.27)
  TOP w0.254: RA37.2 19.34,22.7 RA39.1 18.72,23.23 v2(18.58,23.37)
  BOTTOM w0.254: v2(18.58,23.37) 18.41,23.53 LA10.2
LOGO_LED_B_DRV#: length 17.9
  TOP w0.127: v2(232.48,158.19) v1(233.27,158.19)
  TOP w0.254: v2(232.48,158.19) 232.48,158.3 232.12,158.66 UE3.9
  TOP w0.508: v2(231,170.01) 230.72,169.73 229.62,169.73 228.92,169.02 JLOGO.8
  IN1 w0.508: v2(232.48,158.19) 232,158.67 232,162.42 230.77,163.65 230.77,165.78 231,166.01 v2(231,170.01)
LOGO_LED_G_DRV#: length 20.8
  TOP w0.127: JLOGO.7 227.92,166.83 v1(227.49,166.4)
  TOP w0.254: UE3.8 231.01,157.32 v2(231.36,156.96)
  TOP w0.508: JLOGO.7 227.92,170.18 v2(228.48,170.74)
  IN1 w0.508: v2(228.48,170.74) 228.48,169.35 228.97,168.86 228.97,166.14 230.01,165.1 230.01,163.51 231.36,162.16 v2(231.36,156.96)
LOGO_LED_R_DRV#: length 20.1
  TOP w0.127: v1(233.33,156.06) 232.85,156.54 230.95,156.54 v2(230.65,156.84)
  TOP w0.254: UE3.6 230.01,157.48 v2(230.65,156.84)
  TOP w0.508: JLOGO.6 226.92,169.21 226.82,169.31 v2(226.82,169.49)
  IN1 w0.508: v2(230.65,156.84) 230.65,157.9 229.87,158.69 229.87,161.6 229.37,162.1 229.37,164.84 228.32,165.89 228.32,167.81 226.82,169.31 v2(226.82,169.49)
LPC_AD0: length 105.7
  TOP w0.114: v2(300.27,20.31) 300.27,21.68 301.94,23.35 UE5.10
  IN6 w0.081: v2(300.27,20.31) 299.57,19.61 298.84,19.61 297.89,20.56 293.61,20.56 293.25,20.92 276.44,20.92 276.04,21.32 272.96,21.32 271.36,22.91 270.52,22.91 269.9,22.3 267.64,22.3 267.06,22.88 265.25,22.88 264.7,22.33 261,22.33 256.12,27.22 249.79,27.22 244.76,22.18 244.76,21.53 242.6,19.38 236.91,19.38 235.47,20.82 235.47,21.62 234.77,22.32 231.94,22.32 231,21.37 229.53,21.37 229.48,21.43 228.71,21.43 228.29,21.01 227.52,21.01 226.81,21.72 225.52,21.72 225.43,21.63 225.43,21.63 225.06,21.27 225.06,21.26 224.75,20.95 224.19,20.95 222.86,22.28 221.43,22.28 221.22,22.49 219.74,22.49 219.18,21.93
  IN6 w0.089: v2(213.86,21.99) 214.54,21.32 215.47,21.32 215.95,20.83 217.65,20.83 218.53,21.71 218.96,21.71 219.18,21.93
  BOTTOM w0.122: UH1.BB39 v2(213.86,21.99)
LPC_AD1: length 112.1
  TOP w0.089: v2(212.38,22.77) v1(212.38,22.2)
  TOP w0.114: UE5.8 302.74,23.53 300.68,21.47 300.68,20.16 301.04,19.8 301.04,19.52 301.49,19.08 v2(301.49,18.41)
  IN6 w0.081: 219.18,21.36 221.09,21.36 221.32,21.59 221.32,21.6 221.5,21.77 222.75,21.77 224.01,20.51 225,20.51 225.77,21.28 226.56,21.28 227.53,20.31 229.5,20.31 229.61,20.2 231.01,20.2 231.83,21.02 234.65,21.02 236.73,18.94 241.69,18.94 242.43,18.2 244.49,18.2 246.19,19.89 246.19,22.66 250.04,26.52 256.2,26.52 260.82,21.9 264.89,21.9 265.43,22.44 266.67,22.44 267.25,21.86 271.74,21.86 272.72,20.88 275.86,20.88 276.26,20.49 293.07,20.49 293.43,20.12 297.71,20.12 298.7,19.13 301.28,19.13 301.49,18.93 v2(301.49,18.41)
  IN6 w0.089: v2(212.38,22.77) 212.49,22.77 214.12,21.14 215.39,21.14 215.87,20.65 217.73,20.65 218.43,21.36 219.18,21.36
  BOTTOM w0.122: UH1.AW37 212.56,22.94 v2(212.38,22.77)
LPC_AD2: length 109.9
  TOP w0.114: UE5.7 303.14,23.59 301.11,21.55 v2(301.11,20.33)
  IN6 w0.081: v2(301.11,20.33) 300.46,20.98 293.79,20.98 293.42,21.34 276.61,21.34 276.21,21.74 273.13,21.74 271.5,23.36 270.63,23.36 270.37,23.36 269.8,22.79 268.04,22.79 267.53,23.3 265.08,23.3 264.53,22.75 261.65,22.75 260.36,24.04 260.36,26.96 259.74,27.58 257.01,27.58 255.78,28.81 252.38,28.81 251.36,27.79 249.78,27.79 249.56,27.58 249.29,27.58 245.27,23.56 244,23.56 240.22,19.79 237.08,19.79 235.91,20.97 235.91,21.77 234.94,22.74 229.96,22.74 229.35,22.13 224.52,22.13 223.36,23.3 220.23,23.3 219.18,22.25
  IN6 w0.089: 219.18,22.25 218.83,21.9 218.47,21.9 217.61,21.04 216.13,21.04 214.77,22.41 213.37,22.41 212.58,23.19 v2(212,23.19)
  BOTTOM w0.122: UH1.AV37 212,23.22 v2(212,23.19)
LPC_AD3: length 111.6
  TOP w0.114: v2(301.92,20.46) 301.92,20.46 301.92,21.7 303.94,23.72 UE5.5
  IN6 w0.081: 219.18,23.02 219.43,23.02 219.96,23.55 223.4,23.55 224.61,22.34 229.24,22.34 229.85,22.94 235.27,22.94 237.13,21.08 237.13,20.54 237.42,20.25 240.38,20.25 243.91,23.77 245.19,23.77 249.2,27.79 249.47,27.79 250.7,29.02 255.86,29.02 257.09,27.79 259.82,27.79 260.56,27.04 260.56,24.13 261.73,22.96 264.45,22.96 264.99,23.5 268.62,23.5 269.75,24.63 271.24,24.63 273.93,21.94 276.3,21.94 276.7,21.55 293.51,21.55 293.87,21.18 301.2,21.18 v2(301.92,20.46)
  IN6 w0.089: 219.18,23.02 218.74,23.02 218.53,22.81 218.53,22.23 218.2,21.9 216.8,21.9 216.35,21.45 216.04,21.45 214.89,22.6 213.56,22.6 212.92,23.23 212.92,23.61 v2(212.58,23.96)
  BOTTOM w0.122: v2(212.58,23.96) 212.87,23.66 212.87,23.24 UH1.BA38
