# Allegro board LAF551PR10-0221.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 159.02,30.28 159.02,26.77 158.58,26.33 154.87,26.33 154.64,26.55 154.64,27.56 154.83,27.75 157.16,27.75 157.33,27.92 157.33,29.23 157.14,29.42 154.9,29.42 154.69,29.63 154.69,31.33 154.87,31.51 157.78,31.51
GND on BOTTOM (solid shape): 236.85,155.88 236.85,152.99 236.51,152.64 232.74,152.64 232.42,152.96 231.4,152.96 229.85,154.52 229.85,155.53 230.07,155.76 231.58,155.76 232.07,156.24 236.49,156.24
GND on BOTTOM (solid shape): 241.09,153.5 241.09,152.52 241.12,152.49 241.12,152.45 241.12,152.44 241.12,151.37 240.96,151.22 239.5,151.22 239.44,151.28 239.44,152.36 239.5,152.42 240.58,152.42 240.77,152.61 240.77,153.47 240.87,153.57 241.02,153.57
GND on BOTTOM (solid shape): 252.62,130.69 252.62,125.99 253.24,125.36 253.24,122.57 253.18,122.51 250.34,122.51 250.2,122.64 250.19,122.64 250.03,122.8 250.03,125.03 247.65,127.41 247.65,130.27 248,130.62 250.03,130.62 250.44,131.02 252.28,131.02
GND on BOTTOM (solid shape): 254.93,153.61 254.93,152.55 254.9,152.55 254.9,152.51 254.9,152.51 254.9,151.45 254.74,151.3 253.28,151.3 253.22,151.36 253.22,152.44 253.28,152.5 254.36,152.5 254.55,152.69 254.55,153.64 254.64,153.74 254.8,153.74
GND on BOTTOM (solid shape): 149.73,117.26 149.73,117.07 149.35,116.7 149.35,115.95 149.29,115.89 149.03,115.89 148.91,116.02 148.91,116.65 148.53,117.03 148.53,117.22 148.65,117.35 148.84,117.35 148.99,117.21 149.26,117.21 149.42,117.37 149.61,117.37
GND on BOTTOM (solid shape): 165.62,172.82 165.62,171.19 165.81,171 167.27,171 167.39,170.87 167.39,169.47 167.33,169.41 165.17,169.41 165.03,169.55 165.03,172.8 165.16,172.93 165.52,172.93
GND on BOTTOM (solid shape): 139.55,117.18 139.74,117.18 139.95,117.38 140.11,117.38 140.27,117.22 140.27,117.03 139.89,116.65 139.89,116.02 139.76,115.89 139.51,115.89 139.44,115.95 139.44,116.66 139.06,117.05 139.06,117.24 139.2,117.38 139.35,117.38
GND on BOTTOM (solid shape): 144.31,117.18 144.51,117.18 144.71,117.38 144.87,117.38 145.03,117.22 145.03,117.03 144.65,116.65 144.65,116.02 144.52,115.89 144.27,115.89 144.21,115.95 144.21,116.66 143.82,117.05 143.82,117.24 143.96,117.38 144.11,117.38
GND on BOTTOM (solid shape): 146.66,117.18 146.86,117.18 147.06,117.38 147.22,117.38 147.35,117.26 147.35,117 147,116.65 147,116.02 146.87,115.89 146.62,115.89 146.56,115.95 146.56,116.66 146.17,117.05 146.17,117.24 146.31,117.38 146.46,117.38
GND on BOTTOM (solid shape): 152.07,117.24 152.07,117.05 151.7,116.67 151.7,115.95 151.64,115.89 151.38,115.89 151.26,116.02 151.26,116.65 150.87,117.03 150.87,117.22 151,117.35 151.19,117.35 151.34,117.21 151.59,117.21 151.77,117.38 151.94,117.38
GND on BOTTOM (solid shape): 191.92,112.4 191.92,110.78 192.41,110.29 193.04,110.29 193.13,110.19 195.36,110.19 195.4,110.15 195.4,109.57 195.28,109.45 191.54,109.45 191.12,109.87 191.12,112.37 191.22,112.47 191.85,112.47
GND on BOTTOM (solid shape): 221.47,130.9 221.68,130.83 221.89,130.89 221.9,130.9 222.04,130.9 222.19,130.74 222.19,129.91 222.1,129.82 220.96,129.82 220.89,129.88 220.89,130.83 220.96,130.9
GND on BOTTOM (solid shape): 141.9,117.18 142.09,117.18 142.1,117.19 142.12,117.19 142.32,117.38 142.46,117.38 142.62,117.22 142.62,117.03 142.24,116.65 142.24,116.02 142.11,115.89 141.86,115.89 141.79,115.95 141.79,116.66 141.41,117.05 141.41,117.24 141.55,117.38 141.7,117.38
GND on BOTTOM (solid shape): 198.87,186.77 200.3,185.5 200.67,185.28 201.1,185.2 205.72,185.2 205.72,178.5 198.72,178.5 198.72,186.91
GND on BOTTOM (solid shape): 23.57,46.41 23.57,44.57 23.82,44.31 23.82,41.01 22.87,40.06 21.73,40.06 21.54,40.25 21.54,40.95 22.23,41.65 22.23,43.42 21.28,44.38 21.28,45.77 21.66,46.16 21.92,46.16 22.11,46.35 22.11,47.01 22.2,47.11 22.87,47.11
GND on BOTTOM (solid shape): 264.11,155.64 264.11,153.21 263.67,152.77 260.23,152.77 259.91,153.09 258.9,153.09 257.63,154.36 257.33,154.36 257.15,154.55 257.15,154.98 257.26,155.1 259.68,155.1 259.95,155.36 262.15,155.36 262.34,155.55 262.34,156 262.45,156.11 263.64,156.11
GND on BOTTOM (solid shape): 79.24,21.12 79.84,21.12 80.07,20.9 80.07,19.82 80.21,19.68 81.29,19.68 81.73,19.23 81.73,12.37 81.48,12.12 75.07,12.12 74.94,12.25 74.94,19.04 75.07,19.17 75.68,19.17 76.15,19.63 76.15,20.82 76.44,21.12 79.24,21.12
GND on BOTTOM (solid shape): 86.47,36.19 86.56,36.19 87.19,35.55 87.19,30.15 87.54,29.8 88.63,29.8 88.72,29.72 88.72,29.2 88.65,29.14 87.19,29.14 86.37,29.96 81.48,29.96 81.29,30.15 81.29,33.33 81.43,33.47 82.95,33.47 83.83,34.34 83.83,35.8 84.3,36.27 86.38,36.27
GND on BOTTOM (solid shape): 160.99,163.91 161.03,163.89 161.09,163.87 161.86,163.1 161.86,159.54 161.48,159.16 158.71,159.16 158.07,158.52 156.7,158.52 155.91,159.31 152.84,159.31 152.36,159.79 152.36,162.79 153.45,163.88 154.24,163.88 155.81,162.31 157.82,162.31 158.71,163.2 159.77,163.2 160.49,163.91
GND on BOTTOM (solid shape): 163.27,144.23 163.27,143.92 163.9,143.28 163.9,142.36 163.71,142.17 163.71,139.55 163.51,139.35 161.53,139.35 161.4,139.47 161.4,142.29 161.18,142.52 157.47,142.52 157.44,142.55 157.44,143.61 157.49,143.67 158.1,143.67 158.1,143.66 158.23,143.66 158.28,143.71 158.28,144.48 158.35,144.55 162.95,144.55
GND on BOTTOM (solid shape): 172.07,144.94 172.07,143.5 172.6,142.97 172.6,140.07 172.21,139.68 170.27,139.68 169.22,140.73 169.22,142.11 168.88,142.46 165.1,142.46 165.08,142.47 165.08,143.56 165.16,143.64 165.82,143.64 165.87,143.69 165.87,144.39 166.01,144.52 169.73,144.52 170.01,144.81 170.01,144.91 170.19,145.09 171.92,145.09
GND on BOTTOM (solid shape): 9.57,68.1 1.27,68.1 1.27,73.9 1.49,74.45 2.03,74.7 2.07,74.7 9.57,74.7
GND on BOTTOM (solid shape): 162.28,172.54 162.28,169.23 162.62,168.89 163.38,168.89 163.83,168.44 163.83,168.1 163.72,167.99 162.79,167.99 162.62,167.82 161.23,167.82 161.18,167.86 161.18,168.17 161.03,168.32 160.67,168.32 160.47,168.51 160.47,169.47 160.91,169.9 160.91,172.56 161.02,172.67 162.14,172.67
GND on BOTTOM (solid shape): 213.83,154.05 213.82,153.97 213.81,153.93 213.82,153.88 213.83,153.81 213.75,153.72 213.75,152.38 213.75,151.37 213.56,151.18 212.1,151.18 212.04,151.25 212.04,152.33 212.1,152.39 213.18,152.39 213.37,152.58 213.37,154.04 213.5,154.17 213.71,154.17
GND on BOTTOM (solid shape): 227.6,154.11 227.6,153.78 227.4,153.59 227.4,151.31 227.24,151.15 225.78,151.15 225.72,151.22 225.72,152.3 225.78,152.36 226.86,152.36 227.05,152.55 227.05,153.79 227.07,153.89 227.06,153.98 227.06,154.01 227.18,154.14 227.19,154.14 227.22,154.17 227.54,154.17
GND on BOTTOM (solid shape): 14.74,58.41 14.74,56.54 14.66,56.32 14.74,56.09 14.74,56.06 14.68,56 13.53,56 13.15,56.38 13.15,57.38 13.15,57.46 12.96,57.65 12.96,59.23 12.96,59.43 13.09,59.55 13.6,59.55
GND on BOTTOM (solid shape): 146.92,147.1 147.87,147.1 148.5,146.46 148.5,143.48 148.6,143.39 148.6,142.09 148.57,142.07 148.57,141.25 148.41,141.09 146.63,141.09 146.03,141.69 146.03,145.25 145.77,145.5 142.09,145.5 142.09,146.76 142.15,146.82 142.86,146.82 142.91,146.87 142.91,147.59 143,147.68 146.34,147.68
GND on BOTTOM (solid shape): 154.73,147.12 155.43,147.12 155.71,146.84 155.71,144.02 156.01,143.72 156.01,141.84 155.84,141.66 153.93,141.66 153.63,141.96 153.63,145.47 153.53,145.57 149.72,145.57 149.67,145.62 149.67,146.71 149.72,146.76 150.48,146.76 150.55,146.84 150.55,147.42 150.54,147.44 150.54,147.64 150.59,147.69 154.16,147.69
GND on BOTTOM (solid shape): 158.48,117.2 158.67,117.2 158.7,117.22 158.75,117.22 158.88,117.35 159.07,117.35 159.19,117.22 159.19,117.03 158.81,116.65 158.81,116.02 159.21,115.62 159.21,115.43 159.08,115.3 158.32,115.3 158.19,115.43 158.19,115.89 158.37,116.07 158.37,116.63 157.97,117.02 157.97,117.24 158.11,117.38 158.3,117.38
GND on BOTTOM (solid shape): 92,47.74 92,46.83 92.08,46.76 92.48,46.76 92.59,46.86 92.59,47.76 92.63,47.8 92.74,47.8 92.8,47.74 92.8,46.9 92.97,46.73 93.48,46.73 93.55,46.65 93.55,44.96 93.48,44.89 91.89,44.89 91.83,44.95 91.83,46.66 91.77,46.73 91.77,47.74 91.83,47.81 91.94,47.81
GND on BOTTOM (solid shape): 179.92,143.49 179.92,138.76 179.56,138.41 179,138.41 178.88,138.53 178.88,140.16 178.67,140.36 178.06,140.36 177.96,140.47 177.96,141.91 177.77,142.1 174,142.1 173.87,142.23 173.87,143.15 173.97,143.25 174.38,143.25 174.61,143.48 174.61,143.98 174.76,144.14 179.27,144.14
GND on BOTTOM (solid shape): 252.18,30.95 252.18,28.15 252.46,27.87 253.13,27.87 255.27,27.87 255.27,27.87 256.42,27.87 256.55,27.74 256.55,27.3 256.29,27.04 256.29,25.64 256.36,25.58 256.36,25.53 256.61,25.27 256.61,24.31 256.42,24.12 254.77,24.12 254.26,24.63 254.07,24.63 253.56,24.63 250.33,27.87 250.33,30.88 250.55,31.11 252.03,31.11
GND on BOTTOM (solid shape): 229.77,44.2 229.77,43.15 230.22,42.7 230.22,39.82 230.64,39.4 230.64,36.63 230.5,36.49 228.56,36.49 228.34,36.71 228.34,37.52 228.52,37.7 228.85,37.7 228.95,37.8 228.95,39.37 229.46,39.88 229.46,41.16 229.11,41.51 229.11,42.8 229.49,43.18 229.49,44.21 229.55,44.28 229.69,44.28
GND on BOTTOM (solid shape): 246.39,40.95 246.39,40.25 246.2,40.06 245.15,40.06 245.14,40.06 244.99,40.1 244.84,40.06 244.83,40.06 244.26,40.06 244.25,40.06 244.1,40.1 243.95,40.06 243.92,40.05 243.79,40.19 243.79,40.21 243.79,40.95 243.91,41.07 246.26,41.07
GND on BOTTOM (solid shape): 161.57,117.25 161.57,117.06 161.16,116.65 161.16,115.95 161.37,115.75 161.5,115.75 161.62,115.62 161.62,115.43 161.56,115.37 160.67,115.37 160.61,115.43 160.61,115.91 160.72,116.02 160.72,116.65 160.34,117.03 160.34,117.22 160.46,117.35 160.65,117.35 160.78,117.22 160.93,117.22 161.07,117.22 161.23,117.38 161.44,117.38
GND on BOTTOM (solid shape): 186.72,178.5 179.72,178.5 179.72,185.4 180.55,185.4 180.87,185.25 181.22,185.2 183.1,185.2 184.34,185.2 184.77,185.28 185.14,185.5 186.57,186.77 186.6,186.8 186.72,186.91
GND on BOTTOM (solid shape): 226.55,130.9 226.77,130.83 226.98,130.9 227.18,130.9 227.34,130.74 227.34,129.91 227.24,129.82 226.1,129.82 226.04,129.88 226.04,130.72 226.07,130.8 226.14,130.83 226.25,130.84 226.34,130.9
GND on BOTTOM (solid shape): 242.01,45.45 242.01,45.38 242.01,43.69 242.52,43.18 242.52,41.86 242.4,41.74 242.4,40.89 242.64,40.64 242.64,39.64 242.5,39.5 241.57,39.5 241.44,39.64 241.44,40.59 241.69,40.84 241.69,41.72 241.29,42.12 241.29,43.49 241.63,43.83 241.63,45.45 241.71,45.54 241.92,45.54
GND on BOTTOM (solid shape): 244.35,100.14 244.72,100.14 244.78,100.21 244.98,100.21 245.07,100.12 245.38,100.12 245.48,100.22 245.68,100.22 245.75,100.16 245.75,99.93 245.67,99.85 245.5,99.85 245.4,99.95 245.05,99.95 244.96,99.86 244.81,99.86 244.73,99.94 244.32,99.94 244.18,99.8 243.51,99.8 243.26,99.55 243.01,99.55 242.58,99.98 242.58,100.12 242.7,100.23 242.82,100.23 242.95,100.1 243.28,100.1 243.45,100.27 244.22,100.27
GND on BOTTOM (solid shape): 20.2,55.22 20.2,53.08 20.96,52.31 20.96,51.11 20.9,51.04 19.69,51.04 19.5,50.85 18.6,50.85 18.18,50.44 16.37,50.44 15.57,51.24 15.57,52 16.39,52.82 16.39,53.46 16.14,53.71 16.14,55.17 16.2,55.24 17.09,55.24 17.22,55.11 18.3,55.11 18.31,55.1 18.96,55.1 19.31,55.45 19.97,55.45
GND on BOTTOM (solid shape): 57.6,25.98 57.6,25.45 57.73,25.33 58.94,25.33 59.38,25.77 59.89,25.77 59.95,25.71 59.95,24.18 59.7,23.93 58.94,23.93 58.75,23.74 58.75,22.62 58.47,22.34 55.63,22.34 55.41,22.57 55.41,23.26 55.89,23.74 55.89,24.76 55.7,24.95 55.38,24.95 54.94,25.38 54.94,25.97 55,26.03 57.56,26.03
GND on BOTTOM (solid shape): 163.1,117.31 163.14,117.27 163.19,117.22 163.29,117.22 163.45,117.22 163.57,117.35 163.77,117.35 163.89,117.22 163.89,117.03 163.51,116.65 163.51,115.41 163.4,115.3 163.08,115.3 162.98,115.4 162.98,115.58 162.98,116.73 162.7,117.01 162.7,117.28 162.82,117.4 163.01,117.4
GND on BOTTOM (solid shape): 122.14,123.16 122.14,120.55 121.7,120.11 121.7,119.5 121.73,119.47 121.73,119.23 122.19,118.77 122.19,117.56 121.76,117.13 121.76,116.01 121.93,115.85 121.93,115.55 121.87,115.49 121.53,115.49 121.46,115.56 121.46,117.13 121.01,117.58 121.01,120.25 120.95,120.31 120.88,120.61 120.66,120.84 120.66,123.14 120.86,123.35 121.95,123.35
GND on BOTTOM (solid shape): 213.63,150.87 216.54,150.87 216.86,150.55 216.86,149.98 217.24,149.6 221.88,149.6 222.58,148.9 223.88,148.9 223.97,148.81 223.97,148.24 223.91,148.18 223.91,142.45 223.97,142.39 223.97,140.77 223.72,140.52 219.33,140.52 219.11,140.73 219.11,146.69 218.81,146.99 217.5,146.99 215.85,148.64 212.16,148.64 212.04,148.77 212.04,149.85 212.16,149.98 212.8,149.98 212.86,150.04 212.86,150.76 212.97,150.87 213.62,150.87
GND on BOTTOM (solid shape): 224.65,130.9 224.86,130.83 225.07,130.9 225.28,130.9 225.38,130.84 225.49,130.83 225.56,130.8 225.59,130.72 225.59,129.88 225.53,129.82 224.45,129.82 224.26,130.01 224.26,130.77 224.33,130.84 224.39,130.87 224.44,130.9
GND on BOTTOM (solid shape): 37.89,22.24 38.24,21.99 38.58,22.24 38.59,22.28 39.06,22.28 39.32,22.03 39.32,19.61 38.92,19.22 37.12,19.22 37.07,19.17 33.28,19.17 33.16,19.29 33.16,19.99 33.22,20.06 34.24,20.06 34.49,20.31 34.49,21.96 34.81,22.28 37.88,22.28
GND on BOTTOM (solid shape): 216.19,18.11 217.23,18.11 217.48,17.86 217.48,17.48 217.42,17.41 217.4,17.41 217.3,17.37 217.21,17.3 216.96,17.3 216.73,17.39 216.51,17.3 216.06,17.3 215.78,17.58 215.78,17.6 215.77,17.66 215.74,17.72 215.74,17.85 215.73,17.87 215.73,18.22 215.78,18.27 216.04,18.27
GND on BOTTOM (solid shape): 244.23,150.61 244.23,150.1 244.55,149.79 249.63,149.79 249.88,149.53 251.32,149.53 251.44,149.42 251.44,148.64 251.21,148.42 250.68,148.42 249.88,147.62 249.88,146.93 249.56,146.61 249.56,145.91 249.69,145.79 251.21,145.79 251.66,145.34 251.66,141.77 251.23,141.34 246.83,141.34 246.64,141.53 246.64,146.48 246.07,147.06 245.16,147.06 243.4,148.82 239.43,148.82 239.4,148.85 239.4,149.91 239.53,150.04 240.17,150.04 240.23,150.1 240.23,150.8 240.36,150.93 243.91,150.93
GND on BOTTOM (solid shape): 258.01,150.68 258.01,150.3 258.52,149.79 263.2,149.79 263.64,149.36 263.64,148.03 263.97,147.7 265.39,147.7 265.46,147.63 265.46,146.54 265.31,146.38 264.31,146.38 264.14,146.21 264.14,141.61 264.02,141.49 260.23,141.49 260.1,141.62 260.1,142.58 260.23,142.7 260.23,146.7 259.81,147.12 258.97,147.12 257.24,148.85 253.23,148.85 253.18,148.9 253.18,149.98 253.31,150.1 253.95,150.1 254.01,150.17 254.01,150.87 254.14,150.99 257.69,150.99
GND on BOTTOM (solid shape): 187.84,149.99 187.84,148.16 188.51,147.48 188.51,144.36 188.1,143.95 188.1,137.09 187.71,136.71 185.48,136.71 185.07,137.11 185.07,142.04 184.82,142.29 184.01,142.29 183.98,142.27 181.31,142.27 181.21,142.37 181.21,143.36 181.22,143.36 181.67,143.36 181.67,143.44 181.9,143.44 182,143.54 182,144.17 182.21,144.38 183.01,144.38 183.02,144.38 186.17,144.38 186.17,144.37 187.02,144.37 187.63,144.98 187.63,146.75 186.66,147.71 186.24,147.71 186.17,147.79 186.17,148.42 186.34,148.59 186.34,149.89 186.46,150.02 187.82,150.02
GND on BOTTOM (solid shape): 154.46,117.25 154.46,117 154.4,116.94 154.36,116.86 154.35,116.85 154.13,116.63 154.13,116.13 153.92,115.92 153.64,115.92 153.4,116.16 153.4,116.79 153.34,116.85 153.33,116.87 153.29,116.94 153.22,117 153.19,117.02 153.19,117.21 153.33,117.35 153.6,117.35 153.66,117.28 153.72,117.24 153.91,117.22 154.06,117.33 154.11,117.38 154.34,117.38
GND on BOTTOM (solid shape): 263.57,20.74 263.57,20.45 263.66,20.36 263.66,20.35 263.67,20.35 263.77,20.25 265.66,20.25 266.35,19.55 266.29,19.35 266.36,19.15 266.36,19.12 266.52,18.96 266.52,18.43 266.36,18.27 266.36,15.97 266.01,15.62 266.01,13.9 265.04,12.93 262.71,12.93 262.39,13.25 262.39,15.61 262.58,15.8 262.89,15.8 262.93,15.83 262.97,15.86 263.02,15.92 263.05,15.98 263.13,16.06 263.13,16.68 262.9,16.91 261.43,16.91 261.33,17.01 261.33,19.61 261.44,19.73 262.78,19.73 263.07,20.01 263.07,20.74 263.18,20.85 263.46,20.85
GND on BOTTOM (solid shape): 154.98,102.59 154.98,102.36 154.78,102.15 154.76,102.15 154.7,102.14 154.64,102.11 154.63,102.11 154.56,102.11 154.54,102.08 154.54,101.98 154.54,101.98 154.52,101.9 154.54,101.82 154.54,101.81 154.54,101.76 154.56,101.74 154.56,101.5 154.46,101.39 154.27,101.39 154.24,101.36 154.23,101.36 154.09,101.28 154.02,101.15 154.01,101.13 153.97,101.09 153.76,101.09 153.68,101.18 153.68,101.4 153.68,101.41 153.72,101.57 153.68,101.73 153.68,101.74 153.68,101.94 154.23,102.5 154.42,102.5 154.61,102.69 154.88,102.69
GND on BOTTOM (solid shape): 16.58,33.77 16.58,32.38 14.75,30.54 1.27,30.54 1.27,31.9 1.51,32.46 2.07,32.7 11.68,32.7 12.45,32.2 13.05,32.9 13.05,33.65 13.37,33.96 16.39,33.96
GND on BOTTOM (solid shape): 180.4,172.96 180.4,172.17 180.02,171.79 180.02,171.42 180,171.4 179.68,171.4 179.65,171.43 179.65,171.87 179.56,171.96 178.95,171.96 178.86,171.88 178.86,170.39 179.08,170.17 179.08,170.08 179.09,170.07 179.72,170.07 179.78,170.12 179.78,170.3 179.87,170.39 180.06,170.39 180.29,170.17 180.29,169.35 180.16,169.22 180.01,169.22 179.9,169.22 179.76,169.36 179.76,169.37 179.65,169.47 179.27,169.47 178.82,169.92 178.57,169.92 178.44,170.04 178.44,170.68 178.25,170.87 178.25,172.48 178.31,172.54 178.35,172.62 178.82,173.09 179.1,173.09 179.16,173.16 180.21,173.16
GND on BOTTOM (solid shape): 30.3,15.04 30.3,14.53 30.93,13.9 32.65,13.9 33.42,14.67 36.64,14.67 37.02,14.28 37.02,13.66 36.81,13.44 36.52,13.44 36.33,13.25 36.33,10.82 36.13,10.61 36.13,9.87 36.9,9.1 37.07,9.1 37.16,9.01 37.16,8.13 37.15,8.12 36.46,8.12 36.2,8.37 34.3,8.37 34.17,8.5 33.28,8.5 32.97,8.18 31.44,8.18 31,8.63 30.49,8.63 30.11,9.01 29.35,9.01 29.28,9.07 29.28,9.71 29.35,9.77 30.11,9.77 30.17,9.83 30.17,11.1 29.92,11.36 29.54,11.36 29.42,11.47 29.42,12.18 29.92,12.68 29.92,13.26 29.79,13.39 29.03,13.39 28.96,13.45 28.96,14.98 29.22,15.23 30.11,15.23
GND on BOTTOM (solid shape): 93.29,28.85 93.29,26.6 93.8,26.09 97.52,26.09 97.68,25.92 97.68,23.3 97.56,23.18 94.76,23.18 94.58,23.36 89.99,23.36 89.8,23.55 89.8,23.96 93.38,23.96 93.38,23.9 93.39,23.85 93.4,23.8 93.43,23.75 93.46,23.71 93.49,23.67 93.53,23.64 93.58,23.61 93.63,23.59 93.68,23.58 93.73,23.57 93.79,23.58 93.84,23.59 93.89,23.61 93.94,23.64 93.98,23.67 94.01,23.71 94.04,23.75 94.07,23.8 94.08,23.85 94.09,23.9 94.09,23.96 94.08,24.01 94.07,24.06 94.04,24.11 94.01,24.15 93.98,24.19 93.94,24.22 93.89,24.25 93.84,24.27 93.79,24.28 93.73,24.29 93.68,24.28 93.63,24.27 93.58,24.25 93.53,24.22 93.49,24.19 93.46,24.15 93.43,24.11 93.4,24.06 93.39,24.01 93.38,23.96 89.8,23.96 89.8,28.76 90.18,29.14 93,29.14
GND on BOTTOM (solid shape): 230.51,150.55 230.51,150.04 230.83,149.72 235.97,149.72 236.22,149.48 237.61,149.48 237.67,149.42 237.67,145.95 237.75,145.86 237.75,142.98 237.57,142.68 237.75,142.37 237.75,142.09 237.66,141.85 237.75,141.61 237.75,141.14 237.71,141.02 237.71,140.89 237.72,140.86 237.5,140.64 233.05,140.64 232.86,140.83 232.86,146.45 232.32,146.99 231.49,146.99 229.84,148.64 225.81,148.64 225.69,148.77 225.69,149.85 225.81,149.98 226.45,149.98 226.51,150.04 226.51,150.74 226.64,150.87 230.2,150.87
GND on BOTTOM (solid shape): 235.07,100.92 235.14,100.89 235.17,100.86 235.2,100.83 235.25,100.75 235.2,100.67 235.13,100.6 235.07,100.5 235.07,100.5 234.97,100.35 234.95,100.33 234.94,100.32 234.86,100.26 234.79,100.18 234.79,100.17 234.65,100.03 234.63,100.02 234.5,99.96 234.39,99.85 233.09,99.85 232.89,99.64 232.88,99.64 232.79,99.59 232.72,99.53 232.54,99.53 232.24,99.83 231.52,99.83 231.37,99.97 231.37,100.15 231.49,100.27 234.29,100.27 234.49,100.47 234.5,100.48 234.58,100.54 234.64,100.62 234.65,100.63 234.79,100.77 234.81,100.78 234.91,100.82 235,100.89
GND on BOTTOM (solid shape): 241.44,100.93 242.19,100.93 242.29,100.83 242.29,100.65 242.19,100.55 241.29,100.55 241.14,100.7 240.92,100.7 240.77,100.55 239.39,100.55 239.19,100.34 239.18,100.34 239.06,100.26 238.98,100.14 238.98,100.13 238.88,100.03 238.86,100.03 238.73,99.98 238.62,99.89 238.55,99.86 238.48,99.88 238.44,99.91 238.4,99.94 238.37,99.95 238.37,100.1 238.4,100.11 238.5,100.19 238.57,100.3 238.57,100.3 238.66,100.45 238.7,100.48 238.78,100.54 238.84,100.62 238.85,100.63 238.99,100.77 239.01,100.78 239.16,100.85 239.26,100.97 240.59,100.97 240.79,101.17 240.88,101.23 240.93,101.3 241.07,101.3
GND on BOTTOM (solid shape): 138.52,64.14 138.52,63.17 138.24,62.89 130.47,62.89 130.47,63.07 130.39,63.15 130.39,63.17 129.96,63.46 129.69,63.02 129.68,62.93 129.59,62.89 119.97,62.89 119.97,62.99 119.88,63.08 119.88,63.1 119.48,63.39 119.17,63.01 119.15,62.93 119.07,62.89 111.16,62.89 110.55,63.5 110.55,65 110.7,65.15 137.5,65.15
GND on BOTTOM (solid shape): 9.57,49.3 1.31,49.3 1.6,49.7 2.07,49.85 2.27,49.85 3.12,50.2 3.47,51.05 3.47,53.55 3.12,54.4 2.27,54.75 2.07,54.75 1.51,54.99 1.27,55.55 1.27,56.1 9.57,56.1
GND on BOTTOM (solid shape): 176.79,65.46 176.79,63.17 176.46,62.84 173.97,62.84 173.97,62.98 173.42,63.54 173.29,63.54 172.81,63.5 172.81,63.01 172.83,62.9 172.74,62.84 163.47,62.84 163.47,63.2 163.93,63.66 164.32,63.66 164.89,63.94 164.32,64.22 163.7,64.22 162.91,63.43 162.91,62.84 155.71,62.84 155.23,63.33 155.23,65.23 155.89,65.89 176.36,65.89
GND on BOTTOM (solid shape): 219.81,114.19 220.06,114.06 220.31,114.19 220.59,114.19 220.77,114.13 220.95,114.19 221.29,114.19 221.31,114.18 221.36,114.09 221.31,114.01 221.21,113.88 221.18,113.73 221.15,113.65 221.08,113.62 220.93,113.58 220.83,113.47 220.61,113.47 220.44,113.61 220.22,113.57 220.18,113.54 219.89,113.83 219.6,113.83 219.47,113.96 219.44,114.03 219.47,114.1 219.51,114.14 219.53,114.19
GND on BOTTOM (solid shape): 236.19,101.32 236.25,101.23 236.34,101.17 236.35,101.16 236.44,101.07 236.44,101.06 236.54,100.87 236.73,100.77 236.74,100.77 236.88,100.63 236.89,100.62 236.95,100.53 237.04,100.47 237.05,100.46 237.29,100.22 237.91,100.22 237.98,100.15 238.06,100.09 238.09,100.08 238.09,99.97 238.06,99.96 237.99,99.91 237.93,99.86 237.11,99.86 237.05,99.91 236.97,99.96 236.76,100.17 236.75,100.18 236.69,100.27 236.6,100.33 236.59,100.34 236.37,100.56 235.75,100.56 235.7,100.62 235.64,100.67 235.6,100.75 235.64,100.83 235.74,100.93 235.8,101.06 235.8,101.07 235.89,101.16 236.01,101.25 236.05,101.32 236.06,101.34 236.18,101.34
GND on BOTTOM (solid shape): 233.63,84.95 233.72,84.91 233.84,84.81 233.99,84.78 234.07,84.75 234.1,84.67 234.17,84.47 234.37,84.38 234.39,84.38 234.51,84.26 234.45,84.21 234.42,84.21 234.2,84.16 234.1,83.95 234.1,83.93 233.84,83.67 233.84,83.17 233.64,82.98 233.5,83.12 233.5,83.52 233.2,83.82 233.22,83.85 233.23,83.89 233.24,83.94 233.26,84 233.32,84.04 233.58,84.28 233.45,84.62 233.4,84.7 233.45,84.78 233.5,84.83 233.55,84.9
GND on BOTTOM (solid shape): 250.42,84.92 250.5,84.89 250.63,84.79 250.79,84.77 250.87,84.74 250.9,84.66 250.97,84.47 251.17,84.38 251.19,84.38 251.31,84.26 251.25,84.21 251.22,84.21 251,84.16 250.9,83.95 250.9,83.93 250.64,83.67 250.64,83.17 250.44,82.98 250.3,83.12 250.3,83.52 250,83.82 250.02,83.85 250.03,83.89 250.04,83.94 250.06,84 250.12,84.04 250.38,84.28 250.24,84.62 250.2,84.7 250.24,84.79 250.29,84.83 250.34,84.88
GND on BOTTOM (solid shape): outline of 96 points within 102.69,49.58 107.26,55.05
GND on BOTTOM (solid shape): 220.19,97.75 220.23,97.72 220.27,97.7 220.32,97.66 220.33,97.59 220.63,97.2 220.95,97.58 220.94,97.61 221.02,97.69 221.08,97.68 221.16,97.65 221.18,97.57 221.2,97.44 221.27,97.32 221.29,97.25 221.26,97.18 221.17,97.06 221.14,96.92 221.12,96.85 221.05,96.82 220.88,96.73 220.8,96.56 220.8,96.53 220.68,96.41 220.63,96.47 220.63,96.5 220.58,96.72 220.37,96.82 220.35,96.82 220.09,97.08 219.59,97.08 219.43,97.25 219.43,97.31 219.54,97.42 219.86,97.42
GND on BOTTOM (solid shape): outline of 98 points within 260.93,24.76 270.06,37.07
GND on BOTTOM (solid shape): 253.03,91.78 253.02,91.75 253.06,91.49 253.29,91.38 253.32,91.39 253.54,91.17 253.56,91.17 253.56,90.61 253.42,90.47 253.36,90.5 253.3,90.55 253.29,90.61 252.96,90.97 252.66,90.59 252.67,90.56 252.62,90.51 252.56,90.52 252.48,90.55 252.46,90.63 252.44,90.77 252.36,90.89 252.33,90.96 252.35,91.03 252.42,91.15 252.44,91.27 252.47,91.35 252.76,91.46 252.84,91.67 252.83,91.7 252.97,91.84
GND on BOTTOM (solid shape): outline of 107 points within 218.18,156.6 222.74,160.38
GND on BOTTOM (solid shape): 228.55,101.23 228.67,101.13 228.89,101.13 229.07,101.3 229.21,101.3 229.28,101.21 229.38,101.16 229.39,101.15 229.47,101.15 229.52,101.15 230.12,101.15 230.12,101.15 230.29,101.17 230.42,101.27 230.62,101.27 230.7,101.2 230.81,101.15 230.82,101.15 231.07,100.9 231.07,100.62 230.99,100.55 230.85,100.55 230.52,100.73 230.19,100.55 230.02,100.55 229.92,100.65 229.69,100.65 229.57,100.53 229.46,100.53 229.17,100.73 228.84,100.61 228.77,100.58 228.7,100.61 228.35,100.73 227.97,100.5 227.87,100.6 227.87,100.9 228.12,101.15 228.13,101.15 228.25,101.21 228.33,101.3 228.49,101.3
GND on BOTTOM (solid shape): 121.88,148.47 121.88,147.5 121.83,147.45 121.82,147.45 121.61,147.2 121.69,146.88 121.7,146.87 121.7,146.79 121.69,146.77 121.64,146.38 121.98,146.18 122,146.18 122.11,146.08 122.46,146.08 122.59,145.95 122.59,144.94 123.05,144.48 123.81,144.48 123.83,144.5 123.91,144.5 123.91,145.16 124.29,145.55 125.13,145.55 125.46,145.88 126.04,145.88 126.15,145.77 126.15,145.14 126.22,145.06 126.63,145.06 126.88,144.81 126.88,143.54 126.98,143.44 127.57,143.44 127.62,143.39 127.62,142.73 127.52,142.62 126.98,142.62 126.91,142.55 126.91,142.47 126.88,142.47 126.88,141.76 126.91,141.76 126.91,140.92 126.96,140.87 127.64,140.87 127.75,140.77 127.75,140.08 127.62,139.96 127.06,139.96 126.88,139.78 126.88,139.37 126.78,139.27 126.3,139.27 126.12,139.45 126.12,139.98 125.99,140.11 125.36,140.11 125.31,140.06 125.26,140.06 125.26,140.01 124.85,139.6 121.17,139.6 121.05,139.72 121.05,140.87 121.27,141.09 121.27,143.39 121.7,143.82 121.7,145.47 121.56,145.61 121.13,145.61 120.96,145.77 120.96,146.81 121.02,146.99 120.96,147.18 120.96,147.81 121.04,147.81 121.04,148.44 121.14,148.54 121.8,148.54
GND on BOTTOM (solid shape): 198.15,187.15 198.37,187.12 198.57,187.02 198.63,186.99 198.92,186.73 200.3,185.5 200.67,185.28 201.1,185.2 208.67,185.2 208.67,177.1 209.27,176.4 210.04,176.9 211.24,176.9 211.24,176.44 210.32,176.44 209.02,175.99 208.21,177.1 208.21,178.04 207.76,178.49 198.7,178.49 198.07,179.12 197.41,179.12 197.39,179.1 195.55,179.1 195.42,179.23 195.42,180.14 195.52,180.24 195.71,180.24 195.79,180.32 195.79,180.88 195.66,181.02 195.28,181.02 195.2,181.09 195.2,181.55 195.29,181.64 196.81,181.64 197.07,181.9 197.07,182.72 196.68,183.11 196.68,183.2 196.67,183.21 196.67,184.19 196.38,184.48 196.37,184.5 196.37,186.28 196.38,186.28 196.38,186.31 196.66,186.59 196.66,187.15
GND on BOTTOM (solid shape): 257.37,88.76 257.37,88.51 257.14,88.28 257.11,88.3 256.76,88.28 256.64,87.96 256.64,87.93 256.41,87.7 255.24,87.7 254.98,87.95 254.33,87.95 254.25,87.99 254.23,88.08 254.24,88.13 254.24,88.17 254.23,88.2 254.28,88.24 254.31,88.24 254.62,88.35 254.66,88.68 254.67,88.78 254.75,88.83 254.93,88.83 255.01,88.74 255.01,88.71 255.16,88.38 255.53,88.41 255.6,88.43 255.67,88.4 255.93,88.28 256.17,88.41 256.21,88.44 256.75,88.52 256.63,88.99 256.63,89.08 257.06,89.08
GND on BOTTOM (solid shape): 148.14,122.43 148.14,122.16 148.09,122.01 148.14,121.87 148.14,121.51 148.09,121.36 148.14,121.22 148.14,120.86 148.09,120.71 148.14,120.57 148.14,120.21 148.09,120.06 148.14,119.92 148.14,119.82 148.48,119.47 148.48,118.72 148.35,118.59 148.29,118.59 148.14,118.44 148.14,118.26 148.09,118.11 148.14,117.96 148.14,117.61 148.09,117.46 148.14,117.31 148.14,116.97 148.06,116.81 148.08,116.64 148.1,116.61 147.81,116.32 147.81,115.92 147.72,115.83 146.97,115.83 146.88,115.92 146.79,115.92 146.74,115.97 146.74,117.06 146.83,117.15 146.86,117.15 147.05,117.33 147.19,117.33 147.43,117.58 147.43,117.63 147.44,117.64 147.47,117.78 147.44,117.93 147.43,117.94 147.43,118.93 147.44,118.94 147.47,119.08 147.44,119.23 147.43,119.24 147.43,120.23 147.44,120.24 147.47,120.38 147.44,120.53 147.43,120.54 147.43,121.53 147.44,121.54 147.47,121.69 147.44,121.83 147.43,121.84 147.43,122.1 147.56,122.22 147.56,122.36 147.74,122.55 148.03,122.55
GND on BOTTOM (solid shape): 93.21,62.2 93.21,62.18 95.63,56.55 89.57,57.52 89.57,58.79 89.57,58.9 89.69,59.76 90.03,60.57 90.96,61.59 92.24,62.14 92.55,62.18 92.87,62.2
GND on BOTTOM (solid shape): outline of 139 points within 29.35,44.76 39.12,49.08
GND on BOTTOM (solid shape): 246.01,20.5 246.01,18.15 246.74,17.42 246.74,17.39 246.84,17.07 247.15,16.98 247.18,16.98 247.85,16.31 247.85,15.8 247.79,15.74 246.25,15.74 246.15,15.8 246.18,15.92 246.24,16.39 245.78,16.5 245.73,16.46 245.68,16.42 245.6,16.39 245.53,16.43 244.89,16.22 245.51,15.97 245.59,16 245.66,15.96 245.71,15.92 245.74,15.8 245.64,15.74 243.72,15.74 243.64,15.78 243.62,15.86 243.28,16.3 242.93,15.86 242.91,15.78 242.83,15.74 241.56,15.74 240.42,16.88 240.36,16.95 238.49,16.95 238.41,17.02 238.41,19.39 239.72,20.7 239.97,20.95 245.56,20.95
GND on BOTTOM (solid shape): 156.53,39.73 156.61,39.69 156.63,39.61 156.98,39.2 157.33,39.61 157.35,39.69 157.43,39.73 166.83,39.73 166.91,39.69 166.93,39.6 167.26,39.13 167.6,39.6 167.62,39.69 167.7,39.73 168.17,39.73 168.17,39.49 168.19,39.46 168.2,39.45 168.63,39.16 168.89,39.6 168.91,39.69 168.99,39.73 176.73,39.73 176.81,39.69 176.83,39.6 176.83,39.4 176.95,39.23 176.95,39.09 176.74,38.89 175.41,38.89 175.34,38.92 175.31,38.99 174.9,39.32 174.61,38.87 174.62,38.85 174.33,38.57 174.31,38.57 174.13,38.55 173.98,38.45 154.42,38.45 154.26,38.61 154.26,39.42 154.57,39.73
GND on BOTTOM (solid shape): 127.51,39.7 127.6,39.65 127.6,39.55 127.9,39 128.2,39.55 128.2,39.65 128.29,39.7 138.57,39.7 138.72,39.55 138.72,38.38 138.44,38.1 115.97,38.1 115.88,38.16 115.89,38.26 115.81,38.76 115.32,38.69 115.23,38.65 115.15,38.71 114.46,38.62 115.1,38.36 115.19,38.4 115.27,38.34 115.29,38.3 115.31,38.26 115.32,38.16 115.23,38.1 113.59,38.1 113.5,38.15 113.5,38.25 113.18,38.76 112.86,38.25 112.86,38.15 112.77,38.1 112.2,38.1 111.69,38.61 111.69,39.45 111.95,39.7
GND on BOTTOM (solid shape): 252.69,84.8 252.8,84.68 252.96,84.63 252.99,84.62 253.01,84.59 253.29,84.38 253.54,84.64 253.56,84.7 253.62,84.74 253.68,84.74 253.71,84.49 253.91,84.35 254.26,83.99 254.63,84.33 254.83,84.37 254.96,84.52 255.2,84.52 255.46,84.26 255.48,84.05 255.63,83.9 255.66,83.89 255.66,83.11 254.39,81.84 253.25,81.84 252.99,82.1 252.99,82.17 253.1,82.28 253.1,82.89 253.11,82.93 253.13,82.96 253.46,82.99 253.59,83.29 253.93,83.66 253.57,84.01 253.25,84.26 252.97,83.98 252.94,83.97 252.88,83.97 252.85,83.98 252.83,84.01 252.64,84.21 252.37,84.13 252.3,84.1 252.23,84.13 252.1,84.26 252.1,84.51 252.33,84.74 252.35,84.74 252.43,84.77 252.5,84.83 252.68,84.83
GND on BOTTOM (solid shape): 114.17,52.42 114.31,52.28 114.31,52.26 114.71,51.97 115.01,52.36 115.04,52.45 115.11,52.48 124.28,52.48 124.36,52.44 124.38,52.36 124.66,51.93 125.08,52.22 125.08,52.24 125.22,52.38 125.22,52.48 135.16,52.48 135.16,51.86 135.66,51.37 135.74,51.37 135.75,51.36 136.31,51.58 135.86,51.99 135.83,51.98 135.72,52.09 135.72,52.48 136.64,52.48 136.93,52.19 136.9,52.15 136.77,51.4 137.41,50.99 138.12,50.99 138.31,50.8 138.31,50.47 137.96,50.12 130.8,50.12 130.73,50.15 130.7,50.22 130.37,50.58 129.99,50.29 129.99,50.27 129.92,50.2 129.92,50.12 120.15,50.12 120.08,50.15 120.05,50.23 119.69,50.61 119.34,50.23 119.31,50.15 119.24,50.12 112.12,50.12 111.36,50.88 111.36,52.05 111.79,52.48 114.17,52.48
GND on BOTTOM (solid shape): outline of 199 points within 155.28,50.14 176.87,52.51
GND on BOTTOM (solid shape): outline of 203 points within 277.78,36.16 286.85,49.65
GND on BOTTOM (solid shape): outline of 135 points within 227.84,108.6 245.77,109.33
GND on BOTTOM (solid shape): 227.67,185.75 228.23,185.51 228.47,184.95 228.47,184.45 228.82,183.6 229.67,183.25 230.47,183.25 230.47,177.49 231.07,176.79 231.85,177.29 238.3,177.29 239.08,176.79 239.68,177.49 239.68,183.25 240.47,183.25 241.24,183.52 241.65,184.22 241.67,184.22 241.67,184.42 241.91,184.97 242.47,185.2 244.71,185.2 244.71,177.38 244.55,177.22 244.23,177.22 241.82,174.81 241.82,173.16 240.99,172.33 240.29,172.33 239.98,172.65 239.98,174.17 240.23,174.43 240.23,176.08 239.76,176.54 239.64,176.54 238.77,176.35 238.02,176.83 232.13,176.83 231.54,176.39 230.8,176.39 230.13,176.39 229.75,176.01 229.75,174.62 230.2,174.17 230.2,172.39 229.82,172.01 228.29,172.01 227.08,173.22 223.47,173.22 223.08,173.6 223.08,173.92 223.11,173.94 223.11,176.23 223,176.33 222.92,176.44 222.04,176.44 222.04,176.9 223.2,176.9 223.97,176.4 224.57,177.1 224.57,185.75
GND on BOTTOM (solid shape): outline of 226 points within 289.52,38.97 299.08,62.92
GND on BOTTOM (solid shape): outline of 154 points within 227.84,91.43 245.79,92.2
GND on BOTTOM (solid shape): 220.56,119.03 220.59,118.95 220.55,118.88 220.39,118.61 220.5,118.31 220.54,118.28 220.58,118.2 220.54,118.12 220.5,118.08 220.42,118.04 220.34,118.08 220.31,118.11 219.8,118.12 219.81,117.61 219.84,117.58 219.88,117.5 219.84,117.42 219.8,117.38 219.72,117.34 219.64,117.38 219.62,117.41 219.1,117.41 219.11,116.9 219.22,116.83 219.36,116.79 219.65,116.53 219.98,116.76 220.02,116.8 220.07,116.79 220.2,116.6 220.43,116.55 220.45,116.51 220.45,116.46 220.4,116.42 220.38,116.42 220.21,116.36 220.11,116.21 220.09,116.18 220.06,116.17 220.03,116.17 219.97,116.18 219.92,116.23 219.46,116.31 219.66,115.88 219.72,115.86 219.76,115.8 219.85,115.63 220.02,115.54 220.08,115.5 220.1,115.44 220.11,115.39 220.02,115.31 219.34,115.31 219.26,115.34 219.24,115.42 219.18,115.62 218.99,115.72 219,115.75 218.99,115.78 219,115.82 219.03,115.84 219.17,116.4 218.65,116.14 218.61,116.09 218.53,116.08 218.46,116.05 218.43,116.03 218.32,116.13 218.32,118.17 218.61,118.42 218.5,118.79 218.87,119.15 220.44,119.15
GND on BOTTOM (solid shape): outline of 127 points within 198.88,161.95 202.43,166.13
GND on BOTTOM (solid shape): outline of 108 points within 251.25,84.89 255.47,87.64
GND on BOTTOM (solid shape): outline of 176 points within 227.84,105.8 245.75,106.5
GND on BOTTOM (solid shape): outline of 165 points within 227.84,92.83 245.79,93.6
GND on BOTTOM (solid shape): outline of 163 points within 227.84,107.2 245.77,107.9
GND on BOTTOM (solid shape): outline of 166 points within 227.84,103 245.77,103.7
GND on BOTTOM (solid shape): outline of 166 points within 227.84,104.4 245.77,105.1
GND on BOTTOM (solid shape): outline of 166 points within 227.84,94.23 245.79,95
GND on BOTTOM (solid shape): outline of 173 points within 227.93,101.6 245.77,102.33
GND on BOTTOM (solid shape): outline of 187 points within 227.84,95.62 245.79,96.4
GND on BOTTOM (solid shape): outline of 183 points within 227.84,97.02 245.79,97.8
GND on BOTTOM (solid shape): outline of 193 points within 227.84,98.42 245.79,99.2
GND on BOTTOM (solid shape): outline of 142 points within 219.18,98.51 224.09,101.93
GND on BOTTOM (solid shape): outline of 208 points within 215.53,81.65 221.94,87.62
GND on BOTTOM (solid shape): outline of 179 points within 16.02,0.2 338.22,185.2
GND on BOTTOM (solid shape): outline of 236 points within 0.2,36 189.98,187.35
GND on BOTTOM (solid shape): outline of 1157 points within 201.07,24.95 209.01,34.54
GND on BOTTOM (solid shape): outline of 1933 points within 231.1,82.86 241.35,89.03
GND on BOTTOM (solid shape): outline of 3939 points within 213.5,99.88 227.61,119.34
GND on BOTTOM (solid shape): outline of 5157 points within 218.32,82.72 232.03,102.42
GND on BOTTOM (solid shape): outline of 7007 points within 240.61,82.86 255.15,110.72
GND on IN1 (solid shape): 16.58,33.77 16.58,32.38 14.75,30.54 1.27,30.54 1.27,31.9 1.51,32.46 2.07,32.7 11.68,32.7 12.45,32.2 13.05,32.9 13.05,33.65 13.37,33.96 16.39,33.96
GND on IN1 (solid shape): 227.67,185.75 228.23,185.51 228.47,184.95 228.47,184.45 228.82,183.6 229.67,183.25 230.47,183.25 230.47,177.49 231.07,176.79 231.85,177.29 238.3,177.29 239.08,176.79 239.68,177.49 239.68,183.25 240.47,183.25 241.24,183.52 241.65,184.22 241.67,184.22 241.67,184.42 241.91,184.97 242.47,185.2 244.71,185.2 244.71,177.38 244.55,177.22 244.23,177.22 242.01,175 242.01,173.35 240.99,172.33 240.29,172.33 239.98,172.65 239.98,174.17 240.23,174.43 240.23,176.08 239.76,176.54 239.64,176.54 238.77,176.35 238.02,176.83 232.13,176.83 231.54,176.39 230.8,176.39 230.13,176.39 229.75,176.01 229.75,174.62 230.2,174.17 230.2,172.39 229.82,172.01 228.29,172.01 227.08,173.22 223.47,173.22 223.08,173.6 223.08,173.92 223.11,173.94 223.11,176.23 223,176.33 222.92,176.44 222.04,176.44 222.04,176.9 223.2,176.9 223.97,176.4 224.57,177.1 224.57,185.75
GND on IN1 (solid shape): outline of 179 points within 16.02,0.2 338.22,185.2
GND on IN1 (solid shape): outline of 243 points within 0.2,36 211.24,187.35
GND on IN2 (solid shape): 16.58,33.77 16.58,32.38 14.75,30.54 1.27,30.54 1.27,31.9 1.51,32.46 2.07,32.7 11.68,32.7 12.45,32.2 13.05,32.9 13.05,33.65 13.37,33.96 16.39,33.96
GND on IN2 (solid shape): 227.67,185.75 228.23,185.51 228.47,184.95 228.47,184.45 228.82,183.6 229.67,183.25 230.47,183.25 230.47,181.47 230.47,177.49 231.07,176.79 231.85,177.29 238.3,177.29 239.01,176.79 239.66,177.35 239.67,177.42 239.68,177.49 239.68,183.25 240.47,183.25 241.24,183.52 241.65,184.22 241.67,184.22 241.67,184.42 241.91,184.97 242.47,185.2 244.71,185.2 244.71,177.38 244.55,177.22 244.23,177.22 242.01,175 242.01,173.35 240.99,172.33 240.29,172.33 239.98,172.65 239.98,174.17 240.23,174.43 240.23,176.08 239.76,176.54 239.64,176.54 238.77,176.35 238.02,176.83 232.13,176.83 231.54,176.39 230.8,176.39 230.13,176.39 229.75,176.01 229.75,174.62 230.2,174.17 230.2,172.39 229.82,172.01 228.29,172.01 227.08,173.22 223.47,173.22 223.08,173.6 223.08,173.92 223.11,173.94 223.11,176.23 223,176.33 222.92,176.44 222.04,176.44 222.04,176.9 223.2,176.9 223.97,176.4 224.57,177.1 224.57,181.47 224.57,185.75
GND on IN2 (solid shape): outline of 179 points within 16.02,0.2 338.22,185.2
GND on IN2 (solid shape): outline of 239 points within 0.2,36 211.24,187.35
GND on IN3 (solid shape): 16.58,33.77 16.58,32.38 14.75,30.54 1.27,30.54 1.27,31.9 1.51,32.46 2.07,32.7 11.68,32.7 12.45,32.2 13.05,32.9 13.05,33.65 13.37,33.96 16.39,33.96
GND on IN3 (solid shape): 227.67,185.75 228.23,185.51 228.47,184.95 228.47,184.45 228.82,183.6 229.67,183.25 230.47,183.25 230.47,182.12 230.47,177.49 231.07,176.79 231.85,177.29 238.3,177.29 238.64,176.87 239.16,176.81 239.54,177.06 239.68,177.49 239.68,183.25 240.47,183.25 240.61,183.25 240.74,183.28 241.34,183.62 241.65,184.22 241.67,184.22 241.67,184.42 241.91,184.97 242.47,185.2 244.71,185.2 244.71,177.38 244.55,177.22 244.23,177.22 241.82,174.81 241.82,173.16 240.99,172.33 240.29,172.33 239.98,172.65 239.98,174.17 240.23,174.43 240.23,176.08 239.76,176.54 239.64,176.54 238.77,176.35 238.02,176.83 232.13,176.83 231.54,176.39 230.8,176.39 230.13,176.39 229.75,176.01 229.75,174.62 230.2,174.17 230.2,172.39 229.82,172.01 228.29,172.01 227.08,173.22 223.47,173.22 223.08,173.6 223.08,173.92 223.11,173.94 223.11,176.23 223,176.33 222.92,176.44 222.04,176.44 222.04,176.9 223.13,176.9 223.2,176.9 223.35,176.63 223.59,176.45 223.65,176.43 223.87,176.4 224.09,176.43 224.44,176.69 224.57,177.1 224.57,177.65 224.57,182.12 224.57,185.75
GND on IN3 (solid shape): outline of 179 points within 16.02,0.2 338.22,185.2
GND on IN3 (solid shape): outline of 259 points within 0.2,36 211.24,187.35
GND on IN4 (solid shape): 16.58,33.77 16.58,32.38 14.75,30.54 1.27,30.54 1.27,31.9 1.51,32.46 2.07,32.7 11.68,32.7 12.45,32.2 13.05,32.9 13.05,33.65 13.37,33.96 16.39,33.96
GND on IN4 (solid shape): 227.67,185.75 228.23,185.51 228.47,184.95 228.47,184.45 228.82,183.6 229.67,183.25 230.47,183.25 230.47,177.49 231.07,176.79 231.85,177.29 238.3,177.29 239.08,176.79 239.68,177.49 239.68,183.25 240.47,183.25 241.24,183.52 241.65,184.22 241.67,184.22 241.67,184.42 241.91,184.97 242.47,185.2 244.71,185.2 244.71,177.38 244.55,177.22 244.23,177.22 241.72,174.71 241.72,173.06 240.99,172.33 240.29,172.33 239.98,172.65 239.98,174.17 240.23,174.43 240.23,176.08 239.76,176.54 239.64,176.54 238.77,176.35 238.02,176.83 232.13,176.83 231.54,176.39 230.8,176.39 230.13,176.39 229.75,176.01 229.75,174.62 230.2,174.17 230.2,172.39 229.82,172.01 228.29,172.01 227.08,173.22 223.47,173.22 223.08,173.6 223.08,173.92 223.11,173.94 223.11,176.23 223,176.33 222.92,176.44 222.04,176.44 222.04,176.9 223.2,176.9 223.97,176.4 224.57,177.1 224.57,185.75
GND on IN4 (solid shape): outline of 179 points within 16.02,0.2 338.22,185.2
GND on IN4 (solid shape): outline of 253 points within 0.2,36 211.24,187.35
GND on IN6 (solid shape): 16.58,33.77 16.58,32.38 14.75,30.54 1.27,30.54 1.27,31.9 1.51,32.46 2.07,32.7 11.68,32.7 12.45,32.2 13.05,32.9 13.05,33.65 13.37,33.96 16.39,33.96
GND on IN6 (solid shape): 227.67,185.75 228.23,185.51 228.47,184.95 228.47,184.45 228.82,183.6 229.67,183.25 230.47,183.25 230.47,177.49 231.07,176.79 231.85,177.29 238.3,177.29 239.08,176.79 239.68,177.49 239.68,183.25 240.47,183.25 241.24,183.52 241.65,184.22 241.67,184.22 241.67,184.42 241.91,184.97 242.47,185.2 244.71,185.2 244.71,177.38 244.55,177.22 244.23,177.22 242.01,175 242.01,173.35 240.99,172.33 240.29,172.33 239.98,172.65 239.98,174.17 240.23,174.43 240.23,176.08 239.76,176.54 239.64,176.54 238.77,176.35 238.02,176.83 232.13,176.83 231.54,176.39 230.8,176.39 230.13,176.39 229.75,176.01 229.75,174.62 230.2,174.17 230.2,172.39 229.82,172.01 228.29,172.01 227.08,173.22 223.47,173.22 223.08,173.6 223.08,173.92 223.11,173.94 223.11,176.23 223,176.33 222.92,176.44 222.04,176.44 222.04,176.9 223.2,176.9 223.97,176.4 224.57,177.1 224.57,185.75
GND on IN6 (solid shape): outline of 179 points within 16.02,0.2 338.22,185.2
GND on GND1: outline of 299 points within 0.2,0.2 338.22,187.35 ; 1 cut-out
GND on GND2, GND5: outline of 299 points within 0.2,0.2 338.22,187.35
GND on GND3: outline of 299 points within 0.2,0.2 338.22,187.35 ; 2 cut-outs
GND on GND4: outline of 308 points within 0.2,0.2 338.22,187.35
GND on IN5: 188.84,173.28 186.3,175.82 173.94,175.82 173.94,182.74 146.5,182.74 146.5,175.89 142.14,175.89 142.14,186.53 147.41,186.53 147.97,185.43 149.12,184.98 173.72,184.98 174.87,185.43 175.43,186.53 179.2,186.53 179.2,186.4 179.79,184.97 181.22,184.38 184.34,184.38 185.06,184.51 185.68,184.89 187.3,186.33 198.14,186.33 199.76,184.89 200.38,184.51 201.1,184.38 207.85,184.38 207.85,177.1 208.83,175.68 210.5,176.08 222.74,176.08 224.41,175.68 225.39,177.1 225.39,184.93 227.65,184.93 227.65,184.45 228.24,183.03 229.66,182.43 229.66,177.49 230.63,176.07 232.3,176.47 237.85,176.47 239.52,176.07 240.49,177.49 240.49,182.43 241.88,183.01 242.49,184.38 243.89,184.38 243.89,177.26 243.4,176.12 243.91,174.99 243.91,173.28
GND on IN5: 265.63,165.66 265.63,173.32 264.99,173.96 264.99,176.31 263.7,177.6 262.53,177.6 262.53,184.38 265.4,184.38 265.4,176.9 265.99,175.47 267.42,174.88 279.09,174.88 279.09,165.66
GND on IN5: 33.45,23.3 33.35,23.4 33.35,27.46 33.2,27.61 33.15,27.61 33.15,29.35 33.21,29.41 33.21,29.62 33.06,29.77 29.83,29.77 29.66,29.94 29.66,34.68 29.77,34.79 30.72,34.79 30.87,34.94 30.87,35.15 30.74,35.27 30.74,36.65 30.81,36.72 30.81,36.93 30.11,37.62 30.11,39.17 36.04,39.17 38.49,36.72 38.49,35.45 39.27,34.66 39.91,34.66 40.01,34.56 40.01,34 39.97,33.96 39.08,33.96 38.68,33.56 38.68,23.34 38.64,23.3
GND on IN5: 2.09,30.53 2.09,31.88 11.22,31.88 12.89,31.48 13.87,32.9 13.87,46.5 12.89,47.92 11.22,47.52 2.09,47.52 2.09,49.03 2.27,49.03 3.7,49.62 4.29,51.05 4.29,53.55 3.7,54.98 2.27,55.57 2.09,55.57 2.09,56.1 1.02,57.1 1.02,67.1 2.09,68.1 2.09,73.88 11.74,73.88 12.12,73.81 12.44,73.6 16.26,69.77 16.48,69.45 16.55,69.07 16.55,61.3 17.44,59.17 19.57,58.28 19.57,34.09 19.53,34.09 17.66,32.23 17.66,31.08 17.11,30.53
GND on IN5: 276.97,108.77 276.4,109.34 244.48,109.34 244.48,116.17 243.19,117.47 219.93,117.47 219.27,116.81 219.27,117.32 218.77,117.82 218.77,123.67 218.05,124.39 206.81,124.39 206.68,124.51 199.93,124.51 199.72,124.3 199.72,139.33 199.72,139.34 199.72,145.6 200.84,145.6 201.56,146.32 201.56,150.66 201.57,150.68 206.53,150.68 206.57,150.63 206.57,145.43 206.98,145.02 209.28,145.02 213.92,149.66 264.66,149.66 265.38,150.38 265.38,153.89 264.72,154.55 242.32,154.55 242.32,157.41 278.07,157.41 279.09,156.39 279.09,109.06 278.8,108.77
GND on GND6: outline of 299 points within 0.2,0.2 338.22,187.35 ; 1 cut-out
GNDA on GND1, GND2, GND3, GND4, GND5, GND6: 2.07,2 1.51,2.24 1.27,2.8 1.27,6.05 1.51,6.61 2.07,6.85 14.37,6.85 15.07,7.45 14.57,8.22 14.57,13.43 15.07,14.2 14.37,14.8 2.07,14.8 1.51,15.04 1.27,15.6 1.27,18.75 1.51,19.31 2.07,19.55 14.37,19.55 15.07,20.15 14.57,20.92 14.57,26.13 15.07,26.9 14.37,27.5 2.07,27.5 1.51,27.74 1.27,28.3 1.27,30.03 17.32,30.03 18.17,30.87 18.17,32.02 19.74,33.58 21.83,33.58 27.42,39.17 29.43,39.17 29.6,39 29.6,37.41 30.45,36.57 30.49,36.57 30.49,35.3 29.56,35.3 29.16,34.89 29.16,29.73 29.62,29.26 32.9,29.26 32.9,27.52 32.84,27.46 32.84,23.4 31.38,21.94 31.38,19.78 31.08,19.49 29.37,19.49 28.86,18.98 27.84,18.98 27.02,18.15 23.99,18.15 23.82,18.32 23.82,20.67 23.36,21.14 21.81,21.14 21.22,20.54 21.22,17.75 21.11,17.64 20.67,17.64 17.98,14.95 17.98,5.56 17.18,4.75 16.1,4.75 15.5,4.16 15.5,2
GNDA on IN5: 2.09,2.82 2.09,6.03 14.37,6.03 15.79,7.01 15.39,8.68 15.39,12.97 15.79,14.64 14.37,15.62 2.09,15.62 2.09,18.73 14.37,18.73 15.79,19.71 15.39,21.38 15.39,25.67 15.79,27.34 14.37,28.32 2.09,28.32 2.09,30.03 17.51,30.03 18.23,30.75 18.23,31.95 19.74,33.46 21.7,33.46 27.42,39.17 29.43,39.17 29.6,39 29.6,37.41 30.45,36.57 30.49,36.57 30.49,35.3 29.56,35.3 29.16,34.89 29.16,29.73 29.62,29.26 32.52,29.26 32.52,27.75 32.84,27.43 32.84,23.4 31.4,21.96 31.38,21.96 31.38,19.8 31.06,19.49 29.35,19.49 29.03,19.17 28.16,19.17 27.97,18.98 27.84,18.98 27.08,18.22 24.12,18.22 23.95,18.38 23.95,20.8 23.48,21.26 21.75,21.26 21.09,20.61 21.09,18.07 17.98,14.95 17.98,5.56 17.18,4.75 16.1,4.75 15.5,4.16 15.5,2.82
VCC_1.0VS_VGAP on BOTTOM (solid shape): 241.38,45.4 241.38,44.93 241.5,44.81 241.5,43.99 241.45,43.94 240.84,43.94 240.77,44.01 240.77,45.41 240.87,45.51 241.27,45.51
VCC_CHG on TOP (solid shape): 60.78,26.22 60.78,25.96 59.94,25.12 59.1,25.12 59.02,25.2 59.02,25.42 59.37,25.77 59.75,25.77 60.33,26.35 60.65,26.35
VCC_VCCIO on BOTTOM (solid shape): 122.91,116.73 122.91,114.97 122.83,114.89 122.41,114.89 122.24,115.06 122.24,115.83 121.92,116.15 121.92,116.95 121.99,117.02 122.62,117.02
VIN on TOP (solid shape): 77.35,42.55 77.35,35.42 75.78,33.86 71.32,33.86 71.08,34.1 69.74,34.1 69.66,34.18 69.66,35.66 70.66,36.67 70.66,41.16 69.86,41.96 69.86,42.6 70.11,42.85 77.05,42.85
VIN on BOTTOM (solid shape): 79.38,40.12 79.38,34.06 79.08,33.76 76.68,33.76 76.26,34.18 74.09,34.18 73.76,33.86 71.43,33.86 70.94,34.35 70.94,40.76 71.32,41.14 78.37,41.14
VIN on IN1 (solid shape): 74.24,35.61 74.24,34.28 73.92,33.96 71.26,33.96 70.94,34.28 70.94,35.68 71.19,35.93 73.92,35.93
VIN on IN3 (solid shape): 74.3,35.8 74.3,34.03 74.11,33.84 71.38,33.84 71,34.22 71,35.8 71.32,36.12 73.99,36.12
VIN on IN4 (solid shape): 74.49,35.87 74.49,34.34 74.05,33.9 71.32,33.9 70.94,34.28 70.94,35.68 71.26,36 74.37,36
+EC_VCCA on TOP (solid shape): 294.06,11.3 294.06,9.14 294,9.08 293.85,9.08 293.8,9.13 293.8,10.98 293.75,11.04 293.57,11.04 293.49,11.12 293.49,11.39 293.58,11.48 293.87,11.48
+FBX_PLLAVDD on TOP (solid shape): 204.44,108.12 205.25,108.12 205.43,107.94 205.43,106.67 205.24,106.48 201.74,106.48 201.46,106.76 201.46,108.33 201.58,108.44 203.14,108.44 203.15,108.45 204.12,108.45
+HDMI_5V_OUT on BOTTOM (solid shape): outline of 122 points within 220.29,168.46 225.91,175.19
+IFPX_PLLVDD on TOP (solid shape): outline of 113 points within 225.5,112.07 231.4,123.18
+INV_PWR_SRC on TOP (solid shape): 173.59,184.48 173.59,183.41 173.32,183.14 171.54,183.14 171.23,182.83 171.23,179.75 170.9,179.41 169.75,179.41 169.5,179.67 169.5,182.68 169.48,182.7 169.48,183.19 169.78,183.49 169.78,184.54 169.87,184.63 173.44,184.63
+INV_PWR_SRC on BOTTOM (solid shape): 159.18,174.19 159.18,173.69 159.12,173.49 159.18,173.29 159.18,173.25 159.43,173 160.28,173 160.62,172.66 160.62,171.46 160.49,171.33 159.19,171.33 158.91,171.61 158.23,171.61 157.95,171.33 156.84,171.33 156.69,171.47 156.69,172.05 156.74,172.23 156.69,172.4 156.69,172.84 156.86,173 157.16,173 157.64,172.96 157.73,173.43 157.92,173.62 157.92,174.11 158.01,174.19 158.08,174.3 158.09,174.31 159.06,174.31
+INV_PWR_SRC on IN2 (solid shape): outline of 1451 points within 157.91,170.79 171.22,181.54
+LAN_IO on TOP (solid shape): 270.74,171.76 270.78,171.71 270.82,171.67 270.69,171.26 271.05,171.02 271.05,168.16 270.51,167.61 269.27,167.61 269.22,167.66 269.22,169.91 269.45,170.24 269.22,170.57 269.22,171.64 269.34,171.76
+LAN_IO on BOTTOM (solid shape): 270.96,170.41 270.96,168.83 270.8,168.67 269.87,168.67 269.73,168.81 269.73,170.45 269.86,170.58 270.79,170.58
+LAN_IO on IN1 (solid shape): outline of 466 points within 242.32,159.19 271.24,174.68
+LAN_IO on IN2 (solid shape): outline of 548 points within 266.66,157.62 279.66,170.66
+LCDVDD on TOP (solid shape): outline of 511 points within 162.82,171.44 167.54,183.22
+LCDVDD on BOTTOM (solid shape): 164.77,173.21 164.77,169.6 165.72,168.65 165.72,168.18 165.61,168.07 164.23,168.07 164.09,168.2 164.09,168.42 163.44,169.08 162.68,169.08 162.47,169.29 162.47,172.36 163.61,173.49 164.49,173.49
+NVVDD1 on TOP (solid shape): 234.97,105.59 234.97,105.09 234.89,105.01 234.55,105.01 234.24,104.7 233.64,104.7 233.63,104.74 233.32,104.97 233.01,104.74 233,104.7 232.24,104.7 232.23,104.74 231.92,104.97 231.61,104.74 231.6,104.7 231.05,104.7 230.91,104.85 230.91,105.58 231.03,105.7 234.86,105.7
+NVVDD1 on TOP (solid shape): 245,100.26 245.19,100.16 245.4,100.21 245.5,100.21 245.55,100.12 245.55,99.43 245.36,99.43 245.2,99.27 245.18,99.27 245.09,99.24 245.01,99.19 244.73,99.19 244.65,99.24 244.56,99.27 244.54,99.27 244.34,99.47 244.17,99.47 244.17,99.57 243.53,99.57 243.45,99.61 243.43,99.69 243.44,99.8 244.17,99.8 244.17,99.9 244.27,99.9 244.55,100.18 244.57,100.18 244.66,100.21 244.74,100.26
+NVVDD1 on TOP (solid shape): 231.27,92.84 234.24,92.84 234.24,93.11 234.51,93.11 234.72,93.03 234.93,93.11 235.01,93.11 235.07,93.05 235.07,92.64 234.86,92.42 234.49,92.42 234.22,92.15 233.57,92.15 233.32,92.27 233.07,92.15 232.17,92.15 231.92,92.27 231.67,92.15 230.84,92.15 230.73,92.26 230.7,92.34 230.73,92.41 230.84,92.67 230.7,92.92 230.65,93 230.7,93.08 230.73,93.11 231.27,93.11
