# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB1.8_EN: length 346.1
  TOP w0.102: UU8.3 36.2,51.49 36.78,50.91 CU91.1 37.45,50.61 RU31.2 v1(37.54,51.72) 37.54,52.31 v2(37.41,52.44) ; UE10.9 320.03,59.32 320.43,58.92 320.43,54.35 v2(319.92,53.84)
  IN2 w0.102: v2(271.78,41.48) 271.77,41.46 270.15,41.46 266.6,45.02 245.22,45.02 242.97,47.27 225.13,47.27 224.71,47.69 216.29,47.69 214.88,49.1 210.79,49.1 210.04,49.85 210.04,51.07 206.87,54.24 202.94,54.24 199.68,50.98 193.05,50.98 191.02,48.95 186.13,48.95 183.22,46.04 v2(182.18,46.04)
  IN3 w0.102: v2(182.18,46.04) 182.66,45.56 182.66,45.1 181.2,43.64 181.2,34.25 179.18,32.23 179.18,30.5 174.4,25.72 120.1,25.72 118.6,24.22 106.66,24.22 105.99,23.55 105.99,23.1 105.99,22.91 105.63,22.56 90.81,22.56 90.64,22.74 88.19,24.72 88.12,24.87 84.13,33.64 84.09,33.68 84.09,34.22 83.8,34.51 69.62,48.7 68.02,48.7 65.04,51.68 55.6,51.68 55.09,51.17 51.26,51.17 50.62,51.81 46,51.81 45.6,52.21 43.14,52.21 43.01,52.35 41.62,53.74 38.01,53.74 37.41,53.13 v2(37.41,52.44)
  IN4 w0.102: v2(319.92,53.84) 319.9,53.81 317.65,53.81 307.41,43.58 307.06,43.58 306.3,42.82 299.31,42.82 297.7,41.2 297.7,40.09 297.41,39.81 295.98,39.81 295,40.78 292.46,40.78 291.38,41.86 278.7,41.86 277.57,40.73 272.32,40.73 271.78,41.27 v2(271.78,41.48)
USB2_COMP: length 8.8
  BOTTOM w0.127: v1(190.58,44.84) 190.1,44.36 RH109.1
  BOTTOM w0.381: RH109.1 191.21,43.84 191.63,43.42 194.38,43.42 196.29,41.52 196.29,41.08
USB3_A_PRX_L_DTX_N2: length 4.9
  TOP w0.107: LU10.3 11.57,61.01 11.41,60.85 11.09,60.85 DU28.1 10.79,61.07 10.56,60.84 9.29,60.84 8.53,60.08 8.12,60.08 7.97,60.22 JUSBC2.A10
USB3_A_PRX_L_DTX_P2: length 4.9
  TOP w0.107: JUSBC2.A11 7.93,59.73 8.08,59.87 8.62,59.87 9.38,60.63 10.55,60.63 10.78,60.4 DU29.1 10.95,60.4 11.2,60.65 11.43,60.65 11.56,60.51 LU10.2
USB3_A_PRX_RD_DTX_N2: length 7.8
  TOP w0.107: UU2.22 16.77,56.64 16.76,56.64 16.76,57.51 v2(16.84,57.59) ; v2(15.12,59.68) 14.94,59.86 14.94,60.38 14.46,60.86 13.73,60.86 13.58,61.01 LU10.4
  IN1 w0.089: v2(15.12,59.68) 14.91,59.47 14.91,59.13 15.73,58.31 16.56,58.31 16.75,58.11 16.75,57.67 v2(16.84,57.59)
USB3_A_PRX_RD_DTX_P2: length 7.7
  TOP w0.107: v2(16.25,57.59) 16.56,57.28 16.56,56.86 16.37,56.67 UU2.23 ; v2(14.54,59.68) 14.74,59.88 14.74,60.29 14.37,60.66 13.73,60.66 13.58,60.51 LU10.1
  IN1 w0.089: v2(14.54,59.68) 14.75,59.47 14.75,59.06 15.66,58.14 16.49,58.14 16.59,58.05 16.59,57.9 16.27,57.59 v2(16.25,57.59)
USB3_A_PTX_C_DRX_N1: length 1.4
  TOP w0.107: CU80.1 13.69,64.15 13.35,64.15 13.2,64 LU8.1
USB3_A_PTX_C_DRX_P1: length 1.5
  TOP w0.107: LU8.4 13.2,64.5 13.35,64.35 13.56,64.35 CU79.1
USB3_A_PTX_L_DRX_N1: length 4.4
  TOP w0.107: JUSBC2.A3 8.05,63.73 8.19,63.86 8.58,63.86 8.87,64.15 10.24,64.15 DU25.1 10.75,64.17 11.02,64.17 11.19,64 LU8.2
USB3_A_PTX_L_DRX_P1: length 4.3
  TOP w0.107: JUSBC2.A2 8.04,64.22 8.2,64.06 8.49,64.06 8.78,64.35 10.19,64.35 10.44,64.6 DU24.1 10.71,64.37 11.02,64.37 11.15,64.5 LU8.3
USB3_A_PTX_RD_DRX_N1: length 10.9
  TOP w0.107: CU80.2 15.57,64.56 15.83,64.56 15.93,64.45 15.93,60.07 18.87,57.14 18.87,56.7 18.77,56.6 UU2.17
USB3_A_PTX_RD_DRX_P1: length 11
  TOP w0.107: CU79.2 15.91,64.76 16.14,64.54 16.14,60.16 19.07,57.23 19.07,56.68 19.17,56.59 UU2.16
USB3_B_PRX_L_DTX_N1: length 8
  TOP w0.107: JUSBC2.B10 6.34,63.97 6.49,64.13 6.68,64.13 6.93,64.38 6.93,64.89 7.36,65.32 8.7,65.32 9.29,65.9 10.93,65.9 11.16,65.67 DU22.1 11.4,65.67 11.63,65.91 11.97,65.91 12.03,65.97 12.2,65.97 12.34,65.83 LU7.2
USB3_B_PRX_L_DTX_P1: length 8
  TOP w0.107: JUSBC2.B11 6.26,64.48 6.41,64.33 6.59,64.33 6.72,64.46 6.72,64.97 7.27,65.52 8.62,65.52 9.2,66.11 10.94,66.11 11.18,66.34 DU23.1 11.5,66.11 11.89,66.11 11.95,66.17 12.15,66.17 12.31,66.33 LU7.3
USB3_B_PRX_RD_DTX_N1: length 17.9
  TOP w0.107: UU2.13 20.37,56.66 20.26,56.76 20.26,57.43 v2(20.43,57.6) ; LU7.1 14.03,65.83 14.16,65.96 14.59,65.96 14.82,66.18 14.82,66.44 14.92,66.55 15.39,66.55 v2(15.46,66.48)
  IN1 w0.089: v2(20.43,57.6) 20.43,57.59 20.37,57.52 20.37,56.75 20.08,56.47 19.12,56.47 18.93,56.65 18.93,57.14 15.99,60.09 15.99,66.54 15.9,66.63 15.62,66.63 v2(15.46,66.48)
USB3_B_PRX_RD_DTX_P1: length 17.8
  TOP w0.107: v2(19.85,57.59) 20.06,57.37 20.06,56.76 19.97,56.67 UU2.14 ; v2(15.46,67.06) 15.16,66.75 14.84,66.75 14.61,66.53 14.61,66.27 14.51,66.16 14.23,66.16 14.06,66.33 LU7.4
  IN1 w0.089: v2(15.46,67.06) 15.73,66.79 15.97,66.79 16.15,66.61 16.15,60.16 19.1,57.21 19.1,56.72 19.19,56.63 20.01,56.63 20.2,56.82 20.2,57.25 19.93,57.52 19.92,57.52 v2(19.85,57.59)
USB3_B_PTX_C_DRX_N2: length 1.4
  TOP w0.107: LU11.4 12.65,58.72 12.8,58.58 13.24,58.58 CU82.1
USB3_B_PTX_C_DRX_P2: length 1.4
  TOP w0.107: CU81.1 13.24,58.37 12.8,58.37 12.65,58.22 LU11.1
USB3_B_PTX_L_DRX_N2: length 6.6
  TOP w0.107: JUSBC2.B3 6.33,60.48 6.8,60 6.8,59.18 7.12,58.87 7.85,58.87 8.14,58.58 9.7,58.58 9.91,58.78 DU26.1 10.22,58.78 10.39,58.61 10.7,58.61 10.81,58.72 LU11.3
USB3_B_PTX_L_DRX_P2: length 6.6
  TOP w0.107: JUSBC2.B2 6.54,59.97 6.6,59.91 6.6,59.1 7.03,58.66 7.77,58.66 8.06,58.37 9.76,58.37 10.02,58.12 DU27.1 10.46,58.41 10.66,58.41 10.84,58.22 LU11.2
USB3_B_PTX_RD_DRX_N2: length 5.3
  TOP w0.107: UU2.19 17.97,56.58 17.92,56.63 17.92,56.91 17.8,57.02 17.8,57.51 17.04,58.27 15.81,58.27 15.32,58.76 14.66,58.76 CU82.2
USB3_B_PTX_RD_DRX_P2: length 5.3
  TOP w0.107: CU81.2 14.89,58.03 14.99,58.14 14.99,58.47 15.08,58.56 15.24,58.56 15.73,58.07 16.96,58.07 17.6,57.42 17.6,56.94 17.71,56.82 17.71,56.68 17.57,56.54 UU2.20
USB3_CC1: length 38.8
  TOP w0.102: JUSBC2.A5 v2(8.38,62.73)
  IN4 w0.097: 11.57,65.08 v2(11.95,65.08)
  IN4 w0.102: 11.57,65.08 10.42,63.94 8.14,63.94 7.96,63.76 7.96,63.14 v2(8.38,62.72)
  IN6 w0.102: v2(13.04,63.49) 13.04,60.59 13.85,59.78 13.85,58.47 15.95,56.38 17.7,56.38 19.19,54.89 19.19,52.5 21.47,50.22 23.2,50.22 23.39,50.41 24.38,50.41 24.81,49.97 24.81,49.86 24.98,49.69 v2(24.98,46.41)
  BOTTOM w0.102: v2(24.98,46.41) 25.03,46.41 25.11,46.49 UU7.11 ; v2(13.04,63.49) 13.23,63.68 14.51,63.68 14.84,64.01 14.84,65.33 14.6,65.58 DU20.9 DU20.1 12.45,65.58 v1(12.32,65.45) v2(11.95,65.08)
USB3_CC2: length 44.8
  TOP w0.107: JUSBC2.B5 6.39,61.48 6.61,61.26 v2(6.71,61.26)
  IN4 w0.097: v2(6.71,61.26) 7.5,62.05 7.5,63.68
  IN4 w0.102: v2(12.57,67.02) 12.57,66.46 10.33,64.22 8.04,64.22 7.5,63.68
  IN6 w0.102: v2(24.3,47.84) 24.42,47.84 24.71,48.12 24.71,49.64 24.58,49.77 24.58,49.88 24.28,50.18 23.49,50.18 23.3,49.99 21.37,49.99 18.96,52.41 18.96,52.59 18.96,54.8 17.61,56.15 15.85,56.15 13.62,58.38 13.62,59.68 12.63,60.67 12.63,63.66 12.87,63.9 14.46,63.9 v2(15.31,63.05)
  BOTTOM w0.102: UU7.13 24.43,47.97 v2(24.3,47.84) ; 15.22,63.14 v1(15.22,64.58) 15.22,65.69 14.83,66.08 DU20.8 DU20.2 12.75,66.08 12.57,66.26 v2(12.57,67.02)
  BOTTOM w0.107: 15.22,63.14 v2(15.31,63.05)
USB3_PRX_C_DTX_N8: length 3.5
  BOTTOM w0.099: 166,176.8 CI38.2 ; JCDRA.36 166.62,178.46
  BOTTOM w0.102: 166.62,178.46 166.72,178.36 166.72,177.97 166.05,177.3 166.05,176.86 166,176.8
USB3_PRX_C_DTX_P8: length 3.5
  BOTTOM w0.099: JCDRA.37 167.02,178.46
  BOTTOM w0.102: 167.02,178.46 166.95,178.39 166.95,177.88 v4(166.57,177.5) 166.28,177.21 166.28,176.77 CI39.2
USB3_PRX_C_RD_DTX_N1: length 1.9
  TOP w0.107: UU2.44 18.77,49.75 18.87,49.65 18.87,49.36 18.93,49.3 18.93,49.04 19.09,48.89 19.09,48.8 CU84.1
USB3_PRX_C_RD_DTX_P1: length 1.9
  TOP w0.107: UU2.45 19.17,49.76 19.07,49.66 19.07,49.44 19.14,49.38 19.14,49.13 19.29,48.97 19.29,48.8 CU83.1
USB3_PRX_DTX_N1: length 214
  TOP w0.107: CU84.2 19.03,47.25 19.03,46.55 v2(18.91,46.42)
  IN3 w0.127: v2(190.93,37.02) 190.82,36.91 190.77,36.91 190.77,36.91 190.46,36.91 190.1,36.55 190.1,35.94 190.69,35.35 190.69,32.57 189.38,31.27 189.38,27.53 188.88,27.03 188.28,27.03 186.92,25.67 186.92,22.91 186.04,22.03 183.66,22.03 183.37,21.74 144.44,21.74 143.83,22.35 135.47,22.35 133.9,20.78 113.67,20.78 105.68,18.32 90.96,18.32 82.22,27.06 82.22,33.44 69.61,46.06 67.09,46.06 64.68,48.47 62.32,48.47 61.76,49.03 58.29,49.03 57.57,49.74 57.56,49.74 57.5,49.8 56.37,49.8 55.86,49.29 48.75,49.29 48.04,48.58 37.42,48.58 35.19,50.82 33.27,50.82 32.85,51.24 31,51.24 30.43,50.67 29.45,50.67 29.39,50.61 23.55,50.61 22.97,50.03 21.69,50.03 20.49,48.83 20.22,48.83 18.91,47.52 v2(18.91,46.42)
  BOTTOM w0.107: UH1.D11 195.14,36.4 194.73,36.4 194.52,36.2 194.37,36.2 194.05,36.52 192.42,36.52 192.18,36.76 191.91,36.76 191.65,37.02 v2(190.93,37.02)
USB3_PRX_DTX_N6: length 195.1
  TOP w0.107: v2(24.28,39.22) 24.1,39.39 23.35,39.39 23.23,39.28 LU5.1
  IN6 w0.089: v2(196.4,34.29) 194.17,32.06 193.31,32.06 193.3,32.06 193,32.06 192.99,32.06 191.86,32.06 191.79,32.13 191.09,32.13 190.13,33.09 187.4,33.09 187.19,32.88 185.04,32.88 184.64,33.28 183.92,33.28 183.23,32.59 182.84,32.59 180.82,30.56 172.1,30.56 171.27,29.73 109,29.73 109,29.74 108.78,29.74 102.9,35.62 102.9,41.89 97.89,46.89 96.6,46.89 94.76,48.72 65.91,48.72 65.59,49.04 57.77,49.04 57.32,49.48 46.68,49.48 45.85,50.31 45.35,50.31 44.71,49.67 35.66,49.67 35.28,49.29 34.05,49.29 31.31,46.56 30.9,46.56 29.19,44.84 29.19,43.36 28.37,42.53 28.37,42.38 25.38,39.39 24.6,39.39 24.59,39.41 24.46,39.41 v2(24.28,39.22)
  BOTTOM w0.107: v2(196.4,34.29) 196.75,34.64 UH1.G14
USB3_PRX_DTX_N7: length 151
  TOP w0.107: v2(323.99,23.93) 324.18,24.12 324.43,24.12 324.76,24.45 324.86,24.45 325.16,24.16 JIO.26
  IN6 w0.089: v2(197.79,33.42) 197.77,33.42 197.66,33.53 197.66,33.75 197.94,34.03 197.94,37.16 198.29,37.51 198.29,38.48 198.13,38.64 198.13,42.09 199.34,43.3 201.45,43.3 201.72,43.03 203.66,43.03 203.82,42.88 204.97,42.88 205.47,42.38 205.47,41.41 205.76,41.12 206.35,41.12 206.74,41.51 206.74,41.9 207.06,42.22 210.47,42.22 210.89,41.8 213.78,41.8 214.31,42.33 222.6,42.33 224.64,40.29 230.44,40.29 230.5,40.34 231.13,40.34 231.52,39.96 233.35,39.96 234.43,38.88 238.74,38.88 241.79,35.83 245.73,35.83 246.96,34.6 250.14,34.6 251.73,33.01 262.33,33.01 264.69,30.65 292.32,30.65 293.07,29.9 298.69,29.9 299.58,30.79 299.58,30.83 300.64,31.89 308.52,31.89 310.01,30.41 317.01,30.41 319.31,28.11 319.31,26.62 321.73,24.21 323.71,24.21 v2(323.99,23.93)
  BOTTOM w0.107: UH1.G17 197.61,33.24 v2(197.79,33.42)
USB3_PRX_DTX_N8: length 185.7
  IN1 w0.089: v2(200.78,31.96) 200.46,31.96 200.37,31.87 200.37,31.61 200.46,31.52 201.17,31.52 201.27,31.62 201.27,33.37 200.82,33.81 198.92,33.81 198.47,34.26 198.47,34.72 197.52,35.67 197.52,37.52 196.76,38.28 196.76,39.61 194.38,41.99 192.42,41.99 189.29,45.12 189.29,46.57 188.96,46.9 188.96,52.84 189.87,53.75 189.87,56.72 189.62,56.97 189.62,62.02 190.01,62.42 190.01,64.17 186.23,67.95 186.23,70.07 185.73,70.57 185.73,87.3 187.93,89.49 187.93,94.68 184.82,97.8 184.82,112.99 187.44,115.61 187.44,122.76 189.39,124.71 189.39,132.96 192.05,135.62 192.61,135.62 192.93,135.62 194.07,136.76 194.07,147.49 186.94,154.63 185.73,154.63 185.1,155.26 183.48,155.26 183.09,155.65 182.42,155.65 182.18,155.88 181.24,155.88 180.83,156.29 176.66,156.29 176.26,156.45 172.35,156.45 172.16,156.27 169.48,156.27 164.28,161.47 164.28,168.02 164.09,168.21 164.09,169.9 166.21,172.02 166.21,174.08 v2(165.85,174.44)
  BOTTOM w0.107: CI38.1 166.02,175.23 166.02,174.61 v2(165.85,174.44) ; v2(200.78,31.96) 200.58,31.76 200.58,31.61 UH1.R21
USB3_PRX_DTX_P1: length 214.1
  TOP w0.107: v2(19.49,46.42) 19.24,46.68 19.24,47.15 CU83.2
  IN3 w0.127: v2(19.49,46.42) 19.49,46.43 19.12,46.8 19.12,47.43 20.31,48.61 20.58,48.61 21.78,49.81 23.07,49.81 23.64,50.39 29.48,50.39 29.54,50.45 30.52,50.45 31.09,51.02 32.76,51.02 33.18,50.6 35.1,50.6 37.33,48.36 48.13,48.36 48.84,49.08 55.95,49.08 56.46,49.58 57.41,49.58 57.47,49.53 57.48,49.53 58.2,48.81 61.67,48.81 62.23,48.25 64.59,48.25 67,45.84 69.52,45.84 82,33.35 82,26.97 90.87,18.1 105.71,18.1 113.71,20.56 133.99,20.56 135.56,22.13 143.73,22.13 144.34,21.52 183.47,21.52 183.75,21.81 186.13,21.81 187.14,22.82 187.14,25.58 188.37,26.81 188.97,26.81 189.6,27.44 189.6,31.17 190.91,32.48 190.91,35.44 190.32,36.03 190.32,36.46 190.55,36.69 190.68,36.69 190.83,36.53 v2(190.83,36.45)
  BOTTOM w0.107: UH1.C11 195.09,36.16 195.17,36.08 195.17,35.93 195.09,35.86 194.96,35.86 194.89,35.93 194.87,35.93 194.86,35.93 194.64,35.93 194.57,36 194.29,36 193.97,36.31 192.34,36.31 192.09,36.56 191.83,36.56 191.56,36.82 191.31,36.82 191.1,36.61 191,36.61 v2(190.83,36.45)
USB3_PRX_DTX_P6: length 195.1
  TOP w0.107: LU5.4 23.22,39.78 23.35,39.64 24.11,39.64 v2(24.28,39.81)
  IN6 w0.089: v2(24.28,39.81) 24.51,39.57 24.66,39.57 24.67,39.56 25.31,39.56 28.2,42.45 28.2,42.6 29.03,43.42 29.03,44.91 30.84,46.72 31.24,46.72 33.98,49.46 35.21,49.46 35.59,49.83 44.64,49.83 45.28,50.47 45.92,50.47 46.74,49.65 57.39,49.65 57.83,49.21 65.66,49.21 65.97,48.89 94.83,48.89 96.66,47.06 97.96,47.06 103.06,41.95 103.06,35.69 108.85,29.9 109.07,29.9 109.07,29.9 171.2,29.9 172.03,30.72 180.75,30.72 182.78,32.75 183.16,32.75 183.86,33.45 184.71,33.45 185.11,33.05 187.12,33.05 187.33,33.26 190.2,33.26 191.16,32.29 191.86,32.29 191.93,32.22 192.93,32.22 192.93,32.23 193.37,32.23 193.38,32.22 194.1,32.22 196.03,34.16 196.03,34.6 v2(195.96,34.67)
  BOTTOM w0.107: v2(195.96,34.67) 196.17,34.67 196.27,34.78 UH1.F14
USB3_PRX_DTX_P7: length 151
  TOP w0.102: JIO.27 325.09,24.66
  TOP w0.107: v2(323.99,24.51) 324.18,24.32 324.35,24.32 324.68,24.66 325.09,24.66
  IN6 w0.089: v2(323.99,24.51) 323.85,24.38 323.77,24.38 321.8,24.37 319.48,26.69 319.48,28.18 317.08,30.57 310.08,30.57 308.59,32.06 300.57,32.06 299.41,30.9 299.41,30.86 298.62,30.06 293.14,30.06 292.39,30.81 264.76,30.81 262.4,33.18 251.8,33.18 250.21,34.76 247.03,34.76 245.8,36 241.85,36 238.81,39.04 234.5,39.04 233.42,40.12 231.59,40.12 231.2,40.51 230.43,40.51 230.37,40.45 224.71,40.45 222.67,42.5 214.24,42.5 213.71,41.96 210.96,41.96 210.54,42.38 206.99,42.38 206.57,41.96 206.57,41.58 206.28,41.28 205.83,41.28 205.63,41.48 205.63,42.45 205.04,43.04 203.88,43.04 203.73,43.2 201.79,43.2 201.52,43.46 199.27,43.46 197.96,42.16 197.96,38.57 198.13,38.41 198.13,37.58 197.77,37.23 197.77,34.1 197.42,33.74 v2(197.29,33.74)
  BOTTOM w0.107: UH1.F16 196.39,33.74 v2(197.29,33.74)
USB3_PRX_DTX_P8: length 185.7
  IN1 w0.089: v2(200,31.96) 200.21,31.75 200.21,31.55 200.39,31.36 201.24,31.36 201.43,31.55 201.43,33.46 200.91,33.98 198.99,33.98 198.64,34.33 198.64,34.79 197.68,35.74 197.68,37.59 196.92,38.35 196.92,39.68 194.45,42.15 192.49,42.15 189.45,45.19 189.45,46.64 189.12,46.97 189.12,52.77 190.03,53.68 190.03,56.79 189.78,57.04 189.78,61.95 190.18,62.35 190.18,64.24 186.4,68.02 186.4,70.14 185.9,70.64 185.9,87.23 188.1,89.43 188.1,94.75 184.98,97.87 184.98,112.92 187.6,115.54 187.6,122.69 189.56,124.64 189.56,132.89 192.12,135.45 192.54,135.45 193,135.45 194.24,136.69 194.24,147.56 187.01,154.79 185.79,154.79 185.16,155.42 183.55,155.42 183.16,155.81 182.49,155.81 182.25,156.05 181.31,156.05 180.9,156.45 176.73,156.45 176.33,156.62 172.28,156.62 172.09,156.44 169.55,156.44 164.45,161.53 164.45,168.09 164.26,168.28 164.26,169.83 166.38,171.95 166.38,174.39 v2(166.44,174.44)
  BOTTOM w0.107: v2(166.44,174.44) 166.25,174.63 166.25,175.25 CI39.1 ; UH1.P21 200,31.96 v2(200,31.96)
USB3_PRX_L_DTX_N6: length 9.8
  TOP w0.099: JUSB1.5 15.05,36.08
  TOP w0.107: 15.05,36.08 15.14,36.18 15.4,36.18 16.41,37.19 17.41,37.19 v4(17.66,37.44) 17.92,37.7 17.92,38.94 18.4,39.42 18.8,39.42 18.94,39.29 DU2.9 DU2.1 20.73,39.29 20.86,39.42 21.17,39.42 21.32,39.28 LU5.2
USB3_PRX_L_DTX_P6: length 9.9
  TOP w0.099: JUSB1.6 15.05,36.48
  TOP w0.107: 15.05,36.48 15.15,36.38 15.32,36.38 16.33,37.39 17.28,37.39 17.71,37.82 17.71,39.06 v4(18.02,39.37) 18.28,39.63 18.89,39.63 19.05,39.79 DU2.8 DU2.2 20.73,39.79 20.89,39.63 21.17,39.63 21.31,39.78 LU5.3
USB3_PTX_C_DRX_N6: length 1.5
  TOP w0.099: LU4.1 23.4,40.8 23.54,40.94 23.83,40.94 CU13.1
USB3_PTX_C_DRX_P6: length 1.5
  TOP w0.099: CU12.1 23.83,41.16 23.54,41.16 23.4,41.3 LU4.4
USB3_PTX_C_RD_DRX_N1: length 1.8
  TOP w0.107: UU2.40 17.17,49.7 17.27,49.6 17.27,48.76 CU49.1
USB3_PTX_C_RD_DRX_P1: length 1.8
  TOP w0.107: UU2.41 17.57,49.68 17.47,49.58 17.47,48.83 CU50.1
USB3_PTX_DRX_N1: length 219.5
  TOP w0.107: CU49.2 17.22,47.29 17.22,47.19 17.22,46.73 v2(17.08,46.59)
  IN3 w0.127: v2(196.92,37.33) 196.84,37.42 196.01,37.42 195.91,37.52 195.09,37.52 194.5,36.93 191.73,36.93 191.08,37.58 190.45,37.58 189.56,36.69 189.56,35.87 189.67,35.76 189.99,35.43 189.99,33.63 189.11,32.75 189.11,31.97 188.95,31.81 188.95,28.78 188.52,28.36 187.47,28.36 186.38,27.28 186.38,24.6 184.8,23.01 180.07,23.01 179.22,22.17 145.03,22.17 144.85,22.34 144.44,22.34 144,22.78 135.29,22.78 134.85,22.34 121.59,22.34 117.93,21.21 113.61,21.21 105.61,18.75 91.14,18.75 82.65,27.24 82.65,33.62 69.79,46.49 68.07,46.49 65.54,49.01 62.39,49.01 61.94,49.46 58.47,49.46 57.75,50.18 57.74,50.18 57.68,50.23 56.19,50.23 55.68,49.73 48.57,49.73 47.86,49.02 37.6,49.02 35.37,51.25 34.48,51.25 33.7,52.02 26.32,52.02 26.22,52.12 24.46,52.12 22.8,50.46 20.31,50.46 19.25,49.4 19.25,48.76 18.42,47.93 18.42,45.81 18.17,45.56 17.38,45.56 17.08,45.86 v2(17.08,46.59)
  BOTTOM w0.107: UH1.F9 196.81,37.27 v2(196.92,37.33)
USB3_PTX_DRX_N6: length 195.5
  TOP w0.107: v2(25.89,40.71) 25.89,40.99 25.82,41.06 25.44,41.06 25.08,40.71 CU13.2
  IN6 w0.089: v2(25.89,40.71) 25.89,41.13 25.8,41.23 25.8,41.49 25.97,41.67 27.09,42.62 27.09,43.56 27.44,43.91 27.44,45.01 27.64,45.21 27.64,45.78 28.27,46.41 29.73,46.41 30.65,47.32 30.95,47.32 32.37,48.74 32.37,49.48 32.69,49.8 32.69,49.81 34.12,51.24 42.83,51.24 43.5,51.91 45.5,51.91 47.13,50.28 57.9,50.28 58.33,49.85 65.91,49.85 66.24,49.52 95.12,49.52 96.95,47.69 98.22,47.69 103.78,42.13 103.78,35.98 109.06,30.7 170.5,30.7 171.09,31.28 180.08,31.28 183.02,34.22 184.9,34.22 185.43,33.68 186.63,33.68 186.91,33.96 190.37,33.96 191.36,32.97 192.04,32.97 192.18,32.84 192.64,32.84 192.96,33.16 192.96,34.43 192.79,34.6 192.57,34.6 v2(192.31,34.34)
  BOTTOM w0.107: UH1.C17 194.69,33.67 194.32,33.82 193.63,33.82 192.81,34.65 192.62,34.65 v2(192.31,34.34)
USB3_PTX_DRX_N7: length 160.5
  TOP w0.102: JIO.29 325.12,25.66 324.98,25.79 323.87,25.79 323.77,25.69 323.77,25.43 v2(324.04,25.16)
  IN6 w0.089: v2(192.49,33.2) 192.33,33.37 191.52,33.37 191.33,33.55 191.33,35.21 193.54,37.42 193.54,39.87 194.06,40.39 194.06,44.48 194.72,45.14 195.57,45.14 195.74,44.97 196.26,44.97 196.65,44.57 196.95,44.57 198.15,45.77 199.5,45.77 200.02,46.28 201.05,46.28 202.26,45.08 202.26,44.57 202.83,44 204.05,44 204.94,44.88 210.28,44.88 210.55,44.61 215.9,44.61 215.98,44.69 223.76,44.69 224.97,43.48 227.99,43.48 228.52,42.95 230.06,42.95 230.57,42.43 231.61,42.43 232.55,41.49 233.84,41.49 235.02,40.31 239.54,40.31 240.75,39.11 247.28,39.11 250.1,36.29 252.18,36.29 253.96,34.51 263.41,34.51 265.56,32.36 271.61,32.36 271.94,32.69 289.66,32.69 291.29,34.32 309.53,34.32 309.6,34.25 309.71,34.25 311.52,32.44 316.66,32.44 321,28.1 321,27.54 321.44,27.11 322.59,27.11 323.76,25.93 323.76,25.47 v2(324.04,25.16)
  BOTTOM w0.107: UH1.A17 193.64,33.39 192.68,33.39 v2(192.49,33.2)
USB3_PTX_DRX_N8: length 208.7
  IN3 w0.127: v2(168.89,177.53) 169.05,177.36 169.05,177.36 169.14,177.27 169.14,176.62 169.59,176.18 179.26,176.18 179.73,176.65 180.29,176.65 180.86,176.07 183.85,176.07 185.18,174.74 188.67,174.74 188.93,175.01 189.4,175.01 191.28,173.13 193.05,173.13 193.49,172.69 197.45,172.69 201.17,172.69 202.99,170.86 203.3,170.86 205.41,168.76 205.41,167.57 208.29,164.68 208.29,162.77 207.59,162.07 206.42,162.07 206.04,161.69 206.04,160.68 206.99,159.73 206.99,156.04 205.62,154.67 205.62,150.55 204.96,149.88 204.96,148.99 204.96,144.91 206.78,143.09 206.78,135.01 206.05,134.29 206.05,130.98 206.42,130.61 206.42,130.09 206.42,130.09 206.42,129.74 206.42,129.74 206.42,127.72 202.23,123.53 202.23,122.57 200.35,120.69 200.35,118.5 198.21,116.36 198.21,115.68 197.66,115.13 196.11,115.13 195.19,114.21 191.81,114.21 190.25,112.66 190.25,112.43 189.86,112.04 189.86,111.4 188.01,109.55 188.01,108.7 187.17,107.86 187.17,106.95 185.34,105.12 185.34,101.3 185.15,101.1 185.15,95.54 185.49,95.19 185.49,90.15 184.44,89.1 184.44,72.48 182.07,70.11 182.07,61.27 182.43,60.91 182.43,54.71 182.84,54.3 182.84,52.31 183.57,51.58 183.57,46.31 183.84,46.05 183.84,41.71 184.3,41.26 184.3,34.8 184.65,34.44 185.39,34.44 185.45,34.38 185.46,34.38 v2(185.56,34.28)
  BOTTOM w0.107: v2(185.56,34.28) 185.75,34.47 187.18,34.47 188.09,35.38 189.31,35.38 192.13,32.57 193.86,32.57 194.11,32.81 194.26,32.81 194.26,32.81 194.36,32.81 UH1.B18 ; v2(168.89,177.53) 169.16,177.8 169.16,178.5 169.02,178.64 JCDRA.42
USB3_PTX_DRX_P1: length 219.5
  TOP w0.107: v2(17.66,46.59) 17.64,46.59 17.42,46.81 17.42,47.11 CU50.2
  IN3 w0.127: v2(17.66,46.59) 17.66,46.58 17.3,46.21 17.3,45.95 17.47,45.77 18.08,45.77 18.21,45.9 18.21,48.02 19.03,48.85 19.03,49.49 20.22,50.68 22.7,50.68 24.37,52.34 26.31,52.34 26.41,52.24 33.79,52.24 34.57,51.47 35.46,51.47 37.69,49.23 47.77,49.23 48.48,49.94 55.59,49.94 56.1,50.45 57.77,50.45 57.83,50.39 57.84,50.39 58.56,49.68 62.03,49.68 62.48,49.23 65.63,49.23 68.16,46.71 69.88,46.71 82.87,33.71 82.87,33.33 82.87,27.33 91.23,18.97 105.58,18.97 113.57,21.43 117.9,21.43 121.56,22.56 134.76,22.56 135.2,23 144.1,23 144.53,22.56 144.94,22.56 145.12,22.39 179.13,22.39 179.98,23.23 184.71,23.23 186.16,24.69 186.16,27.37 187.37,28.58 188.43,28.58 188.73,28.87 188.73,31.9 188.89,32.06 188.89,32.84 189.77,33.73 189.77,35.34 189.45,35.67 189.34,35.78 189.34,36.78 190.35,37.8 191.17,37.8 191.82,37.15 194.41,37.15 194.99,37.74 196,37.74 196.1,37.63 196.51,37.63 196.65,37.77 v2(196.65,37.88)
  BOTTOM w0.107: v2(196.65,37.88) 196.43,37.71 196.15,37.74 196.05,37.85 UH1.F7
USB3_PTX_DRX_P6: length 195.6
  TOP w0.107: v2(26.31,41.12) 26.3,41.12 26.05,41.12 25.9,41.27 25.3,41.27 25.08,41.49 CU12.2
  IN6 w0.089: v2(26.31,41.12) 26.14,41.12 25.96,41.3 25.96,41.42 26.09,41.55 27.25,42.55 27.25,43.49 27.61,43.84 27.61,44.94 27.81,45.14 27.81,45.71 28.33,46.24 29.8,46.24 30.72,47.16 31.02,47.16 32.53,48.67 32.53,48.81 32.53,49.41 32.86,49.73 32.86,49.74 34.19,51.07 42.9,51.07 43.57,51.74 45.43,51.74 47.06,50.12 57.83,50.12 58.26,49.69 65.84,49.69 66.17,49.36 95.05,49.36 96.88,47.53 98.15,47.53 103.62,42.06 103.62,35.91 109,30.53 170.57,30.53 171.15,31.12 180.15,31.12 183.08,34.05 184.83,34.05 185.37,33.52 186.7,33.52 186.98,33.8 190.3,33.8 191.29,32.81 191.98,32.81 192.11,32.67 192.71,32.67 193.13,33.09 193.13,34.5 192.86,34.76 192.48,34.76 v2(192.31,34.93)
  BOTTOM w0.107: UH1.C16 194.73,33.87 194.36,34.03 193.72,34.03 192.89,34.85 192.39,34.85 v2(192.31,34.93)
USB3_PTX_DRX_P7: length 160.6
  TOP w0.102: v2(323.29,25.2) 323.54,25.45 323.54,25.78 323.78,26.02 324.93,26.02 325.07,26.16 JIO.30
  IN6 w0.089: v2(323.29,25.2) 323.59,25.48 323.59,25.87 322.52,26.94 321.37,26.94 320.84,27.47 320.84,28.03 316.6,32.26 311.51,32.26 311.5,32.27 311.45,32.27 311.35,32.37 311.35,32.38 309.65,34.08 309.53,34.08 309.46,34.15 291.36,34.15 289.73,32.52 272.01,32.52 271.68,32.19 265.5,32.19 264.85,32.83 264.84,32.83 263.38,34.29 263.38,34.3 263.34,34.34 263.34,34.34 253.89,34.34 252.11,36.12 250.03,36.12 247.21,38.94 240.68,38.94 239.48,40.15 234.95,40.15 233.77,41.33 232.48,41.33 231.54,42.27 230.5,42.27 229.99,42.78 228.45,42.78 227.92,43.31 224.9,43.31 223.69,44.52 216.05,44.52 215.97,44.44 210.48,44.44 210.21,44.71 205.01,44.71 204.12,43.83 202.76,43.83 202.09,44.5 202.09,45.01 200.98,46.12 200.08,46.12 199.57,45.6 198.22,45.6 197.02,44.41 196.58,44.41 196.19,44.8 195.67,44.8 195.5,44.97 194.79,44.97 194.22,44.41 194.22,40.32 193.71,39.81 193.71,37.35 191.5,35.14 191.5,33.62 191.59,33.53 192.24,33.53 v2(192.49,33.78)
  BOTTOM w0.107: UH1.B17 194.13,33.59 192.68,33.59 v2(192.49,33.78)
USB3_PTX_DRX_P8: length 208.8
  IN3 w0.127: v2(169.47,177.53) 169.36,177.42 169.36,176.72 169.68,176.4 179.17,176.4 179.64,176.87 180.38,176.87 180.95,176.29 183.94,176.29 185.27,174.96 188.58,174.96 188.84,175.23 189.49,175.23 191.37,173.35 193.14,173.35 193.58,172.9 197.36,172.9 201.26,172.9 203.08,171.08 203.39,171.08 205.62,168.85 205.62,167.66 208.51,164.77 208.51,162.68 207.68,161.85 206.51,161.85 206.26,161.6 206.26,160.77 207.21,159.82 207.21,155.95 205.84,154.58 205.84,150.46 205.17,149.79 205.17,148.9 205.17,145 206.99,143.18 206.99,134.92 206.27,134.2 206.27,131.07 206.64,130.7 206.64,130.18 206.64,130.18 206.64,129.65 206.64,129.64 206.64,127.63 202.45,123.43 202.45,122.48 200.57,120.6 200.57,118.41 198.42,116.27 198.42,115.59 197.75,114.91 196.2,114.91 195.28,114 191.9,114 190.47,112.57 190.47,112.34 190.08,111.95 190.08,111.31 188.23,109.46 188.23,108.61 187.38,107.77 187.38,106.86 185.56,105.03 185.56,101.2 185.37,101.01 185.37,95.63 185.71,95.29 185.71,90.06 184.66,89.01 184.66,72.39 182.29,70.02 182.29,61.37 182.65,61 182.65,54.8 183.06,54.39 183.06,52.4 183.79,51.67 183.79,46.41 184.06,46.14 184.06,41.8 184.51,41.35 184.51,34.89 184.74,34.66 185.35,34.66 v2(185.56,34.86)
  BOTTOM w0.089: UH1.C18 194.7,32.97
  BOTTOM w0.107: JCDRA.43 169.42,178.61 169.36,178.55 169.36,177.64 v2(169.47,177.53) ; 194.7,32.97 194.64,33.04 194.04,33.04 193.78,32.77 192.21,32.77 189.4,35.58 188.01,35.58 187.1,34.67 185.75,34.67 v2(185.56,34.86)
USB3_PTX_L_DRX_N6: length 8.7
  TOP w0.099: JUSB1.8 15.05,42.83 15.18,42.96 ; 18.96,40.93 18.96,40.93
  TOP w0.107: 18.96,40.93 19.1,40.79 DU2.7 DU2.4 20.73,40.79 20.86,40.92 21.13,40.92 21.25,40.8 LU4.2 ; 15.18,42.96 15.3,42.96 16.24,42.01 17.17,42.01 17.55,41.64 17.55,41.33 17.95,40.94 v4(18.23,40.94) 18.95,40.94 18.96,40.93
USB3_PTX_L_DRX_P6: length 8.8
  TOP w0.099: JUSB1.9 15.05,43.32 15.18,43.19 15.36,43.19
  TOP w0.107: LU4.3 21.25,41.3 21.09,41.14 20.87,41.14 20.73,41.29 DU2.5 DU2.6 19.08,41.29 18.94,41.14 18.53,41.14 18.51,41.17 18,41.17 17.75,41.42 17.75,41.76 v4(17.5,42.02) 17.29,42.22 16.33,42.22 15.36,43.19
USB3_RUF1: length 13.6
  TOP w0.107: v2(8.36,61.27) 8.23,61.27 8.19,61.22 JUSBC2.A8
  BOTTOM w0.102: DU20.7 DU20.4 13.15,67.08 12.56,67.66 11.16,67.66 10.88,67.38 10.88,67.04 10.88,67.04
  BOTTOM w0.107: 10.88,67.04 10.88,66.62 9.91,65.65 v1(9.38,65.65) 8.39,65.65 7.57,64.82 7.57,61.51 7.8,61.27 v2(8.36,61.27)
USB3_RUF2: length 11.8
  TOP w0.107: v2(6.71,63.01) 6.68,62.97 JUSBC2.B8
  BOTTOM w0.102: DU20.5 DU20.6
  BOTTOM w0.107: DU20.5 13.03,67.58 12.59,68.01 v1(11.92,68.01) 11.18,68.01 10.65,67.48 10.65,66.71 9.92,65.98 8.34,65.98 7.21,64.85 7.21,63.51 v2(6.71,63.01)
USB20_N1: length 210.9
  TOP w0.107: v2(25.82,42.15) 25.57,42.15 25.39,41.97 24.98,41.97 24.64,42.32 v4(23.06,42.32) 22.7,42.32 22.33,42.7 UU1.2
  IN6 w0.089: v2(25.82,42.15) 25.82,42.37 26.02,42.58 26.02,43.08 26.55,43.61 26.55,45.46 28.77,47.68 28.77,48.38 29.73,49.33 30.47,49.33 32.84,51.71 42.37,51.71 43.04,52.38 45.71,52.38 47.33,50.75 67.02,50.75 67.29,50.49 81.56,50.49 81.92,50.85 86.86,50.85 87.54,50.17 95.18,50.17 97.19,48.16 98.42,48.16 104.43,42.15 104.43,36.13 105.45,35.11 106.77,35.11 110.51,31.36 170.32,31.36 170.83,31.87 179.97,31.87 183.71,35.61 187.52,35.61 187.74,35.83 188.74,35.83 192.77,39.86 192.77,41.42 192.48,41.71 192.48,42.85 191.59,43.74 191.59,44.31 192.88,45.61 195.97,45.61 196.45,45.12 196.62,45.12 196.8,44.94 v2(196.8,44.93)
  BOTTOM w0.089: UH1.J3 197.79,40.25
  BOTTOM w0.107: 197.79,40.25 197.73,40.31 197.73,40.67 197.79,40.73 197.79,41.67 197.14,42.33 197.14,42.43 197.05,42.52 197.05,43.55 196.85,43.75 196.85,44.4 197.17,44.73 197.17,44.94 197.07,45.05 196.92,45.05 v2(196.8,44.93)
USB20_N2: length 157.4
  TOP w0.107: JIO.23 324.98,22.66 324.87,22.76 324.87,22.85 324.81,22.91 324.3,22.91 323.83,22.44 323.83,21.51 323.04,20.71 322.48,20.71 322.37,20.61 322.37,20.27 v2(322.56,20.08)
  IN6 w0.089: v2(199.03,35.03) 199.29,34.78 199.43,34.79 199.97,34.79 200.61,34.15 202.49,34.15 202.8,34.46 202.8,35.56 205.13,37.9 206.02,37.9 206.41,38.29 206.41,38.99 206.93,39.51 207.36,39.51 208.02,40.17 208.4,40.17 208.54,40.17 208.59,40.12 209.56,39.14 213.81,39.14 215.03,40.36 218.97,40.36 219.34,40 219.34,37.39 220.42,36.31 221.49,36.31 221.75,36.31 222.15,35.91 222.28,35.91 222.28,35.91 223.14,35.91 224.12,36.88 226.66,36.88 229.88,33.66 229.88,26.98 231.12,25.74 233.97,25.74 235.1,24.61 235.6,24.61 236.23,23.98 236.23,23.5 236.94,22.79 239.61,22.79 242.23,25.4 242.37,25.4 244.48,25.4 245.63,26.55 245.63,27.04 249.12,30.53 259.39,30.53 260.38,29.54 266.03,29.54 266.69,28.88 277.31,28.88 278.29,27.91 281.88,27.91 282.96,28.98 291.16,28.98 294.4,25.75 303.57,25.75 306.79,22.53 310.47,22.53 311.59,21.41 312.39,21.41 313.43,20.37 320.16,20.37 320.53,20.73 322.17,20.73 322.35,20.54 322.35,20.29 v2(322.56,20.08)
  BOTTOM w0.107: v2(199.03,35.03) 199.08,35.08 UH1.N13
USB20_N3: length 173.9
  IN1 w0.089: v2(168.49,173.96) 168.39,173.85 168.39,170.59 165.15,167.35 165.15,161.73 168.18,158.7 171.5,158.7 172.63,157.57 174.45,157.57 174.61,157.41 176.56,157.41 176.74,157.58 181,157.58 181.9,156.68 182.51,156.68 182.75,156.45 183.43,156.45 183.82,156.06 185.43,156.06 186.06,155.43 187.27,155.43 194.87,147.82 194.87,147.3 194.87,136.37 190.36,131.85 190.36,124.25 188.62,122.51 188.62,115.41 185.68,112.47 185.68,98.06 188.76,94.98 188.76,89.04 186.54,86.82 186.54,71.2 187.56,70.18 187.56,68.52 189.63,66.46 192.33,66.46 192.94,65.85 194.47,65.85 194.8,65.52 194.8,64.29 194.51,64 194.51,59.95 193.79,59.23 193.79,54.71 195.85,52.65 195.85,51.62 197.16,50.31 197.43,50.31 198.62,49.12 198.62,48.07 198.62,48.06 198.62,46.23 199.12,45.73 199.12,44.7 v2(199.21,44.62)
  BOTTOM w0.107: LM1.1 168.47,174.8 168.32,174.65 168.32,174.12 v2(168.49,173.96) ; UH1.K4 198.55,39.65 198.55,43.41 199.21,44.06 v2(199.21,44.62)
USB20_N3_R: length 3.4
  BOTTOM w0.099: LM1.2 168.47,176.71 ; JCDRA.40 168.22,178.46
  BOTTOM w0.107: 168.47,176.71 168.35,176.84 v4(168.35,177.35) 168.35,177.82 168.09,178.07 168.09,178.33 168.22,178.46
USB20_N4: length 139.3
  TOP w0.107: v2(315.16,21.45) 315.16,21.04 315.79,20.41 UE1.32
  IN6 w0.089: v2(315.16,21.45) 315.16,21.09 315.25,21 315.48,21 315.69,21.21 315.69,21.91 315.15,22.44 314.49,22.44 313.38,23.56 312.44,23.56 311.88,23 306.98,23 302.09,27.89 293.1,27.89 291.54,29.45 267.47,29.45 266.91,30.01 260.57,30.01 259.58,31 247.57,31 245.44,33.14 241.72,33.14 240.94,33.91 240.94,35.62 238.56,38 236.71,38 235.72,37.01 232.74,37.01 230.11,39.64 224.39,39.64 222.33,41.7 214.54,41.7 213.86,41.01 209.56,41.01 209.34,41.23 207.34,41.23 206.71,40.59 204.85,40.59 203.72,41.72 203.72,42.49 203.52,42.68 200.86,42.68 199.82,41.64 199.82,40.21 200.16,39.87 200.16,39.19 199.46,38.49 199.46,37.58 199.16,37.28 199.16,37.09 198.89,36.86 198.85,36.36 v2(198.89,36.31)
  BOTTOM w0.107: UH1.M10 199.17,36.71 199,36.71 198.89,36.6 v2(198.89,36.31)
USB20_N6: length 193.5
  TOP w0.099: DV2.3 161.73,168.41 162.19,167.95
  TOP w0.107: DV2.3 162.31,168.42 162.57,168.67 162.57,169.79 160.08,172.28 160.08,173.58 157.27,176.39 157.27,178.49 159.62,180.85 JEDP.17 ; v2(166.15,166.42) 163.83,166.42 162.98,167.28 162.76,167.28 162.52,167.51 162.52,167.82 162.39,167.95 162.19,167.95
  IN1 w0.089: v2(166.15,166.42) 166.96,166.42 167.42,165.96 167.42,163.3 168.5,162.22 175.56,162.22 177.95,159.83 184.16,159.83 184.41,159.58 187.97,159.58 188.25,159.3 188.25,159.12 190.03,157.34 190.03,154.74 195.98,148.79 195.98,148.28 195.98,148.28 195.98,146.84 195.98,146.84 195.98,145.33 196.36,144.96 196.36,134.34 191.74,129.73 191.74,124.07 189.75,122.07 189.75,114.27 186.79,111.32 186.79,99.13 187.65,98.28 187.65,97.67 189.87,95.44 189.87,88.58 187.65,86.36 187.65,71.66 188.67,70.64 188.67,68.98 190.08,67.56 192.79,67.56 193.4,66.95 195.07,66.95 195.91,66.11 195.91,63.8 196.72,62.98 196.72,60.47 194.89,58.63 194.89,55.17 196.95,53.11 196.95,52.08 197.62,51.41 198.07,51.41 200.06,49.42 200.06,48.23 200.27,48.02 200.27,46.77 200.45,46.6 200.45,45.63 200.38,45.56 200.38,45.24 200.28,45.14 v2(200.18,45.14)
  IN6 w0.089: v2(200.18,45.14) 200.38,44.95 200.38,44.79 200.26,44.67 199.93,44.67 199.42,44.16 198.95,44.16 196.76,41.97 196.76,38.49 197.01,38.24 197.25,38.24 197.4,38.29 v2(197.64,38.18)
  BOTTOM w0.107: v2(197.64,38.18) 198.12,38.18 UH1.K7
USB20_N7: length 171.2
  TOP w0.107: LV2.1 167.02,162.8 167.31,162.5 167.31,161.83 167.59,161.56 v4(167.59,161.52) 167.96,161.15 167.96,160.59 168.15,160.4 168.15,160.31 v2(167.77,159.93)
  IN1 w0.089: v2(201.59,42.32) 201.84,42.02 201.83,41.73 201.74,41.65 200.67,41.65 200.26,42.05 200.26,42.8 199.74,43.33 199.74,44.8 199.72,44.82 199.72,45.58 199.98,45.84 199.98,46.4 199.8,46.58 199.8,47.82 199.59,48.03 199.59,49.23 197.88,50.94 197.42,50.94 196.48,51.88 196.48,52.91 194.42,54.98 194.42,58.97 195.14,59.69 195.14,63.64 195.44,63.93 195.44,65.78 194.74,66.48 193.2,66.48 192.59,67.09 189.89,67.09 188.2,68.78 188.2,70.45 187.18,71.47 187.18,86.56 189.4,88.78 189.4,95.25 187.18,97.47 187.18,98.08 186.32,98.94 186.32,112.21 189.26,115.15 189.26,122.25 191.18,124.17 191.18,129.9 195.51,134.23 195.51,147.03 195.51,147.03 195.51,148.09 195.51,148.09 195.51,148.6 189.49,154.61 189.49,156.5 188.44,157.55 184.93,157.55 184.52,157.14 184.18,157.14 183.94,157.37 183.94,157.56 183.34,158.17 182.49,158.17 181.38,159.27 175.74,159.27 174.91,158.45 173.08,158.45 171.31,160.23 171.31,160.58 170.93,160.96 168.53,160.96 168.19,160.61 168.19,160.35 v2(167.77,159.93)
  BOTTOM w0.107: v2(201.59,42.32) 201.74,42.47 201.74,42.57 201.58,42.73 200.05,42.73 199.55,43.22 199.23,43.22 198.95,42.95 198.95,42.09 199.42,41.63 199.42,41 199.24,40.82 199.24,40.02 199.07,39.85 198.96,39.85 198.85,39.75 UH1.L4
USB20_N7_R: length 24.9
  TOP w0.107: LV2.2 167.02,164.71 167.23,164.92 167.23,165.25 167.49,165.51 167.49,165.58 167.89,165.98 167.89,166.96 166.95,167.9 166.95,168.29 166.79,168.46 DV4.3 166.99,169.36 166.99,170 166.88,170.11 163.27,170.11 161.29,172.09 161.29,173.9 160.66,174.52 160.66,177.66 161.38,178.38 161.38,179.66 160.77,180.28 160.77,181.23 160.62,181.38 JEDP.19
USB20_N8: length 218.2
  IN3 w0.127: v2(195.51,43.11) 195.88,43.47 195.88,43.68 195.75,43.81 195.46,43.81 195.13,43.47 194.93,43.15 193.81,39.94 193.36,39.49 188.92,37.87 188.8,37.73 188.8,35.59 188.98,35.41 188.98,33.65 188.37,33.04 188.37,32.6 188.22,32.45 188.22,29.63 187.68,29.09 187.28,29.09 187.16,29.09 185.65,27.58 185.65,24.9 184.5,23.74 178.7,23.74 178.46,23.5 124.38,23.5 105.67,21.77 90.59,21.77 87.7,24.11 87.68,24.12 87.67,24.15 84.65,30.77 83.53,33.23 83.38,33.38 83.38,33.92 70.07,47.24 67.64,47.94 65.84,49.74 63.3,50.97 55.89,50.97 55.38,50.45 44.08,50.45 35.9,51.78 35.85,51.79 35.67,51.97 34.78,51.97 34,52.75 27.21,52.75 21.44,55.05 21.43,55.07 19.43,56.36 19.06,56.6 18.95,56.76 18.71,57.27 18.7,57.32 17.97,58.04 16.45,58.04 15.98,58.51 15.98,58.67 15.78,58.87 15.78,58.88 v2(15.62,59.05)
  BOTTOM w0.107: LU9.4 15.66,59.65 15.81,59.5 15.81,59.24 v2(15.62,59.05) ; v2(195.51,43.11) 195.83,42.79 195.83,42.61 196.34,42.1 196.34,42 196.99,41.34 196.99,41.08 196.85,40.93 196.85,40.4 196.8,40.35 196.8,40.06 196.6,39.86 196.6,39.71 UH1.G4
USB20_N8_R: length 18.8
  TOP w0.107: JUSBC2.A7 8.03,61.73 8.21,61.9 8.61,61.9 v2(8.82,61.7) ; JUSBC2.B7 6.24,62.48 6.29,62.42 v2(6.71,62.42)
  IN1 w0.089: v2(8.82,61.7) 9.5,61.7 9.85,62.05 9.85,62.49 9.85,62.51 9.85,62.87 9.85,63.6 9.48,63.97 7.92,63.97 7.23,63.28 7.23,62.59 7.06,62.42 v2(6.71,62.42)
  BOTTOM w0.107: v2(8.82,61.7) 9.68,61.7 10.19,62.21 12.4,62.21 13.23,61.38 13.49,61.38 13.72,61.14 13.72,60.77 DU11.3 14.36,60.98 14.36,61.29 14.84,61.76 15.71,61.76 15.82,61.65 15.82,61.52 15.66,61.36 LU9.3
USB20_N9: length 175.8
  TOP w0.107: v2(198.83,38.48) 198.6,38.18 198.23,38.13 197.93,37.78 197.93,36.06 197.55,35.68 194.83,35.68 192.67,37.84 192.67,38.04 192.88,38.26 v2(192.88,38.26)
  IN1 w0.089: v2(192.88,38.26) 192.62,38.53 192.62,38.76 192.41,38.97 190.86,38.97 190.23,39.61 190.23,39.75 190.23,41.76 187.77,44.22 187.77,54.27 188.8,55.31 188.8,56.28 188.79,56.3 188.18,56.9 188.18,62.39 187.74,62.84 186.1,64.47 186.1,64.59 185.17,65.53 185.17,67.51 185.17,68.13 184.22,69.08 184.22,69.99 184.35,70.12 184.35,71.96 184.67,72.28 184.67,74.93 184.64,74.96 184.64,87.72 184.67,87.75 184.67,87.76 186.86,89.95 186.86,94.25 183.58,97.53 182.81,97.53 182.23,98.1 182.23,106.79 183.71,108.27 183.71,113.41 186.38,116.08 186.38,123.3 188.18,125.11 188.18,133.3 188.27,133.39 188.27,143.86 187.21,144.92 187.21,147.67 184.49,150.39 183.97,150.39 183.83,150.52 169.27,150.52 169.15,150.65 166.24,150.65 162.38,154.51 162.38,157.42 160.31,159.49 158.35,159.49 156,161.85 156,163.37 156.29,163.66 156.31,163.66 v2(156.36,163.72)
  BOTTOM w0.107: UH1.M6 199.41,38.55 199.24,38.37 198.94,38.37 v2(198.83,38.48) ; RE647.1 157.4,166.1 LE3.1 157.37,165.87 157.21,165.71 157.21,164.87 156.28,163.95 156.28,163.8 v2(156.36,163.72)
USB20_N9_R: length 5
  TOP w0.102: v2(156.86,169.36) 156.67,169.17 156.45,169.17 156.16,168.87 JTOBII.3
  BOTTOM w0.102: RE647.2 157.54,167.19 LE3.2
  BOTTOM w0.107: LE3.2 157.37,168.3 157.51,168.44 157.51,169.02 157.28,169.24 156.98,169.24 v2(156.86,169.36)
USB20_N10: length 102.5
  TOP w0.107: v2(153.23,4.5) 153.04,4.31 153.04,2.53 152.47,1.96 147.77,1.96 147.07,2.66 147.07,5.64 146.5,6.21 v4(145.86,6.21) 145.32,6.21 145.07,5.97 145.07,5.54 145.17,5.43 145.18,5.43 145.29,5.32 DK1.2 145.15,4.85 145,4.85 144.89,4.74 144.89,4.55 143.98,3.64 143.98,3.15 v2(144.17,2.96)
  IN6 w0.089: v2(196.01,44.44) 196.01,44.44 195.81,44.26 195.81,44.07 194.92,43.18 194.92,36.62 197.02,34.51 197.02,34.12 196.76,33.85 196.76,32.97 194.7,30.92 191.69,30.92 191.11,31.49 190.83,31.49 190.37,31.95 183.16,31.95 180.97,29.76 172.73,29.76 171.67,28.71 162.39,28.71 161.94,28.25 v2(161.94,27.32)
  BOTTOM w0.089: UH1.H3 197.52,40.32 197.52,40.55 197.53,40.56
  BOTTOM w0.107: v2(144.17,2.96) 144.08,2.87 JPK.10 ; v2(153.23,4.5) 153.04,4.69 153.04,10.6 161.93,19.49 161.93,27.32 v2(161.94,27.32) ; 197.53,40.56 197.53,40.75 197.59,40.81 197.59,41.59 196.94,42.24 196.94,42.35 196.74,42.55 196.74,43.27 196.33,43.68 195.97,43.68 195.82,43.84 195.82,44.25 196.01,44.44 v2(196.01,44.44)
USB20_N11: length 182.8
  TOP w0.107: v2(189.09,146.3) 189.28,146.49 192.81,146.49 194.75,144.54 201.22,144.54 205.86,149.18 205.86,152.38 206.05,152.57 206.38,152.57 v2(206.55,152.4) ; v2(207.01,163.62) 207.21,163.82 207.21,168.95 205.27,170.88 202.95,170.88 202.62,170.54 202.62,170.34 202.41,170.13 202.41,169.74 RT114.1
  IN4 w0.127: v2(199.87,36.58) 199.79,36.66 199.55,36.66 199.53,36.63 199.17,36.63 198.58,37.23 198.09,37.23 197.09,36.22 194.97,36.22 193.54,37.65 191.65,37.65 191.12,38.18 190.36,38.18 189.72,38.82 189.72,40.92 184.62,46.02 184.62,46.8 184.35,47.07 184.35,50.28 182.98,51.65 181.34,51.65 180.77,52.22 180.77,56.44 180.98,56.66 180.98,58.83 180.37,59.44 180.37,65.23 180.78,65.64 180.78,70.65 181.43,71.3 181.58,71.3 182.01,71.73 182.01,73.39 179.6,75.81 179.6,82.04 177.37,84.26 177.37,94.24 179.69,96.55 179.69,108.67 180.51,109.49 180.51,111.34 180.7,111.53 180.7,116.95 182.18,118.43 182.18,121.94 189.87,129.63 189.87,137.7 189.21,138.36 189.21,145 189.59,145.38 189.59,146.37 189.46,146.5 189.29,146.5 v2(189.09,146.3)
  IN6 w0.089: v2(206.55,152.4) 206.34,152.61 206.07,152.61 205.76,152.92 205.76,154.12 206.9,155.27 206.9,160.17 206.26,160.82 206.26,162.82 206.63,163.2 207.04,163.2 207.21,163.37 207.21,163.48 207.07,163.62 v2(207.01,163.62)
  BOTTOM w0.107: v2(199.87,36.58) UH1.R10
USB20_N11_R: length 6
  TOP w0.102: 199.91,168.47 v2(199.8,168.36)
  TOP w0.107: RT114.2 201.7,168.98 200.63,167.91 200.23,167.91 200.01,168.13 199.83,168.36 v2(199.8,168.36) ; 199.91,168.47 199.91,168.77 199.66,169.02 RT112.2
  BOTTOM w0.076: v2(199.8,168.36) 199.8,167.83 200.01,167.62 200.01,167.21 199.91,167.11 199.91,166.76
  BOTTOM w0.089: UT4.K5 199.91,166.76
USB20_N14: length 121.8
  IN6 w0.089: v2(301.37,33.18) 301.1,32.91 301.1,32.71 300.92,32.53 299.79,32.53 299.51,32.81 293.85,32.81 292.71,31.66 288.81,31.66 288.48,31.33 284.68,31.33 284.17,31.84 277.82,31.84 277.52,31.54 264.87,31.54 262.76,33.65 253.52,33.65 251.82,35.35 249.36,35.35 246.4,38.31 240.25,38.31 239.04,39.51 234.69,39.51 233.61,40.59 231.97,40.59 231.59,40.98 230.24,40.98 230.18,40.92 224.91,40.92 222.86,42.97 213.76,42.97 212.92,43.81 210.22,43.81 209.95,44.08 205.37,44.08 204.71,43.42 202.21,43.42 201.1,44.54 201.1,45.28 200.87,45.51 200.45,45.51 200.04,45.51 199.54,45.01 198.45,45.01 197.47,44.03 197.47,43.53 196.13,42.19 196.13,39.42 195.97,39.26 195.97,39.03 196.01,38.98 196.09,38.9 196.21,38.9 v2(196.36,39.03)
  BOTTOM w0.107: v2(301.37,33.18) 301.13,33.42 301.13,34.47 301.32,34.67 JWLAN.5 ; UH1.E5 v2(196.36,39.03)
USB20_P1: length 210.8
  TOP w0.107: UU1.3 22.83,43.26 22.54,42.97 22.54,42.77 22.76,42.55 23.34,42.55 23.37,42.52 24.72,42.52 25.07,42.18 25.3,42.18 25.42,42.3 v2(25.42,42.61)
  IN6 w0.089: v2(196.82,45.48) 196.82,45.46 196.65,45.29 196.52,45.29 196.03,45.77 192.82,45.77 191.42,44.38 191.42,43.67 192.31,42.78 192.31,41.64 192.6,41.35 192.6,39.93 188.67,36 187.81,36 187.67,36 187.46,35.78 183.65,35.78 179.9,32.03 170.76,32.03 170.26,31.52 110.58,31.52 106.83,35.27 105.52,35.27 104.59,36.2 104.59,42.22 98.48,48.33 97.26,48.33 95.25,50.34 87.6,50.34 86.93,51.01 81.85,51.01 81.49,50.65 67.36,50.65 67.09,50.92 47.4,50.92 45.77,52.54 42.97,52.54 42.3,51.87 32.77,51.87 30.4,49.5 29.66,49.5 28.61,48.45 28.61,47.75 26.39,45.52 26.39,43.68 25.85,43.15 25.85,42.64 25.76,42.55 25.65,42.55 25.58,42.49 25.53,42.49 v2(25.42,42.61)
  BOTTOM w0.107: v2(196.82,45.48) 197.05,45.25 197.15,45.25 197.38,45.02 197.38,44.64 197.05,44.31 197.05,43.84 197.25,43.64 197.25,42.61 197.34,42.52 197.34,42.52 197.34,42.41 197.99,41.76 197.99,40.96 198.16,40.8 198.16,40.61 198.05,40.5 UH1.J2
USB20_P2: length 157.3
  TOP w0.107: v2(321.98,20.08) 322.17,20.27 322.17,20.69 322.4,20.92 322.96,20.92 323.63,21.59 323.63,22.53 324.26,23.16 JIO.24
  IN6 w0.089: v2(321.98,20.08) 322.19,20.29 322.19,20.48 322.1,20.56 320.59,20.56 320.23,20.2 313.36,20.2 312.32,21.24 311.52,21.24 310.4,22.36 306.72,22.36 303.5,25.58 294.33,25.58 291.09,28.82 283.03,28.82 281.95,27.74 278.22,27.74 277.24,28.72 266.62,28.72 265.96,29.38 260.31,29.38 259.32,30.37 249.19,30.37 245.79,26.97 245.79,26.48 244.55,25.24 242.3,25.24 239.68,22.62 236.87,22.62 236.06,23.43 236.06,23.91 235.53,24.45 235.03,24.45 233.91,25.57 231.05,25.57 229.71,26.91 229.71,33.6 226.59,36.72 224.19,36.72 223.21,35.74 222.22,35.74 222.21,35.75 222.08,35.75 221.68,36.15 221.56,36.15 220.35,36.15 219.17,37.32 219.17,39.93 218.9,40.2 215.1,40.2 213.88,38.98 209.5,38.98 208.47,40.01 208.4,40.01 208.09,40.01 207.42,39.34 207,39.34 206.57,38.92 206.57,38.22 206.09,37.74 205.2,37.74 202.96,35.49 202.96,34.39 202.56,33.99 200.54,33.99 199.9,34.62 199.44,34.62 199.23,34.62 199.23,34.62 v2(199.05,34.43)
  BOTTOM w0.107: UH1.N15 199.47,34.48 199.1,34.48 v2(199.05,34.43)
USB20_P3: length 173.8
  IN1 w0.089: v2(167.9,173.96) 168.22,173.64 168.22,170.66 164.98,167.42 164.98,161.67 168.11,158.53 171.43,158.53 172.56,157.4 174.38,157.4 174.54,157.24 176.63,157.24 176.81,157.41 180.93,157.41 181.83,156.52 182.44,156.52 182.68,156.28 183.36,156.28 183.75,155.89 185.36,155.89 185.99,155.26 187.2,155.26 194.71,147.76 194.71,147.37 194.71,147.37 194.71,136.44 190.19,131.92 190.19,124.31 188.46,122.58 188.46,115.48 185.52,112.54 185.52,98 188.6,94.92 188.6,89.11 186.38,86.89 186.38,71.14 187.4,70.12 187.4,68.45 189.56,66.29 192.26,66.29 192.87,65.68 194.4,65.68 194.64,65.45 194.64,64.36 194.34,64.07 194.34,60.02 193.62,59.3 193.62,54.64 195.68,52.58 195.68,51.55 197.09,50.14 197.36,50.14 198.45,49.05 198.45,48 198.46,48 198.46,46.16 198.96,45.66 198.96,44.96 v2(198.62,44.62)
  BOTTOM w0.107: v2(167.9,173.96) 168.12,174.17 168.12,174.65 167.97,174.8 LM1.4 ; UH1.K3 198.15,40.18 198.15,40.33 198.35,40.53 198.35,43.49 199.01,44.14 199.01,44.3 198.68,44.62 v2(198.62,44.62)
USB20_P3_R: length 3.4
  BOTTOM w0.099: JCDRA.39 167.82,178.46 ; 167.97,176.65 LM1.3
  BOTTOM w0.107: 167.82,178.46 167.89,178.39 167.89,177.99 168.12,177.76 168.12,177.01 168.14,176.98 168.14,176.83 167.97,176.65
USB20_P4: length 139.3
  TOP w0.107: v2(314.75,21.04) 314.87,21.04 315.3,20.62 UE1.33
  IN6 w0.089: v2(198.51,36.76) 198.99,37.17 198.99,37.34 199.3,37.65 199.3,38.56 200,39.26 200,39.8 199.65,40.14 199.65,41.71 200.79,42.85 201.38,42.85 203.59,42.85 203.88,42.56 203.88,41.79 204.92,40.76 206.64,40.76 207.27,41.39 209.41,41.39 209.63,41.18 213.79,41.18 214.47,41.86 222.4,41.86 224.46,39.81 230.18,39.81 232.8,37.18 235.65,37.18 236.64,38.17 238.63,38.17 241.11,35.69 241.11,33.98 241.78,33.3 245.5,33.3 247.64,31.17 259.65,31.17 260.64,30.18 266.98,30.18 267.54,29.62 291.61,29.62 293.17,28.06 302.16,28.06 307.05,23.17 311.81,23.17 312.37,23.72 313.44,23.72 314.55,22.61 315.22,22.61 315.86,21.97 315.86,21.14 315.55,20.84 315.18,20.84 314.98,21.04 v2(314.75,21.04)
  BOTTOM w0.107: v2(198.51,36.76) 198.65,36.9 UH1.L9
USB20_P6: length 193.5
  TOP w0.107: v2(166.15,167.01) 165.97,166.83 165.97,166.82 165.78,166.63 163.92,166.63 163.07,167.48 162.84,167.48 162.72,167.6 162.72,167.83 162.83,167.94 163.18,167.94 DV2.2 162.99,168.42 162.77,168.63 162.77,169.87 160.28,172.36 160.28,173.66 157.47,176.47 157.47,178.41 159.82,180.76 159.82,181.27 160.12,181.57 JEDP.18
  IN1 w0.089: v2(166.15,167.01) 166.57,166.59 167.03,166.59 167.59,166.03 167.59,163.37 168.57,162.39 175.62,162.39 178.02,159.99 184.23,159.99 184.48,159.74 188.04,159.74 188.41,159.37 188.41,159.19 190.19,157.41 190.19,154.81 196.14,148.86 196.14,148.35 196.14,145.4 196.52,145.02 196.52,134.27 191.91,129.66 191.91,124 189.91,122 189.91,114.2 186.96,111.25 186.96,99.2 187.81,98.35 187.81,97.73 190.03,95.51 190.03,88.51 187.81,86.29 187.81,71.73 188.83,70.71 188.83,69.05 190.15,67.73 192.86,67.73 193.46,67.12 195.14,67.12 196.07,66.18 196.07,63.87 196.89,63.05 196.89,60.4 195.06,58.57 195.06,55.24 197.12,53.18 197.12,52.15 197.69,51.58 198.14,51.58 200.23,49.49 200.23,48.29 200.44,48.09 200.44,46.84 200.61,46.67 200.61,45.56 200.54,45.49 200.54,45.31 v2(200.74,45.11)
  IN6 w0.089: v2(197.46,38.7) 197.34,38.45 197.23,38.41 197.07,38.41 196.92,38.56 196.92,41.9 199.02,44 199.49,44 199.99,44.5 200.32,44.5 200.54,44.72 200.54,44.92 v2(200.74,45.11)
  BOTTOM w0.107: UH1.K6 v2(197.46,38.7)
USB20_P7: length 171.2
  TOP w0.107: v2(168.35,159.93) 168.35,160.48 168.16,160.67 168.16,161.23 167.95,161.44 167.95,161.48 167.52,161.92 LV2.4
  IN1 w0.089: v2(168.35,159.93) 168.35,160.55 168.6,160.79 170.86,160.79 171.14,160.51 171.14,160.16 173.02,158.28 174.98,158.28 175.81,159.11 181.31,159.11 182.42,158 183.27,158 183.78,157.5 183.78,157.31 184.11,156.98 184.59,156.98 185,157.38 188.38,157.38 189.33,156.43 189.33,154.54 195.34,148.53 195.34,148.02 195.34,134.3 191.02,129.97 191.02,124.24 189.09,122.32 189.09,115.21 186.15,112.27 186.15,98.87 187.01,98.02 187.01,97.4 189.23,95.18 189.23,88.85 187.01,86.63 187.01,71.4 188.03,70.38 188.03,68.71 189.82,66.93 192.52,66.93 193.13,66.32 194.67,66.32 195.27,65.71 195.27,64 194.98,63.71 194.98,59.76 194.26,59.04 194.26,54.91 196.32,52.84 196.32,51.81 197.36,50.78 197.81,50.78 199.43,49.16 199.43,47.96 199.64,47.76 199.64,46.51 199.81,46.33 199.81,45.91 199.55,45.65 199.55,44.75 199.57,44.73 199.57,43.26 200.1,42.73 200.1,41.98 200.6,41.48 201.81,41.48 201.99,41.66 202.01,42.16 v2(202.14,42.27)
  BOTTOM w0.107: UH1.L3 198.77,40.12 198.84,40.06 198.99,40.06 199.03,40.1 199.03,40.91 199.22,41.09 199.22,41.54 198.75,42.01 198.75,43.03 199.15,43.43 199.64,43.43 200.13,42.93 201.66,42.93 201.94,42.65 201.94,42.5 201.96,42.48 201.96,42.36 202.05,42.27 v2(202.14,42.27)
USB20_P7_R: length 24.8
  TOP w0.107: JEDP.20 161.12,181.38 160.97,181.23 160.97,180.36 161.59,179.75 161.59,178.3 160.87,177.58 160.87,174.6 161.49,173.98 161.49,172.17 163.35,170.31 166.97,170.31 167.19,170.08 167.19,169.28 DV4.2 167.37,168.46 167.15,168.24 167.15,167.99 168.09,167.05 168.09,165.9 167.69,165.5 167.69,165.42 167.43,165.16 167.43,164.85 167.52,164.76 LV2.3
USB20_P8: length 218.2
  IN3 w0.127: v2(196.1,43.11) 196.1,43.77 195.84,44.02 195.37,44.02 194.96,43.61 194.73,43.25 193.62,40.06 193.24,39.68 188.79,38.05 188.59,37.81 188.59,35.5 188.77,35.32 188.77,33.74 188.16,33.13 188.16,32.69 188,32.54 188,29.72 187.59,29.3 187.19,29.3 187.07,29.3 185.44,27.67 185.44,24.99 184.41,23.96 178.61,23.96 178.37,23.72 124.37,23.72 105.66,21.99 90.67,21.99 87.85,24.28 87.84,24.3 85.72,28.96 83.71,33.35 83.6,33.47 83.6,34.02 70.18,47.43 67.75,48.14 65.93,49.96 65.89,49.96 63.35,51.18 55.8,51.18 55.29,50.67 44.1,50.67 35.96,51.99 35.76,52.19 34.87,52.19 34.09,52.97 27.25,52.97 21.6,55.22 19.55,56.55 19.21,56.76 19.14,56.87 18.92,57.34 18.9,57.43 18.89,57.46 18.84,57.49 18.07,58.26 16.54,58.26 16.2,58.6 v2(16.2,59.05)
  BOTTOM w0.107: UH1.G5 196.88,39.69 197,39.81 197,40.26 197.05,40.31 197.05,40.85 197.2,41 197.2,41.42 196.54,42.08 196.54,42.19 196.03,42.7 196.03,43.04 v2(196.1,43.11) ; v2(16.2,59.05) 16.01,59.24 16.01,59.49 16.16,59.64 LU9.1
USB20_P8_R: length 18.8
  TOP w0.107: v2(6.71,61.84) 6.46,62.09 6.3,62.09 6.18,61.97 JUSBC2.B6 ; v2(8.82,62.28) 8.64,62.11 8.21,62.11 8.09,62.22 JUSBC2.A6
  IN1 w0.089: v2(8.82,62.28) 9.24,61.87 9.43,61.87 9.69,62.12 9.69,62.87 9.69,63.53 9.41,63.81 7.99,63.81 7.39,63.21 7.39,62.52 v2(6.71,61.84)
  BOTTOM w0.107: v2(8.82,62.28) 8.87,62.28 9.25,61.9 9.6,61.9 10.11,62.41 12.48,62.41 13.31,61.58 13.47,61.58 13.66,61.78 13.66,62.21 DU11.2 14.46,61.97 15.79,61.97 16.02,61.73 16.02,61.51 16.16,61.37 LU9.2
USB20_P9: length 175.8
  TOP w0.107: v2(192.3,38.26) 192.3,38.26 192.46,38.09 192.46,37.75 194.74,35.47 197.63,35.47 198.13,35.97 198.13,37.7 198.33,37.94 198.72,37.99 v2(198.88,37.87)
  IN1 w0.089: v2(192.3,38.26) 192.45,38.41 192.45,38.69 192.34,38.81 190.8,38.81 190.06,39.54 190.06,39.82 190.06,41.69 187.6,44.16 187.6,54.34 188.64,55.37 188.64,56.21 188.62,56.23 188.02,56.83 188.02,62.32 187.67,62.67 185.94,64.4 185.94,64.52 185,65.46 185,67.44 185,68.06 184.06,69.01 184.06,70.06 184.18,70.19 184.18,72.03 184.5,72.34 184.5,74.86 184.48,74.89 184.48,87.79 184.5,87.82 184.5,87.83 186.69,90.02 186.69,94.18 183.51,97.36 182.74,97.36 182.06,98.03 182.06,106.86 183.54,108.34 183.54,113.48 186.21,116.14 186.21,123.37 188.02,125.18 188.02,133.37 188.11,133.46 188.11,143.79 187.04,144.85 187.04,147.6 184.42,150.22 183.9,150.22 183.76,150.36 169.21,150.36 169.08,150.49 166.17,150.49 162.21,154.44 162.21,157.35 160.24,159.32 158.28,159.32 155.83,161.78 155.83,163.66 v2(155.78,163.72)
  BOTTOM w0.107: UH1.N8 199.56,37.87 v2(198.88,37.87) ; RE648.1 156.84,166.1 LE3.4 156.96,166.02 156.96,165.76 157.01,165.71 157.01,164.96 156,163.96 156,163.94 v2(155.78,163.72)
