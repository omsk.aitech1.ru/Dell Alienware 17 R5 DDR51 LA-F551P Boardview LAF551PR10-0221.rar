# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FB_D_D17: length 35.7
  IN6 w0.102: 218.43,94.86 219.52,95.95 221.07,95.95 v2(221.47,95.55)
  IN6 w0.13: 218.43,94.86 213.36,94.86 206.46,87.96 205.26,87.96 196.35,87.96 193.43,90.89 193.43,92.25 v2(193.03,92.65)
  BOTTOM w0.102: UG9.Y5 v2(221.47,95.55) ; UG7.A13 v2(193.03,92.65)
FB_D_D18: length 40.1
  IN6 w0.102: v2(221.46,94.78) 221.09,94.41 219.7,94.41 218.88,93.59
  IN6 w0.13: 218.88,93.59 214.01,93.59 207.26,86.84 204.8,86.84 204.8,86.84 194.78,86.84 191.83,89.78 191.83,93.06 v2(193.03,94.25)
  BOTTOM w0.102: v2(193.03,94.25) 193.24,94.04 193.24,94.04 UG7.B11 ; UG9.V5 221.46,94.75 v2(221.46,94.78)
FB_D_D19: length 35.1
  IN6 w0.102: 218.64,94.22 219.97,95.55 v2(220.77,95.55)
  IN6 w0.13: 218.64,94.22 213.52,94.22 206.69,87.4 205.03,87.4 196.12,87.4 192.62,90.9 192.62,91.45 v2(193.03,91.85)
  BOTTOM w0.102: UG9.Y4 v2(220.77,95.55) ; UG7.B13 v2(193.03,91.85)
FB_D_D20: length 34.7
  IN6 w0.102: 218.5,95.68 219.16,96.35 220.41,96.35 220.5,96.26 221.36,96.26 v2(222.06,96.96)
  IN6 w0.13: 218.5,95.68 213.39,95.68 206.23,88.52 205.5,88.52 205.5,88.52 198.16,88.52 195.83,90.86 195.83,93.05 v2(196.23,93.45)
  BOTTOM w0.102: UG7.E11 195.83,93.85 v2(196.23,93.45) ; UG9.AA6 v2(222.06,96.96)
FB_D_D21: length 31.2
  IN6 w0.102: 218.31,96.24 218.81,96.75 220.44,96.75 220.61,96.57 221.1,96.57 v2(221.46,96.93)
  IN6 w0.13: 218.31,96.24 213.15,96.24 206,89.08 198.4,89.08 196.63,90.85 196.63,91.45 v2(196.23,91.85)
  BOTTOM w0.102: v2(221.46,96.93) 221.47,96.92 221.47,96.85 UG9.AA5 ; UG7.E13 195.83,92.25 v2(196.23,91.85)
FB_D_D22: length 30.3
  IN6 w0.102: 217.89,97.36 218.75,98.23 220.81,98.23 v2(221.5,97.54)
  IN6 w0.13: v2(197.03,93.45) 197.2,93.45 199.44,91.21 200.19,91.21 200.8,90.61 205.93,90.61 205.98,90.66 205.99,90.66 206.22,90.89 206.22,90.9 208.01,92.68 208.01,92.95 212.42,97.36 217.89,97.36
  BOTTOM w0.102: v2(221.5,97.54) 221.5,97.68 UG9.AC5 ; UG7.F11 196.78,93.7 196.78,93.7 v2(197.03,93.45)
FB_D_D23: length 28.9
  IN6 w0.102: 218.01,96.8 218.42,97.21 218.43,97.21 218.96,97.74 220.41,97.74 v2(220.63,97.52)
  IN6 w0.13: v2(197.03,91.85) 197.73,91.85 199.66,89.92 206.04,89.92 212.92,96.8 218.01,96.8
  BOTTOM w0.102: UG7.F13 196.8,92.08 196.81,92.08 v2(197.03,91.85) ; UG9.AC4 v2(220.63,97.52)
FB_D_D24: length 35.8
  IN1 w0.13: v2(192.23,99.1) 192.23,98.29 194.7,95.81 209.56,95.81 210.44,96.69 215.02,96.69 215.35,97.02 218.47,97.02 219.75,98.3 222.06,98.3 222.31,98.55 222.95,98.55 223.32,98.93 v2(223.32,99.25)
  BOTTOM w0.102: v2(192.23,99.1) 192.28,99.1 UG7.A4 ; v2(223.32,99.25) 223.32,98.91 223.17,98.75 UG9.AD7
FB_D_D25: length 37.7
  IN1 w0.13: v2(192.23,100.65) 191.8,100.23 191.8,97.82 194.91,94.71 209.41,94.71 210.83,96.13 215.02,96.13 215.28,96.38 218.55,96.38 220.14,97.97 222.45,97.97 v2(222.77,97.65)
  BOTTOM w0.102: UG9.AC6 v2(222.77,97.65) ; UG7.A2 v2(192.23,100.65)
FB_D_D26: length 32.6
  IN1 w0.13: v2(222.17,99.75) 221.88,100.04 221.07,100.04 220.96,100.15 220.47,100.15 220.24,99.92 219.78,99.92 218.07,98.21 215.31,98.21 214.91,97.81 209.72,97.81 209.11,97.21 207.97,97.21 207.59,96.83 195.87,96.83 194.05,98.65 193.64,98.65 193.24,99.05 v2(193.03,99.05)
  BOTTOM w0.102: UG9.AF6 v2(222.17,99.75) ; UG7.B4 v2(193.03,99.05)
FB_D_D27: length 35
  IN1 w0.13: v2(193.03,100.65) 192.63,100.25 192.63,98.84 192.81,98.66 193.25,98.66 193.43,98.48 193.43,98.03 193.99,97.47 194.31,97.47 195.37,96.41 209.2,96.41 210.04,97.25 215.01,97.25 215.31,97.55 218.17,97.55 219.28,98.65 221.28,98.65 221.29,98.64 221.63,98.64 222.02,99.03 v2(222.02,99.1)
  BOTTOM w0.102: UG7.B2 v2(193.03,100.65) ; UG9.AD6 v2(222.02,99.1)
FB_D_D28: length 32
  IN1 w0.13: v2(222.87,99.75) 222.28,100.34 221.19,100.34 221.13,100.4 219.43,100.4 217.85,98.82 215.14,98.82 214.69,98.37 209.39,98.37 208.86,97.84 207.23,97.84 206.64,97.26 196.53,97.26 195.83,97.95 195.83,99.46 v2(196.23,99.85)
  BOTTOM w0.102: v2(196.23,99.85) 195.98,99.61 UG7.E4 ; UG9.AF7 v2(222.87,99.75)
FB_D_D29: length 33.6
  IN1 w0.13: v2(196.23,101.45) 196.63,101.05 196.63,98.05 197,97.68 206.35,97.68 207.08,98.42 208.54,98.42 209.06,98.93 214.46,98.93 214.9,99.37 217.07,99.37 217.52,99.83 217.52,100.25 218.07,100.8 221.14,100.8 221.29,100.65 222.67,100.65 v2(223.57,99.75)
  BOTTOM w0.102: v2(196.23,101.45) 196.01,101.23 UG7.E2 ; UG9.AF8 v2(223.57,99.75)
FB_D_D30: length 24.7
  IN1 w0.13: v2(214.77,100.05) 214.77,100.04 214.23,99.5 208.8,99.5 208.29,98.99 207.02,98.99 206.14,98.1 197.98,98.1 v2(197.03,99.05)
  BOTTOM w0.102: UG9.AF2 219.47,100.05 219.08,99.66 215.16,99.66 v2(214.77,100.05) ; v2(197.03,99.05) UG7.F4
FB_D_D31: length 26.7
  IN1 w0.13: v2(197.03,100.65) 197.43,100.25 197.43,99.63 197.64,99.41 197.97,99.41 198.78,98.6 206.07,98.6 206.83,99.37 207.78,99.37 208.99,100.57 213.07,100.57 213.57,100.07 v2(213.57,100.05)
  BOTTOM w0.102: v2(197.03,100.65) UG7.F2 ; UG9.AF3 220.13,100.05 219.78,99.7 219.47,99.7 219.17,99.4 214.22,99.4 v2(213.57,100.05)
FB_D_D32: length 24.5
  IN6 w0.102: 215.2,85.07 215.97,85.84 220.5,85.84 221.26,86.6 v2(221.58,86.6)
  IN6 w0.13: 215.2,85.07 215.2,84.63 213.43,82.86 211.81,81.25 211.81,77.93 208.15,74.26 206.02,74.26 v2(205.83,74.45)
  BOTTOM w0.102: UG9.F4 221.57,86.55 221.57,86.59 v2(221.58,86.6) ; UG8.A4 v2(205.83,74.45)
FB_D_D33: length 20.8
  IN6 w0.102: v2(218.22,85.04) 217.37,84.2 216.35,84.2
  IN6 w0.13: 216.35,84.2 212.94,80.78 212.94,77.46 208.33,72.85 v2(205.83,72.85)
  BOTTOM w0.102: UG8.A2 v2(205.83,72.85) ; UG9.E1 218.53,85.35 v2(218.22,85.04)
FB_D_D34: length 23
  IN6 w0.102: 215.93,86.16 219.8,86.16 v2(220.07,86.43)
  IN6 w0.13: 215.93,86.16 214.64,84.87 214.64,84.87 211.25,81.48 211.25,78.24 208,74.98 206.08,74.98 206.08,74.98 205.55,74.98 v2(205.03,74.45)
  BOTTOM w0.102: UG8.B4 204.63,74.85 v2(205.03,74.45) ; UG9.F3 220.07,86.35 v2(220.07,86.43)
FB_D_D35: length 25.8
  IN6 w0.102: 216,84.64 216.4,84.64 216.67,84.9 216.67,85.27 216.94,85.54 220.66,85.54 221.22,86.1 221.82,86.1 v2(222.07,86.35)
  IN6 w0.13: 216,84.64 212.38,81.02 212.38,77.69 208.33,73.65 207.07,73.65 206.67,73.25 205.43,73.25 v2(205.03,72.85)
  BOTTOM w0.102: v2(222.07,86.35) UG9.F5 ; UG8.B2 v2(205.03,72.85)
FB_D_D36: length 28.4
  IN6 w0.102: v2(218.07,83.65) 217.8,83.65
  IN6 w0.13: v2(201.83,74.45) 202.23,74.05 202.23,71.89 203.1,71.02 208.09,71.02 214.06,76.99 214.06,79.91 217.8,83.65
  BOTTOM w0.102: v2(201.83,74.45) 202,74.63 202,74.63 UG8.E4 ; v2(218.07,83.65) 218.72,84.3 219.32,84.3 UG9.D2
FB_D_D37: length 25.1
  IN6 w0.102: 216.19,83.24 216.85,83.24 v2(217.23,83.62)
  IN6 w0.13: 216.19,83.24 213.5,80.55 213.5,77.23 207.86,71.58 203.34,71.58 203.08,71.84 203.02,71.9 203.02,72.46 v2(202.63,72.85)
  BOTTOM w0.102: v2(217.23,83.62) 217.76,84.15 218.22,84.15 218.72,84.65 UG9.D1 ; UG8.E2 v2(202.63,72.85)
FB_D_D38: length 31.5
  IN6 w0.102: v2(220.07,83.65) 219.73,83.31 219.73,82.74 219.44,82.45 218.87,82.45
  IN6 w0.13: v2(201.03,74.45) 200.58,74 200.58,71.81 202.53,69.85 208.5,69.85 208.83,70.18 215.08,76.43 215.08,78.67 218.87,82.45
  BOTTOM w0.102: v2(201.03,74.45) 201.43,74.85 UG8.F4 ; UG9.C3 v2(220.07,83.65)
FB_D_D39: length 27.7
  IN6 w0.102: 218.59,83.26 218.98,83.26 v2(219.36,83.64)
  IN6 w0.13: v2(201.83,72.85) 201.43,72.45 201.43,71.75 202.76,70.41 208.27,70.41 214.62,76.76 214.62,79.29 218.59,83.26
  BOTTOM w0.102: UG9.C2 v2(219.36,83.64) ; UG8.F2 v2(201.83,72.85)
FB_D_D40: length 20.5
  IN1 w0.13: v2(205.83,80.85) 205.98,80.7 210.09,80.7 215.7,86.32 216.24,86.32 216.97,87.05 218.21,87.05 219.21,88.05 221.67,88.05 v2(222.07,88.45)
  BOTTOM w0.102: v2(205.83,80.85) 205.62,80.64 UG8.A11 ; UG9.J5 v2(222.07,88.45)
FB_D_D41: length 18.8
  IN1 w0.13: v2(216.85,88.14) 216.81,88.14 216.4,87.73 215.53,87.73 209.89,82.1 206.18,82.1 v2(205.83,82.45)
  BOTTOM w0.102: v2(216.85,88.14) 217.29,87.7 218.67,87.7 218.77,87.8 220.72,87.8 221.06,88.14 UG9.J4 ; v2(205.83,82.45) 205.6,82.22 UG8.A13
FB_D_D42: length 27.1
  IN1 w0.13: v2(224.72,89.15) 224.72,89.2 224.27,89.65 220.22,89.65 219.66,89.08 216.08,89.08 209.7,82.7 206.42,82.7 206.13,82.99 204.8,82.99 204.62,82.81 204.62,81.26 v2(205.03,80.85)
  BOTTOM w0.102: v2(224.72,89.15) 224.32,89.55 UG9.L8 ; v2(205.03,80.85) 204.8,80.63 204.8,80.63 UG8.B11
FB_D_D43: length 18.6
  IN1 w0.13: v2(217.97,88.16) 217.97,88.03 217.48,87.54 216.82,87.54 216.41,87.13 215.72,87.13 209.9,81.31 206.1,81.31 206.04,81.25 205.43,81.25 v2(205.03,81.65)
  BOTTOM w0.102: UG9.J2 219.5,88.15 219.1,88.55 218.36,88.55 v2(217.97,88.16) ; v2(205.03,81.65) 204.83,81.86 UG8.B13
FB_D_D44: length 21
  IN1 w0.13: v2(216.29,85.08) 215.91,85.46 215.53,85.46 215.21,85.14 215.21,85.03 209.57,79.39 203.5,79.39 203.03,79.86 203.03,80.45 v2(202.63,80.85)
  BOTTOM w0.102: UG9.F1 218.84,85.92 217.12,85.92 v2(216.29,85.08) ; UG8.E11 v2(202.63,80.85)
FB_D_D45: length 24.3
  IN1 w0.13: v2(217.06,85.09) 216.61,84.64 216.16,84.64 210.31,78.78 203.15,78.78 202.23,79.7 UG8.E13 v2(201.83,82.45)
  BOTTOM w0.102: UG8.E13 202.06,82.22 v2(201.83,82.45) ; v2(217.06,85.09) 217.67,85.7 219.32,85.7 UG9.F2
FB_D_D46: length 27.1
  IN1 w0.13: v2(201.83,80.85) 201.43,80.46 201.43,79.75 203.02,78.15 211.11,78.15 215.91,82.95 215.91,83.49 216.51,84.1 217.21,84.1 217.56,84.45 218.26,84.45 218.64,84.83 218.64,85.61 219.67,86.64 219.67,87 220.01,87.34 220.58,87.34 v2(220.77,87.15)
  BOTTOM w0.102: UG9.H4 v2(220.77,87.15) ; v2(201.83,80.85) UG8.F11
FB_D_D47: length 30.3
  IN1 w0.13: v2(201.03,82.45) 200.62,82.05 200.62,79.91 200.63,79.9 200.63,79.89 200.86,79.66 200.87,79.66 203.07,77.46 211.74,77.46 217.66,83.38 217.66,83.85 217.85,84.04 218.23,84.04 218.92,84.73 218.92,85.17 219.35,85.6 220.3,85.6 221.17,86.47 221.17,86.85 v2(221.47,87.15)
  BOTTOM w0.102: v2(201.03,82.45) 201.28,82.2 201.28,82.2 UG8.F13 ; v2(221.47,87.15) UG9.H5
FB_D_D48: length 43.9
  IN1 w0.13: v2(192.23,80.85) 191.58,80.85 190.49,81.94 190.49,84.89 193.43,87.83 206.59,87.83 213.29,94.53 216.91,94.53 217.6,95.22 219.54,95.22 220.28,95.96 222.13,95.96 222.51,95.58 222.51,95.18 222.85,94.84 v2(222.88,94.84)
  BOTTOM w0.102: UG9.V7 223.17,94.55 v2(222.88,94.84) ; v2(192.23,80.85) 192.49,80.59 UG8.U11
FB_D_D49: length 39.8
  IN1 w0.13: v2(192.23,82.45) 191.78,82.9 191.78,84.46 194.02,86.71 207.95,86.71 214.45,93.21 217.56,93.21 218.43,94.08 221.95,94.08 222.32,94.45 UG9.V8 v2(224.17,94.75)
  BOTTOM w0.102: v2(192.23,82.45) 192.44,82.24 UG8.U13 ; v2(224.17,94.75) UG9.V8
FB_D_D50: length 41.6
  IN1 w0.13: v2(193.03,80.85) 192.63,81.25 191.98,81.25 191.19,82.04 191.19,84.79 193.66,87.27 207.05,87.27 213.69,93.91 217.51,93.91 218.33,94.73 220.21,94.73 220.54,94.4 221.29,94.4 221.3,94.39 221.63,94.39 221.64,94.4 221.67,94.4 222.06,94.79 v2(222.06,94.86)
  BOTTOM w0.102: UG9.V6 v2(222.06,94.86) ; v2(193.03,80.85) 193.24,80.64 UG8.T11
FB_D_D51: length 39.6
  IN1 w0.13: v2(224.87,94.75) 223.99,93.87 222.63,93.87 222.54,93.78 221.65,93.78 221.63,93.8 221.31,93.8 221.25,93.74 220.5,93.74 220.35,93.59 218.98,93.59 218.01,92.62 215.02,92.62 208.55,86.15 195.38,86.15 194.3,85.07 193.44,85.07 192.63,84.25 192.63,82.85 v2(193.03,82.45)
  BOTTOM w0.102: v2(193.03,82.45) 193.25,82.23 UG8.T13 ; UG9.V9 v2(224.87,94.75)
FB_D_D52: length 35.7
  IN1 w0.13: v2(195.43,80.85) 195.03,81.25 194.46,81.25 194.23,81.48 194.23,84.2 195.61,85.59 209.3,85.59 215.51,91.79 217.86,91.79 218.83,92.76 220.29,92.76 220.67,93.14 v2(220.67,93.35)
  BOTTOM w0.102: UG9.U4 v2(220.67,93.35) ; v2(195.43,80.85) UG8.N11
FB_D_D53: length 32.3
  IN1 w0.13: v2(221.57,92.85) 221.17,92.45 219.28,92.45 217.81,90.99 215.61,90.99 209.64,85.02 199.53,85.02 198.95,84.44 196.14,84.44 195.83,84.13 195.83,82.85 v2(196.23,82.45)
  BOTTOM w0.102: UG8.N13 196.23,82.45 v2(196.23,82.45) ; v2(221.57,92.85) 221.76,92.66 221.76,92.48 221.77,92.47 UG9.R5
FB_D_D54: length 32.6
  IN1 w0.13: v2(196.23,80.85) 196.63,81.25 196.63,82.63 196.86,82.86 198.26,82.86 199.43,84.03 202.86,84.03 203.24,84.41 209.82,84.41 215.7,90.29 217.94,90.29 219.72,92.07 221.59,92.07 v2(222.17,92.65)
  BOTTOM w0.102: UG8.M11 v2(196.23,80.85) ; UG9.R6 v2(222.17,92.65)
FB_D_D55: length 33.4
  IN1 w0.13: v2(197.03,82.45) 198.23,82.45 198.77,82.99 203.26,82.99 203.43,83.17 203.43,83.62 203.44,83.62 203.44,83.65 203.63,83.85 210.06,83.85 215.92,89.72 217.84,89.72 219.77,91.65 221.21,91.65 221.3,91.74 223.22,91.74 223.87,92.39 223.87,93.15 v2(224.17,93.45)
  BOTTOM w0.102: UG8.M13 196.8,82.22 v2(197.03,82.45) ; UG9.U8 v2(224.17,93.45)
FB_D_D56: length 42.3
  IN6 w0.102: 218.59,90.67 219.66,91.74 221.61,91.74 221.75,91.6 222.52,91.6 v2(222.87,91.25) ; 207.87,83.65 207.34,83.12
  IN6 w0.13: 218.59,90.67 214.88,90.67 207.87,83.65 ; 207.34,83.12 207.34,80.13 206.31,79.1 200.03,79.1 199.53,79.6 198.89,79.6 197.57,78.28 194.49,78.28 192.49,76.28 192.49,74.99 v2(193.03,74.45)
  BOTTOM w0.102: UG8.U4 193.03,74.45 v2(193.03,74.45) ; UG9.P6 v2(222.87,91.25)
FB_D_D57: length 47
  IN6 w0.102: v2(224.87,92.65) 224.05,91.83 221.86,91.83 221.66,92.03 219.33,92.03 218.54,91.24 ; 207.07,83.65 206.7,83.28 206.7,80.38 205.97,79.64 200.75,79.64 ; 197.28,78.8 198.57,80.09
  IN6 w0.13: 200.75,79.64 200.3,80.09 198.57,80.09 ; 218.54,91.24 214.66,91.24 207.07,83.65 ; v2(193.03,72.85) 192.63,73.25 192.63,73.93 191.99,74.57 191.99,76.64 194.15,78.8 197.28,78.8
  BOTTOM w0.102: UG9.R9 v2(224.87,92.65) ; UG8.U2 193.03,72.85 v2(193.03,72.85)
FB_D_D58: length 37.7
  IN6 w0.102: 218.52,90.1 219.86,91.44 220.48,91.44 v2(220.67,91.25) ; 208.66,83.65 207.97,82.96
  IN6 w0.13: 208.66,83.65 215.1,90.1 218.52,90.1 ; v2(193.03,75.25) 193.43,75.65 193.43,76.25 194.99,77.81 198.49,77.81 199.25,78.57 206.63,78.57 207.97,79.92 207.97,82.96
  BOTTOM w0.102: UG8.T4 193.03,75.25 v2(193.03,75.25) ; UG9.P4 v2(220.67,91.25)
FB_D_D59: length 39.9
  IN6 w0.102: 218.43,89.53 219.42,90.52 220.64,90.52 v2(221.47,91.35) ; 208.67,82.87 208.54,82.74
  IN6 w0.13: 208.54,82.74 208.54,82.03 208.54,82.03 208.54,81.97 208.54,81.97 208.54,80.12 208.54,79.62 207.03,78.11 199.65,78.11 198.96,77.42 195.38,77.42 194.23,76.27 194.23,73.25 v2(193.83,72.85) ; 208.67,82.87 215.33,89.53 218.43,89.53
  BOTTOM w0.102: v2(193.83,72.85) 193.83,72.85 UG8.T2 ; v2(221.47,91.35) UG9.P5
FB_D_D60: length 38.7
  IN6 w0.102: v2(223.47,89.25) 222.62,90.1 219.68,90.1 218.53,88.95
  IN6 w0.13: v2(196.23,74.45) 195.75,74.93 195.75,76.25 196.39,76.89 199.83,76.89 200.49,77.55 207.33,77.55 207.65,77.87 207.66,77.87 209.01,79.22 209.01,82.41 215.55,88.95 218.53,88.95
  BOTTOM w0.102: UG8.N4 195.99,74.69 v2(196.23,74.45) ; UG9.L7 v2(223.47,89.25)
FB_D_D61: length 36.6
  IN6 w0.102: v2(222.17,89.25) 222.17,89.54 222.07,89.64 219.93,89.64 218.93,88.64
  IN6 w0.13: v2(196.23,73.65) 196.63,74.05 196.63,75.46 196.82,75.65 197.48,75.65 198.16,76.33 199.96,76.33 200.64,77.01 207.65,77.01 209.57,78.94 209.57,82.18 216.03,88.64 218.93,88.64
  BOTTOM w0.102: v2(222.17,89.25) UG9.L6 ; v2(196.23,73.65) 196.01,73.43 UG8.N2
FB_D_D62: length 32.8
  IN6 w0.102: 218.7,87.62 220.39,89.31 220.71,89.31 v2(220.77,89.25)
  IN6 w0.13: 218.7,87.62 215.8,87.62 210.13,81.95 210.13,78.7 207.76,76.33 200.65,76.33 200.22,75.9 198.48,75.9 v2(197.03,74.45)
  BOTTOM w0.102: UG8.M4 196.63,74.85 v2(197.03,74.45) ; UG9.L4 v2(220.77,89.25)
FB_D_D63: length 35.5
  IN6 w0.102: v2(221.47,89.25) 220.97,88.75 220.97,88.4 219.68,87.11
  IN6 w0.13: v2(196.23,72.85) 196.62,73.25 197.37,73.25 198.23,74.1 198.23,74.75 198.76,75.28 200.36,75.28 200.78,75.7 207.92,75.7 210.69,78.47 210.69,81.71 214.07,85.09 216.09,87.11 219.68,87.11
  BOTTOM w0.102: UG8.M2 v2(196.23,72.85) ; v2(221.47,89.25) UG9.L5
FB_D_DBI0: length 18.1
  IN2 w0.117: v2(215.67,102.85) 215.03,103.49 215.02,103.49 214.58,103.93 213.48,103.93 213.04,103.5 205.07,103.5 204.23,102.65 204.23,102.26 v2(203.43,101.45)
  BOTTOM w0.102: UG9.AJ1 216.37,102.15 v2(215.67,102.85) ; UG7.P2 v2(203.43,101.45)
FB_D_DBI1: length 20
  IN2 w0.117: v2(217.12,100.1) 217.12,99.75 213.62,96.26 211.52,96.26 207.52,92.26 203.83,92.26 v2(203.43,91.85)
  BOTTOM w0.102: v2(217.12,100.1) 217.77,100.75 UG9.AG1 ; UG7.P13 v2(203.43,91.85)
FB_D_DBI2: length 34.6
  IN2 w0.117: v2(222.87,96.85) 222.53,96.51 218.13,96.51 215.02,93.4 212.35,93.4 207.97,89.02 196.8,89.02 195.84,89.97 195.84,92.32 195.51,92.65 v2(195.43,92.65)
  BOTTOM w0.102: UG9.AA7 v2(222.87,96.85) ; v2(195.43,92.65) 195.03,92.25 UG7.D13
FB_D_DBI3: length 32.1
  IN2 w0.117: v2(221.46,99.03) 221.23,98.8 220.35,98.8 218.6,100.55 211.07,100.55 207.28,96.75 199.93,96.75 197.23,99.45 196.83,99.45 196.63,99.65 196.63,100.05 196.43,100.25 195.03,100.25 v2(194.63,100.65)
  BOTTOM w0.102: UG9.AD5 221.46,98.96 v2(221.46,99.03) ; UG7.D2 v2(194.63,100.65)
FB_D_DBI4: length 24.1
  IN2 w0.117: v2(220.67,84.35) 220.37,84.05 216.4,84.05 209.69,77.33 209.69,76.17 206.22,72.7 206.22,72.69 205.99,72.47 205.98,72.47 205.96,72.44 203.78,72.44 203.43,72.8 v2(203.43,72.85)
  BOTTOM w0.102: v2(220.67,84.35) UG9.D3 ; UG8.D2 v2(203.43,72.85)
FB_D_DBI5: length 20.3
  IN2 w0.117: v2(203.43,81.65) 203.81,81.27 204.06,81.27 204.07,81.27 204.39,81.27 204.39,81.27 204.86,81.27 204.87,81.27 205.19,81.27 205.19,81.27 205.66,81.27 205.67,81.27 205.99,81.27 205.99,81.27 209.64,81.27 214.63,86.27 218.74,86.27 219.08,86.61 v2(219.08,86.67)
  BOTTOM w0.102: UG8.D13 v2(203.43,81.65) ; UG9.H3 220.17,87.45 219.82,87.1 219.52,87.1 v2(219.08,86.67)
FB_D_DBI6: length 33.3
  IN2 w0.117: v2(194.63,82.45) 195.03,82.85 195.03,84.3 197.03,86.3 209,86.3 213.13,90.44 216.63,90.44 218.91,92.72 220.78,92.72 v2(221.47,93.4)
  BOTTOM w0.102: v2(221.47,93.4) 221.47,93.45 UG9.U5 ; UG8.P13 v2(194.63,82.45)
FB_D_DBI7: length 40.6
  IN2 w0.117: v2(195.43,72.85) 195.84,73.27 195.84,73.81 196.07,74.04 196.07,74.04 196.08,74.05 197.21,74.05 197.43,74.27 197.43,74.85 202.23,79.65 202.23,82.78 202.45,83 209.2,83 213.88,87.68 215.15,87.68 215.27,87.56 218.73,87.56 219.34,88.17 219.34,88.5 220.6,89.76 224.08,89.76 v2(224.87,90.55)
  BOTTOM w0.102: UG9.M9 v2(224.87,90.55) ; v2(195.43,72.85) 195.03,73.25 UG8.P2
FB_D_EDC0: length 18.7
  IN2 w0.117: v2(204.23,100.66) 204.63,101.05 207.31,101.05 209.05,102.8 213.3,102.8 213.76,103.25 214.12,103.25 v2(214.52,102.85)
  BOTTOM w0.102: v2(204.23,100.66) 204.23,100.66 UG7.R2 ; UG9.AJ3 220.04,101.82 219.51,101.82 219.26,101.57 215.8,101.57 215.4,101.97 v2(214.52,102.85)
FB_D_EDC1: length 19.6
  IN2 w0.117: v2(204.23,92.65) 204.63,93.05 206.11,93.05 209.99,96.93 212.8,96.93 v2(215.97,100.1)
  BOTTOM w0.102: v2(215.97,100.1) 216.95,101.08 219.34,101.08 UG9.AG2 ; UG7.R13 204.23,92.65 v2(204.23,92.65)
FB_D_EDC2: length 37.4
  IN2 w0.117: v2(194.63,91.85) 195.03,91.45 195.03,89.75 196.72,88.06 208.03,88.06 212.29,92.32 215.89,92.32 219.51,95.94 223.96,95.94 v2(224.87,96.85)
  BOTTOM w0.102: UG7.C13 194.4,92.08 v2(194.63,91.85) ; UG9.AA9 v2(224.87,96.85)
FB_D_EDC3: length 32
  IN2 w0.117: v2(193.83,101.45) 194.23,101.05 197.38,101.05 198.23,100.2 198.23,99.65 200.28,97.6 206.96,97.6 210.58,101.23 215.3,101.23 215.51,101.02 219.5,101.02 v2(220.77,99.75)
  BOTTOM w0.102: UG9.AF4 v2(220.77,99.75) ; UG7.C2 v2(193.83,101.45)
FB_D_EDC4: length 22
  IN2 w0.117: v2(204.23,73.65) 204.32,73.65 204.73,74.07 205.99,74.07 206.22,74.29 206.22,74.3 208.16,76.24 208.16,77.08 215.7,84.61 219.63,84.61 v2(220.07,85.05)
  BOTTOM w0.102: UG9.E3 v2(220.07,85.05) ; v2(204.23,73.65) 204.23,73.65 UG8.C2
FB_D_EDC5: length 18.8
  IN2 w0.117: v2(217.87,86.65) 217.39,87.13 216.99,87.13 216.85,86.99 214.19,86.99 209.26,82.05 204.63,82.05 v2(204.23,82.45)
  BOTTOM w0.102: UG9.H2 219.43,87.45 219.08,87.1 218.32,87.1 v2(217.87,86.65) ; UG8.C13 v2(204.23,82.45)
FB_D_EDC6: length 37.2
  IN2 w0.117: v2(193.83,81.65) 193.43,82.05 193.43,84.15 196.48,87.2 208.62,87.2 212.85,91.43 216.29,91.43 218.7,93.84 222.38,93.84 v2(222.77,93.45)
  BOTTOM w0.102: UG9.U6 v2(222.77,93.45) ; UG8.R13 194.05,81.87 194.05,81.87 v2(193.83,81.65)
FB_D_EDC7: length 38.2
  IN2 w0.117: v2(222.07,90.55) 221.87,90.35 219.87,90.35 218.27,88.75 213.93,88.75 209.37,84.19 202.42,84.19 201.88,83.65 201.83,83.6 201.83,83.31 201.82,83.3 201.82,83.29 201.59,83.07 201.58,83.07 201.43,82.91 201.43,79.91 201.42,79.9 201.42,79.89 201.19,79.67 201.18,79.67 198.03,76.51 196.13,76.51 196.07,76.44 196.07,76.44 195.84,76.21 195.84,76.21 195.02,75.39 195.02,74.04 v2(194.63,73.65)
  BOTTOM w0.102: UG9.M5 v2(222.07,90.55) ; UG8.R2 v2(194.63,73.65)
FB_D_WCK01: length 25.2
  IN2 w0.089: v2(203.42,99.85) 203.42,99.6 203.84,99.18 203.84,98.74 203.98,98.6 206.11,98.6 209.59,102.09 215.36,102.09 215.63,101.82 219.56,101.82 220.13,102.39 222.87,102.39 223.2,102.73 223.8,102.73 224.1,102.43 224.1,102.08 224.1,102.08 224.1,101.92 v2(224.17,101.85)
  BOTTOM w0.102: UG9.AJ8 v2(224.17,101.85)
  BOTTOM w0.119: UG7.P4 203.03,99.45 v2(203.42,99.85)
FB_D_WCK23: length 39.7
  IN2 w0.089: v2(195.43,99.09) 195.43,98.83 195.85,98.41 195.85,97.75 197.99,95.6 197.99,92.23 199.86,90.37 208.05,90.37 212.73,95.05 214.81,95.05 218.04,98.28 224.06,98.28 224.16,98.37 224.16,98.69 224.17,98.71 v2(224.17,98.95)
  BOTTOM w0.102: UG7.D4 195.39,99.09 v2(195.43,99.09) ; UG9.AD8 v2(224.17,98.95)
FB_D_WCK45: length 28.8
  IN2 w0.089: v2(202.65,74.48) 202.65,74.72 202.26,75.11 202.26,75.85 203.4,77 206.46,77 215.09,85.63 218.87,85.63 219.51,86.27 219.51,87.03 219.69,87.21 219.7,87.21 219.72,87.23 219.73,87.23 219.74,87.24 219.74,87.25 220.38,87.9 222.18,87.9 222.48,88.19 222.66,88.19 222.77,88.31 v2(222.77,88.45)
  BOTTOM w0.102: UG9.J6 v2(222.77,88.45)
  BOTTOM w0.119: UG8.D4 203.03,74.85 v2(202.65,74.48)
FB_D_WCK67: length 41.5
  IN2 w0.089: v2(194.63,75.25) 194.63,75.38 194.23,75.78 194.23,76.48 195.17,77.43 195.86,77.43 195.86,77.42 195.94,77.42 197.98,79.46 197.98,82.45 199.02,83.49 199.02,84.51 200.01,85.5 209.17,85.5 213.33,89.66 217.65,89.66 220,92.01 223.77,92.01 223.97,91.81 223.97,91.61 223.99,91.6 223.99,91.53 v2(224.17,91.35)
  BOTTOM w0.102: UG9.P8 v2(224.17,91.35) ; UG8.P4 v2(194.63,75.25)
FB_D_WCK#01: length 25.5
  IN2 w0.089: v2(203.43,99.05) 203.51,99.05 203.62,98.95 203.62,98.64 203.84,98.42 206.18,98.42 209.67,101.91 215.29,101.91 215.55,101.64 219.69,101.64 220.26,102.21 222.95,102.21 223.28,102.55 223.71,102.55 223.91,102.35 223.91,102.16 223.6,101.85 v2(223.47,101.85)
  BOTTOM w0.102: UG9.AJ7 223.17,102.37 223.28,102.48 223.44,102.48 223.53,102.39 223.53,101.91 v2(223.47,101.85)
  BOTTOM w0.119: UG7.P5 203.19,98.81 v2(203.43,99.05)
FB_D_WCK#23: length 39.8
  IN2 w0.089: v2(195.42,98.28) 195.49,98.28 195.62,98.15 195.62,97.66 197.44,95.83 197.51,95.76 197.76,95.51 197.76,92.21 199.78,90.19 208.12,90.19 212.81,94.87 214.89,94.87 218.11,98.1 224.15,98.1 224.35,98.3 224.35,98.61 224.68,98.95 v2(224.87,98.95)
  BOTTOM w0.102: UG9.AD9 v2(224.87,98.95) ; UG7.D5 195.4,98.28 v2(195.42,98.28)
FB_D_WCK#45: length 29
  IN2 w0.089: v2(202.65,75.28) 202.51,75.42 202.51,75.86 203.48,76.82 206.54,76.82 215.17,85.45 218.95,85.45 219.69,86.2 219.69,86.96 219.77,87.03 219.77,87.03 219.79,87.05 219.8,87.05 219.91,87.16 219.91,87.17 220.46,87.72 222.27,87.72 222.55,88 223.02,88 v2(223.47,88.45)
  BOTTOM w0.102: UG9.J7 v2(223.47,88.45)
  BOTTOM w0.119: UG8.D5 203.23,75.65 203.37,75.51 203.37,75.41 203.23,75.28 v2(202.65,75.28)
FB_D_WCK#67: length 41.6
  IN2 w0.089: v2(194.83,76.13) 194.83,75.84 194.74,75.75 194.51,75.75 194.4,75.85 194.4,76.4 195.21,77.21 195.97,77.21 198.15,79.39 198.15,82.36 199.2,83.4 199.2,84.43 200.09,85.32 209.24,85.32 210.98,87.06 211,87.06 213.42,89.49 217.72,89.49 220.07,91.84 223.7,91.84 223.8,91.74 223.8,91.44 223.71,91.35 v2(223.47,91.35)
  BOTTOM w0.102: v2(223.47,91.35) 223.47,91.55 223.37,91.65 UG9.P7
  BOTTOM w0.119: UG8.P5 194.76,75.65 194.64,75.77 194.64,75.94 v2(194.83,76.13)
FB_VCCIO: length 15.3
  TOP w0.254: v2(123.95,117.54) 123.95,120.76 124.54,121.35 124.54,122.4 126.62,124.48 126.62,125.47 126.2,125.89 v1(125.66,125.89) 123.85,125.89 v2(123.78,125.81)
  BOTTOM w0.254: PU509.14 123.84,117.65 123.95,117.54 v2(123.95,117.54) ; v2(123.78,125.81) 123.73,125.76 PC818.2 123.73,124.35 PR5012.2 123.69,124.3 PR5015.1
FB_VDDQ_SENSE: length 88.4
  TOP w0.254: v2(261.08,86.81) 262.72,86.81 263.17,86.37 263.17,80.65 260.1,77.59 v2(260.1,76.13) ; v2(247.63,49.8) 247.63,49.8 247.85,49.8 248.49,49.16 248.49,44.5 245.12,41.12 245.12,40.3 245.47,39.94 v1(245.47,39.17) 245.47,38.53 244.23,37.28 v2(244.23,37.2)
  IN1 w0.254: v2(260.1,76.13) 263.93,76.13 268.65,71.41 268.65,55.38 264.19,50.92 248.74,50.92 v2(247.63,49.8)
  BOTTOM w0.2: v2(261.08,86.81) 260.43,86.81 258.37,84.75 256.92,84.75 256.32,85.35 UG9.E52
  BOTTOM w0.203: PU8200.12 244.33,37.11 v2(244.23,37.2) 244.23,38.08 PR8209.1
FBCAL_GND: length 6.4
  TOP w0.1: RG68.1 254.17,91.49 252.65,91.49 252.14,92 249.42,92 v1(249.21,91.79) v2(248.77,91.35)
  BOTTOM w0.1: UG9.P44 v2(248.77,91.35)
FBCAL_TERM: length 5.5
  TOP w0.1: v2(249.47,92.65) 249.86,92.26 252.68,92.26 v1(252.78,92.15) 253.69,92.15 253.97,92.43 RG69.1
  BOTTOM w0.11: UG9.R45 v2(249.47,92.65)
FBCAL_VDDQ: length 1.7
  TOP w0.305: v2(248.77,92.65) 248.12,92 RG67.1
  BOTTOM w0.11: UG9.R44 v2(248.77,92.65)
FBRTN: length 66.3
  TOP w0.203: PR6029.1 PR6025.1 v1(244.92,124.59) 244.92,125.1 v2(244.55,125.47)
  IN2 w0.254: v2(280.98,144.45) 280.11,144.45 279.22,143.56 274.46,143.56 274.02,144 274.02,144.48 273.45,145.05 v2(273.14,145.05) 272.37,144.29 269.78,144.29 v2(267.92,142.42) 269.06,141.28 269.06,133.72 264.74,129.4 264.18,129.4 263.42,128.65 263.42,128.04 262.06,126.68 258.99,126.68 258.16,125.85 244.93,125.85 v2(244.55,125.47)
  BOTTOM w0.203: PU6000.32 274.01,143.05 273.08,143.97 273.08,145 v2(273.14,145.05) 273.97,145.05 274.2,145.28 PC6012.2 PC6010.1
  BOTTOM w0.254: PC6015.2 PR6061.2 282.72,144.14 282.41,144.45 v2(280.98,144.45) ; PC6002.1 v2(267.92,142.42)
FBVDD/Q_EN: length 158.9
  TOP w0.102: v2(311.97,57.88) 311.97,58.13 312.89,59.05 PR8216.1 312.89,60.05 RG557.1 312.42,60.52 312.42,60.91 312.58,61.08 UG27.4
  IN3 w0.102: v2(305.82,44.12) 305.82,45.39 307.22,46.79 307.86,46.79 308.68,47.62 308.68,51.04 313,55.36 313,56.85 v2(311.97,57.88)
  IN6 w0.102: v2(188.62,59.79) 189.11,59.3 189.11,58.66 190.21,57.57 192.28,57.57 194.07,59.35 194.57,60.11 195.17,60.7 195.3,60.79 195.51,60.93 195.71,61.06 195.86,61.16 195.98,61.21 196.09,61.32 196.14,61.32 196.54,61.71 196.54,61.71 196.89,61.71 197.24,61.71 199.65,61.71 201.34,60.03 201.52,60.03 203.64,60.03 203.76,60.15 204.64,60.15 204.82,59.97 207.72,59.97 211.17,56.53 211.33,56.36 211.33,54.67 211.33,54.49 213.98,51.84 216.33,51.84 216.94,51.24 224.04,51.24 224.29,51.49 227.19,51.49 228.29,50.39 234.53,50.39 235.15,49.77 237.63,49.77 238.25,50.4 248.96,50.4 250.18,49.17 259.77,49.17 261.37,47.57 271.1,47.57 272.45,48.92 277.48,48.92 279.57,46.83 279.57,44.29 281.55,42.3 289.72,42.3 291.1,43.68 305.38,43.68 v2(305.82,44.12)
  BOTTOM w0.102: UG31.19 190.38,57.57 189.34,58.61 189.34,59.08 v1(189.17,59.24) v2(188.62,59.79)
FBVDD/Q_ENP: length 91.7
  TOP w0.254: v2(311.18,59.17) 311.19,59.19 PR8216.2 ; v2(248.97,48.56) 248.97,44.44 245.56,41.03 245.56,40.39 245.88,40.07 245.88,38.39 244.86,37.37 244.86,36.65 245.83,35.68 245.83,33.84 245.52,33.52 v1(245.44,33.52) 244.73,32.81 v2(244.73,32.26)
  IN3 w0.254: v2(248.97,48.56) 249.76,49.34 258.19,49.34 260.59,46.94 272.63,46.94 274.29,48.6 293.68,48.6 299.16,54.08 299.16,56.48 301.55,58.87 308.4,58.87 308.69,59.17 v2(311.18,59.17)
  BOTTOM w0.203: v2(244.73,32.26) PU8200.3
  BOTTOM w0.254: PC8211.1 244.14,31.68 v2(244.73,32.26)
FBVDD_PSI: length 3.4
  TOP w0.102: v1(245.73,31.56) PR8219.2
  TOP w0.254: PR8219.2 244.04,32.3 v2(244.06,32.32)
  BOTTOM w0.203: PU8200.4 244.33,32.59 v2(244.06,32.32)
FFS_INT1: length 84.9
  TOP w0.102: v2(193.27,61.35) 192.86,61.35 192.1,60.58 192.1,60.32 191.88,60.11 190.83,60.11 190.1,60.84 190.1,67.04 189.2,67.94 189.2,68.71 188.81,69.09 188.81,69.09 188.54,69.36 188.54,70.77 188.13,71.17 185.75,71.17 v1(185.42,70.85) 185.24,70.67 US1.11 ; RP5.8 220.21,27.05 220.48,26.79 v2(220.48,26.66)
  IN1 w0.089: v2(214.7,32.69) 214.7,32.76 214.32,33.14 214.32,33.41 213.24,34.49 213.24,34.66 209.87,38.03 209.87,39.23 210.57,39.93 210.57,42.79 210.38,42.98 210.38,43.88
  IN1 w0.102: 210.38,43.88 210.38,44.63 209.3,45.71 v2(209.3,47.62)
  IN3 w0.102: v2(193.27,61.35) 193.27,61.62 195.52,63.87 199.27,63.87 199.84,63.3 199.84,62.35 201.49,60.7 201.49,48.98 203.68,46.79 208.48,46.79 v2(209.3,47.62)
  IN6 w0.089: 219.18,34.09 218.26,34.09 218.2,34.03 218.19,34.03 218,33.84 216.86,33.84 216.8,33.77 215.78,33.77 v2(214.7,32.69)
  IN6 w0.102: v2(220.48,26.66) 220.48,27.58 220.86,27.96 220.86,32.76 219.53,34.09 219.18,34.09
  BOTTOM w0.089: UH1.BE18 214.8,32.79 v2(214.7,32.69)
FFS_INT2: length 82.8
  TOP w0.102: RP5.7 219.72,27.55 219.4,27.23 219.4,26.74 v2(219.54,26.6) ; US1.9 186.24,70.74 186.44,70.95 187.68,70.95 187.89,70.73 QS3.3 187.89,69.69 188.72,68.87 188.72,68.87 188.97,68.61 188.97,67.85 189.88,66.94 189.88,60.39 190.5,59.77 v1(191.16,59.77) 191.33,59.77 191.38,59.81 191.92,59.81 192.32,60.22 192.32,60.49 192.57,60.74 v2(193.26,60.74)
  IN1 w0.089: v2(212.48,43.3) 212.23,43.3 211.25,42.32 211.25,38.43 211.59,38.09 211.59,37.2 212.98,35.82 215.26,35.82 215.85,35.23 215.85,32.63 v2(216.04,32.44)
  IN3 w0.089: v2(212.48,43.3) 211.9,43.88
  IN3 w0.102: v2(193.26,60.74) 193.67,61.14 193.67,61.7 195.27,63.3 197.94,63.3 199.14,62.09 199.14,61.4 201.24,59.3 201.24,48.7 203.72,46.22 209.56,46.22 211.9,43.88
  IN6 w0.089: 219.18,32.88 218.58,32.88 218,33.46 216.54,33.46 216.04,32.95 v2(216.04,32.44)
  IN6 w0.102: 219.18,32.88 219.78,32.88 220.35,32.31 220.35,28.57 219.53,27.74 219.53,26.61 v2(219.54,26.6)
  BOTTOM w0.089: v2(216.04,32.44) 216.03,32.44 215.76,32.72 UH1.BF18
FFS_INT2_CONN: length 114
  TOP w0.102: DS1.2 188.13,64.84 RS1.2 189.02,64.14 188.88,64 187.93,64 186.06,62.13 186.06,53.65 189.45,50.26 189.45,46.4 184.13,41.08
  TOP w0.107: 184.13,41.08 184.13,35.97 181.81,33.65 181.81,32.5 v1(181.65,32.34) 179.27,29.96 179.27,23.87 180.5,22.65 v2(180.5,22.59)
  IN6 w0.102: v2(180.5,22.59) 179.57,21.66 162.53,21.66 160.42,19.56 158.64,19.56 157.74,18.66 129.27,18.66 126.32,15.71 126.32,15.24 124.56,13.48 124.1,13.48 123.47,12.86 v2(122.92,12.86)
  BOTTOM w0.102: v2(122.92,12.86) JHDD.20
FLIP: length 13.4
  TOP w0.102: v2(14.3,52.06) 14.78,52.54 UU2.32
  IN1 w0.102: v2(14.3,52.06) 14.37,52.06 14.69,52.38 14.69,52.48 14.7,52.49 14.7,52.83 14.69,52.84 14.69,53.09 14.7,53.1 14.7,53.44 14.69,53.45 14.69,54.37 14.71,54.39 14.71,54.73 14.69,54.75 14.69,55.98 v2(15.02,56.32)
  BOTTOM w0.102: QU2.1 18.08,55.67 18.48,56.06 18.48,56.1 18.68,56.31 18.68,57.76 18.2,58.25 v1(17.59,58.25) 16.19,58.25 RU27.2 15.81,58.12 15.81,57.41 15.22,56.82 15.22,56.52 v2(15.02,56.32)
FRAME_LOCK#: length 27.2
  IN1 w0.102: v2(215.02,121.4) 218.27,121.4 218.93,120.74 218.93,120.57 219.49,120.01 220.67,120.01 222.58,118.1 222.58,114.88 222.89,114.56 222.89,113.39 222.59,113.08 220.37,113.08 219.24,114.21 v2(219.24,114.33)
  BOTTOM w0.102: QG506.3 211.91,126.2 RG502.2 212.38,125.82 212.48,125.72 212.48,124.69 v1(212.09,124.3) 212.05,124.26 212.05,122.99 212.58,122.46 213.96,122.46 v2(215.02,121.4)
  BOTTOM w0.109: UG9.BG2 v2(219.24,114.33)
G-SYNC#: length 100.7
  TOP w0.107: v2(161.69,180.75) 161.62,180.82 JEDP.21
  IN1 w0.102: v2(161.69,180.75) 163.5,178.95 171.26,178.95 171.76,178.44 174.85,178.44 175.47,177.83 178.93,177.83 179.16,178.06 180.69,178.06 181.4,177.35 183.78,177.35 184.19,176.93 186.89,176.93 187.08,176.93 187.61,176.4 187.93,176.4 188.49,175.85 190.47,175.85 193.5,172.81 201.72,172.81 201.85,172.68 204.1,170.43 204.1,168.52 203.2,167.62 203.2,161.78 203.9,161.08 204.03,160.94 204.03,158.31 204.43,157.92 204.43,157.27 206.16,155.54 207.62,155.54 208.1,155.06 208.1,151.86 204.53,148.29 204.53,144.46 205.37,143.63 205.37,131.56 206.79,130.14 206.79,129.43 207.65,128.57 v2(209.09,128.57)
  BOTTOM w0.102: v1(208.59,128.98) 209.01,128.57 v2(209.09,128.57) 209.47,128.18 209.47,127.46 QG506.1 209.02,127.42 RG517.2
GC6_EVENT#: length 126.9
  IN1 w0.089: v2(213.43,29.45) 213.43,30.53 212.13,31.84 212.13,32.1 211.46,32.76 209.24,32.76 208.02,33.98 207.44,33.98 207.19,34.23 207.19,35.7 206.76,36.12 204.92,36.12 201.88,39.17 201.3,39.17 197.24,43.23 197.24,45.7
  IN1 w0.102: v2(193.49,65.21) 192.99,64.7 192.99,63.74 193.18,63.55 193.18,62.47 192.63,61.93 192.63,61.1 192.29,60.75 192.29,60.25 191.76,59.72 191.76,59.01 192.29,58.48 192.29,54.34 193.22,53.4 193.22,51.82 196.06,48.98 196.79,48.98 197.26,48.51 197.26,47.61 196.71,47.07 196.71,46.62 197.24,46.09 197.24,45.7
  IN2 w0.102: v2(193.49,65.21) 193.49,65.45 191.87,67.07 191.87,68.8 188.57,72.1 188.57,94.65 188.11,95.11 188.11,100.11 187.02,101.2 187.02,102.67 188.68,104.32 v2(189.86,104.32)
  IN6 w0.102: v2(189.86,104.32) 190.19,104.32 190.64,104.77 191.84,104.77 193.76,106.68 194.01,106.68 194.24,106.91 196.29,106.91 197.91,105.3 200.45,105.3 200.59,105.43 202.49,107.33 202.49,107.52 202.48,109.25 204.8,111.56 213.61,111.56 214.61,112.56 v2(215.81,112.56)
  BOTTOM w0.089: DG2.1 214.84,112.56 v2(215.81,112.56) ; UH1.BB26 213.94,28.94 v2(213.43,29.45)
GC6_EVENT#_D: length 5.1
  BOTTOM w0.089: 217.7,112.63 217.69,112.63 217.61,112.71 217.32,112.71 217.09,112.47 DG2.2 216.45,112.48 RG8.1 216.05,113.94 v1(215.18,113.94)
  BOTTOM w0.1: UG9.BD1 218.95,112.63 217.7,112.63
GC6_FB_EN: length 224.9
  TOP w0.089: v2(192.92,30.47) 192.1,31.3
  TOP w0.102: v2(193.8,52.25) 193.8,51.9 190.86,48.96 190.86,45.69 189.47,44.3 189.47,38.79 189.71,38.55 189.71,36.08 190.5,35.28 190.5,32.89 192.1,31.3 ; v1(314.3,55.18) 313.94,55.18 v2(313.69,55.44) 313.53,55.59 RG561.2 312.9,55.48 310.18,52.76 QG511.1
  IN2 w0.089: v2(192.92,30.47) 192.86,30.47 192.48,30.09 192.48,27.49 193.14,26.82 197,26.82 197.27,27.09 198.27,27.09 200.05,25.31 200.55,25.31 201.24,24.63 202.55,24.63 202.88,24.96 205.2,24.96 205.85,25.62 206.92,25.62 207.21,25.91 208.43,25.91 208.86,26.34 209.3,26.34 209.69,26.72 209.69,26.9 210.13,27.34 211.48,27.34 211.53,27.39 212.83,27.39 213.2,27.76 214.58,27.76 215.07,27.27 215.32,27.27 215.38,27.21 217.16,27.21 v2(217.59,27.64)
  IN3 w0.102: v2(305.74,15.88) 306.57,16.7 308.82,16.7 309.51,17.39 309.51,18.28 310.42,19.19 311.57,19.19 312.75,20.37 312.75,21.97 312.08,22.63 311.68,22.63 310.87,23.45 310.87,24.2 312.8,26.13 312.8,27.5 311.03,29.26 311.03,31.55 309.83,32.76 309.83,33.59 309.23,34.18 309.23,44.87 309.6,45.24 309.6,46.61 309.42,46.79 309.42,50.42 313.69,54.68 v2(313.69,55.44)
  IN4 w0.089: v2(217.59,27.64) 218.07,27.64 218.42,27.99 219.18,27.99
  IN4 w0.102: v2(305.74,15.88) 305.32,15.88 303.46,17.73 297.8,17.73 296.74,18.79 292.37,18.79 290.33,20.83 272.1,20.83 271.57,20.3 271.27,20.3 266.06,20.3 265.37,19.61 259.02,19.61 258.31,18.9 257.69,18.9 257.41,18.62 254.96,18.62 254.42,18.08 248.85,18.08 248.54,17.76 246.18,17.76 245.87,18.08 243.29,18.08 240.68,20.69 240.56,20.81 237.54,20.81 235.76,22.58 234.13,22.58 231.49,25.22 231.49,25.35 231.25,25.59 231.25,32.11 229.65,33.71 229.65,33.98 229.26,34.37 229.06,34.37 228.06,34.37 226.89,33.2 225.5,33.2 225.09,33.61 223.91,33.61 221.98,31.68 220.48,31.68 220.32,31.51 220.32,30.44 220.32,28.65 219.66,27.99 219.18,27.99
  BOTTOM w0.102: v2(193.8,52.25) 194,52.45 194,52.7 192.22,54.48 UG31.7
  BOTTOM w0.122: v2(217.59,27.64) 217.16,27.21 216.69,27.21 216.63,27.27 216.04,27.27 215.88,27.43 UH1.BF29
GPD_7: length 7.5
  TOP w0.089: v2(218.96,22.61) RH11.1 218.42,22.03 219.18,21.27
  TOP w0.102: RH594.2 219.81,20.64 219.18,21.27
  BOTTOM w0.089: v2(218.96,22.61) 218.96,22.46 v1(218.42,21.92) 218.33,21.83 217.34,21.83 217.32,21.85 216.77,21.85 216.32,21.39 215.43,21.39 215.25,21.56 UH1.BE41
GPIO4_1V8_MAIN_EN: length 121.3
  IN2 w0.102: v2(187.4,55.75) 187.14,56.01 187.14,56.16 187.14,56.16 187.14,56.51 187.14,56.51 187.14,56.63 187.61,57.1 192.84,57.1 193.81,58.08 193.81,59.22 196.02,61.43 196.02,62.34 198.26,64.58 198.26,65.14 197.56,65.84 196.57,65.84 194.66,67.75 v2(193.49,67.75)
  BOTTOM w0.089: UG9.BE1 218.73,113.59 218.14,113.59 217.81,113.91 216.54,113.91 216.16,114.29 214.69,114.29 213.29,112.89 213.29,110.78 v1(214.15,109.92) 214.58,109.48 214.58,107.25 212.67,105.34 210.82,105.34
  BOTTOM w0.102: RG571.1 187.24,55.59 v2(187.4,55.75) ; RG571.1 188.29,55.05 188.52,55.28 UG31.13 ; RG571.1 187.24,54.91 187,54.66 186.42,54.66 RG574.1 186.04,56.51 187.93,58.4 187.93,61.37 188.53,61.97 193.5,61.97 193.69,61.77 193.69,60.59 193.34,60.24 193.34,60.03 193.09,59.78 192.4,59.78 192.13,59.51 RG582.1 ; v2(193.49,67.75) 191.97,67.75 191.07,68.65 191.07,69.54 190.07,70.54 190.07,83.82 190.5,84.24 190.5,102.28 193.1,104.88 197.91,104.88 198.37,105.34 204.03,105.34 204.82,106.12 206.42,106.12 207.21,105.34 210.82,105.34
GPIO8: length 6.9
  TOP w0.102: v2(200.76,165.88) 200.76,166.21 RT125.1 200.33,166.73 200,167.06 199.3,167.06 198.93,167.43 198.93,168.67 198.51,169.09 RT124.2 198.01,169.93 v1(197.72,170.22)
  BOTTOM w0.089: v2(200.76,165.88) 200.66,165.78 UT4.H6
GPIO_1: length 13.6
  TOP w0.102: v2(37.66,24.76) 37.49,24.76 v1(37.04,25.2)
  IN1 w0.254: v2(36.6,34.78) 36.58,34.78 36.01,34.22 36.01,30.18 37.6,28.6 37.6,24.82 v2(37.66,24.76)
  BOTTOM w0.107: UA1.2 36.32,34.51 v2(36.6,34.78)
  BOTTOM w0.254: v2(37.66,24.76) 37.93,25.02 DA2.2
GPP_H12: length 5.3
  BOTTOM w0.089: UH1.AB47 203.88,18.62 203.65,18.39 203.65,17.78 203.71,17.72 203.71,17.45 203.53,17.26 203.4,17.26 203.34,17.2 202.29,17.2 202.04,16.96
  BOTTOM w0.102: 202.04,16.96 200.92,15.84 RH100.2
GPP_H15: length 7.4
  BOTTOM w0.089: UH1.AC47 204.38,18.68 204.22,18.53 204.22,17.71 203.89,17.38 203.82,17.3 203.82,17.24 203.65,17.07 203.46,17.07 203.41,17.02 202.76,17.02 202.69,16.96
  BOTTOM w0.102: 202.69,16.96 202.33,16.59 202,16.59 201.76,16.35 201.76,15.92 202.02,15.66 202.02,13.9 RH99.1
GPP_J9: length 2.5
  TOP w0.089: v2(212.03,37.31) 211.93,37.42 RH218.1 210.51,37.42 v1(210.21,37.11)
  BOTTOM w0.122: UH1.AU9 v2(212.03,37.31)
GPPJ_RCOMP_1P8: length 5.6
  BOTTOM w0.254: UH1.BE1 215.53,41.04 UH1.BE2 ; UH1.BE1 215.66,41.35 215.66,41.37 216.17,41.88 219.2,41.88 219.62,42.29 RH216.1 ; UH1.BE1 UH1.BD1
GPU_ALERT#: length 198.8
  TOP w0.102: UE10.10 320.04,59.81 320.66,59.2 320.66,54 320.09,53.43 319.62,53.43 318.51,54.54 315.86,54.54 315.64,54.75 313.64,54.75 312.6,53.71 312.36,53.71 312.16,53.52 312.16,53.17 311.87,52.87 311.87,52.31 311.13,51.57 311.13,50.98 308.41,48.25 v1(307.54,48.25) 305.86,48.25 305.76,48.15 v2(305.76,47.87)
  IN4 w0.102: v2(206.13,118.23) 206.32,118.23 208.06,116.49 208.33,116.49 210.98,113.83 210.98,62.17 210.55,61.74 210.55,58.7 212.91,56.34 212.91,53.09 214.64,51.37 215.93,51.37 216.33,50.96 216.33,50.96 216.44,50.86 225.63,50.86 226.48,51.71 230.19,51.71 230.64,51.26 232.01,51.26 233.31,49.96 233.31,49.43 233.88,48.86 236.44,48.86 238.19,50.61 240.64,50.61 240.93,50.9 250.28,50.9 250.58,50.61 258.08,50.61 261.23,47.46 271.63,47.46 273.79,49.62 287.42,49.62 292.35,44.69 296.9,44.69 299.41,47.21 304.03,47.21 304.69,47.87 v2(305.76,47.87)
  BOTTOM w0.102: RE644.1 206.76,118.67 206.32,118.23 v2(206.13,118.23) 206,118.23 205.57,118.66 QG501.3
GPU_B+: length 159.3
  IN3 w3.048: 225.66,6.48 224.82,5.64 202.22,5.64 ; 156.16,13.45 150.82,8.12 138.18,8.12 136.34,9.96 ; 129.49,8.56 128.65,7.72 123.88,7.72 123.85,7.7 122.29,7.7 122.27,7.72 121.16,7.72 117.74,11.15
  IN4 w2.54: 118.5,11.17 122.25,7.42 157.74,7.42 159.54,5.62 171.76,5.62 173.94,7.8 173.94,9.46 176.21,12.23 176.75,12.34 181.65,12.34 185.11,8.88
  IN4 w3.048: 226.45,6.59 225.42,5.57 201.94,5.57
  vias: v1(96.63,19.4) v2(102.37,74.86) v2(102.37,74.22) v2(102.37,73.59) v2(102.37,72.95) v2(102.37,72.32) v2(103.01,74.86) v2(103.01,74.22) v2(103.01,73.59) v2(103.01,72.95) v2(103.01,72.32) v2(103.64,74.86) v2(103.64,74.22) v2(103.64,73.59) v2(103.64,72.95) v2(103.64,72.32) v2(115.9,15.73) v2(115.9,15.14) v2(115.9,14.56) v2(116.53,15.73) v2(116.53,15.14) v2(116.53,14.56) v2(116.53,13.97) v2(116.53,13.39) v2(117.17,15.73) v2(117.17,15.14) v2(117.17,14.56) v2(117.17,13.97) v2(117.17,13.39) v2(117.8,15.73) v2(117.8,15.14) v2(117.8,14.56) v2(117.8,13.97) v2(117.8,13.39) v2(118.44,15.73) v2(118.44,15.14) v2(118.44,14.56) v2(118.44,13.97) v2(118.44,13.39) v2(159.66,152.33) v2(159.66,151.74) v2(160.24,152.33) v2(160.24,151.74) v2(160.83,152.33) v2(160.83,151.74) v2(161.41,152.33) v2(161.41,151.74) v2(162,152.33) v2(162,151.74) v2(162.58,152.33) v2(162.58,151.74) v2(163.17,152.33) v2(163.17,151.74) v2(198.51,148.39) v2(198.51,147.63) v2(198.51,146.99) v2(199.02,148.01) v2(199.14,146.99) v2(199.14,146.36) v2(199.53,147.56) v2(199.78,146.99) v2(199.78,146.36) v2(262.06,24.21) v2(262.09,23.6) v2(262.7,24.84) v2(262.7,24.26) v2(262.72,23.6) v2(263.28,24.84) v2(263.31,24.26) v2(263.33,23.6) v2(263.86,24.83) v2(263.91,24.23) v2(264.46,24.83) v2(269.5,34.04) v2(269.5,33.46) v2(269.5,32.87) v2(270.09,34.04) v2(270.09,33.46) v2(270.09,32.87) v2(270.67,34.04) v2(270.67,33.46) v2(270.67,32.87) v2(273,10.4) v2(273,9.82) v2(273.58,10.99) v2(273.58,10.4) v2(273.58,9.82) v2(274.16,10.99) v2(274.16,10.4) v2(274.16,9.82) v2(274.75,10.99) v2(274.75,10.4) v2(274.75,9.82) v2(275.33,10.99) v2(275.33,10.4) v2(275.33,9.82) v2(275.92,10.99) v2(275.92,10.4) v2(275.92,9.82) v2(276.55,10.4)
GPU_BUFRST#: length 1
  TOP w0.089: T6.1 224.52,114 v2(224.87,114.35)
  BOTTOM w0.125: UG9.BF9 v2(224.87,114.35)
GPU_DP_AUXN: length 97.8
  IN4 w0.127: v2(223.59,119.95) 223.59,120.2 223.72,120.32 224.45,120.32 224.82,120.7 224.82,121.66 224.28,122.21 224.28,122.24 224.01,122.51 211.41,135.11 211.41,152.28 212.54,153.41 212.54,154.21 214.91,156.57 215.6,156.57 216.1,156.07 222.39,156.07 224.8,158.49 225.82,158.49 226.19,158.12 226.19,157.83 225.99,157.63 225.99,157.62 v2(225.83,157.46)
  IN6 w0.089: v2(235.08,159.96) 235.03,159.91 234.52,159.91 233.5,158.89 231.89,158.89 231.31,158.31 226.15,158.31 225.86,158.02 225.86,157.49 v2(225.83,157.46)
  BOTTOM w0.089: v2(223.59,119.95) 223.82,119.95 223.91,120.04 223.91,120.24 223.82,120.33 223.3,120.33 223.1,120.14 223.1,119.09 223.46,118.74 223.46,118.08 223.61,117.93 223.85,117.93 223.95,117.83 223.95,117.63 UG9.BL8
  BOTTOM w0.107: UV3.13 238.08,162.92 238.24,163.08 238.24,163.89 238.32,163.98 238.41,163.98 238.42,163.97 238.46,163.97 238.74,163.68 238.74,160.98 237.32,159.55 235.49,159.55 v2(235.08,159.96) 234.88,159.76 234.5,159.76 234.1,160.16 234.1,162.79 232.85,164.04 232.34,164.04 231.72,163.41 231.09,163.41 230.28,164.22 UV3.6 ; v2(225.83,157.46) 226.02,157.65 226.02,157.95 225.42,158.54 225.42,159.2 RV618.1 RV665.1
GPU_DP_AUXN_C: length 4.8
  BOTTOM w0.107: UV3.5 228.65,163.57 228.47,163.39 228.47,163.08 228.34,162.95 227.81,162.95 227.63,163.13 226.33,163.13 226.06,162.86 226.06,162.44 CV25.1
GPU_DP_AUXN_R: length 1.8
  BOTTOM w0.107: RV618.2 225.41,160.79 225.41,161 225.64,161.23 225.9,161.23 226.01,161.34 226.01,161.49 CV25.2
GPU_DP_AUXP: length 97.5
  IN4 w0.127: v2(223.61,120.72) 223.78,120.54 224.36,120.54 224.6,120.79 224.6,121.57 224.06,122.12 224.06,122.15 211.19,135.02 211.19,152.37 212.32,153.51 212.32,154.3 214.82,156.79 215.7,156.79 216.19,156.29 222.3,156.29 224.71,158.71 225.91,158.71 226.41,158.21 v2(226.41,157.46)
  IN6 w0.089: v2(226.41,157.46) 226.39,157.46 226.03,157.83 226.03,157.95 226.22,158.15 231.38,158.15 231.96,158.73 233.57,158.73 234.59,159.74 234.73,159.74 235.08,159.39 v2(235.08,159.38)
  BOTTOM w0.089: v2(223.61,120.72) 223.42,120.53 223.22,120.53 222.91,120.22 222.91,118.99 223.25,118.65 223.25,118.02 223.52,117.75 223.52,117.44 223.87,117.09 UG9.BK8
  BOTTOM w0.107: v2(226.41,157.46) 226.22,157.65 226.22,158.03 225.62,158.63 225.62,159.2 RV619.1 RV664.1 ; UV3.10 236.3,164.87 236.39,164.96 237.71,164.96 237.83,164.85 237.92,164.85 238.26,164.51 238.26,164.45 238.95,163.77 238.95,160.89 237.41,159.35 237.24,159.35 237.24,159.35 235.4,159.35 235.38,159.38 v2(235.08,159.38) 234.9,159.55 234.41,159.55 233.89,160.08 233.89,162.71 233.23,163.37 233.07,163.37 232.14,162.44 230.53,162.44 230.36,162.27 UV3.3
GPU_DP_AUXP_C: length 4.8
  BOTTOM w0.107: CV24.1 226.26,162.4 226.26,162.77 226.42,162.93 227.54,162.93 227.72,162.75 228.19,162.75 228.51,162.43 228.51,161.89 228.77,161.62 UV3.2
GPU_DP_AUXP_R: length 1.8
  BOTTOM w0.107: CV24.2 226.21,161.44 226.21,161.25 225.99,161.03 225.73,161.03 225.61,160.91 225.61,160.79 225.94,160.46 RV619.2
GPU_DP_HPD#: length 147.4
  TOP w0.102: QV97.3 220.25,160.64 220.86,161.24 221.55,161.24 221.81,160.98 221.81,160.2 RX5.2 221.5,159.83 v1(221.5,158.78) v2(221.5,158.26)
  IN2 w0.102: v2(238.58,158.8) 233.62,158.8 233.09,159.33 233.09,159.66 232.84,159.91 232.84,159.91 232.71,160.04 230.8,160.04 230.21,159.45 225.13,159.45 223.59,157.92 222.32,157.92 221.98,158.26 v2(221.5,158.26)
  IN4 w0.102: v2(217.1,115.01) 217.66,115.01 217.96,115.31 217.96,116.44 217.46,116.93 217.46,117.96 217.13,118.3 217.13,118.8 217.13,118.8 217.13,119.11 217.99,119.97 218.31,119.97 218.36,120.03 219.42,120.03 219.47,119.97 221.62,119.97 222.98,118.61 224.96,118.61 226.29,119.94 226.29,121.69 229.86,125.26 236.21,125.26 239.34,128.4 262.09,128.4 264.84,131.16 268.78,131.16 270.01,132.39 270.01,144.96 264.11,150.87 257.79,150.87 257.26,151.4 253.3,151.4 252.33,150.42 244.88,150.42 243.3,152 241.34,152 240.12,153.21 239.17,153.21 238.71,153.67 238.71,158.49 238.58,158.61 v2(238.58,158.8)
  BOTTOM w0.1: UG9.BE3 220.16,113.35 219.83,113.68 219.54,113.68 219.26,113.96 218.4,113.96 217.75,114.61 217.74,114.61 217.61,114.73 217.6,114.73 217.32,115.01 v2(217.1,115.01)
GPU_DP_HPD_R: length 4.3
  BOTTOM w0.107: RX2.2 CX1.1 232.21,170.03 232.04,170.2 v1(232.04,170.42) 232.04,170.89 232.37,171.23 JDP.2
GPU_DP_N0: length 84.6
  IN6 w0.089: v2(229.87,115.05) 229.87,115.26 230.13,115.52 230.39,115.52 230.63,115.76 230.63,115.98 230.63,121.92 224.41,128.14 222.9,128.14 214.96,136.08 209.72,136.08 208.36,137.44 208.36,143.37 207.03,144.69 207.03,147.89 207.03,148.42 210.15,151.54 210.15,153.46 212.8,156.11 214.49,156.11 216.19,157.81 216.98,157.81 218.07,158.89 222.43,158.89 223.65,160.12 223.65,161.85 223.97,162.17 223.97,164.13 224.97,165.14 225.27,165.14 226.97,166.84 229.71,166.84 229.82,166.73 229.82,166.63 v2(229.58,166.39)
  BOTTOM w0.101: v2(229.87,115.05) 230.07,115.05 230.17,114.95 UG9.BG17
  BOTTOM w0.107: CV27.1 229.75,168.06 229.75,166.56 v2(229.58,166.39)
GPU_DP_N0_C: length 8.4
  BOTTOM w0.107: JDP.5 232.89,174.9 232.42,174.9 231.53,174.01 231.53,172.05 229.5,170.01 229.5,169.23 CV27.2
GPU_DP_N1: length 104.4
  TOP w0.107: CV30.1 242.06,169.31 241.94,169.19 241.94,168.53 241.53,168.11 241.53,167.62 241.66,167.49 241.81,167.49 v2(242.03,167.72)
  IN6 w0.089: v2(242.03,167.72) 241.73,167.42 241.4,167.42 241.21,167.22 241.21,165.03 240.8,164.62 238.7,164.62 238.31,165.01 233.93,165.01 232.58,166.36 232.58,167.24 232.1,167.72 225,167.72 223.94,166.66 223.94,165.32 223.1,164.47 223.1,162.5 222.82,162.22 222.82,160.5 222.21,159.89 217.92,159.89 216.67,158.64 213.54,158.64 212.99,158.09 212.99,157.78 209.35,154.14 209.35,151.87 206.2,148.72 206.2,143.69 206.79,143.1 206.79,137.83 209.38,135.25 214.62,135.25 222.55,127.31 223.8,127.31 229.84,121.27 229.84,118.17 228.71,117.04 228.71,114.71 v2(229.07,114.35)
  BOTTOM w0.101: UG9.BF15 v2(229.07,114.35)
GPU_DP_N1_C: length 10.8
  TOP w0.107: CV30.2 242.22,169.89 242.02,170.09 242.02,170.28 241.19,171.12 239.92,171.12 238.64,172.4 236.54,172.4 235.15,173.79 235.15,175.06 JDP.11
GPU_DP_N2: length 102.9
  IN6 w0.089: v2(240.67,167.58) 239.41,167.58 237.54,165.71 234.54,165.71 233.95,166.3 233.95,167.33 232.86,168.42 231.88,168.42 230.58,169.73 229.05,169.73 227.75,168.42 224.61,168.42 223.19,167 223.19,165.57 222.4,164.78 222.4,162.79 222.12,162.51 222.12,162.22 221.33,161.43 220.95,161.43 220.33,160.81 216.7,160.81 216.02,160.13 215.42,160.13 215.06,159.77 212.83,159.77 212.36,159.3 212.36,158.96 212.13,158.72 211.78,158.72 211.51,158.45 211.51,158.24 208.72,155.44 208.72,152.13 205.41,148.82 205.41,143.36 206.07,142.7 206.07,137.43 208.95,134.54 214.3,134.54 214.33,134.52 214.35,134.52 222.52,126.35 223.28,126.35 226.45,123.18 226.45,122.36 226.47,122.33 226.47,121.67 226.46,121.67 226.46,121.59 226.45,121.58 226.45,120.07 226.46,120.06 228.17,118.35 228.17,113.5 228.06,113.39 227.93,113.39 227.77,113.55 v2(227.77,113.75)
  BOTTOM w0.101: UG9.BF14 v2(227.77,113.75)
  BOTTOM w0.107: v2(240.67,167.58) 240.86,167.39 241.04,167.39 241.23,167.58 241.23,168.3 241.05,168.48 CV33.1
GPU_DP_N2_C: length 8.9
  BOTTOM w0.107: JDP.17 237.05,174.41 237.05,174.59 237.16,174.7 237.92,174.7 238.45,174.17 238.45,172.36 241.29,169.52 241.29,169.08 241.18,168.97 240.86,168.97 CV33.2
GPU_DP_N3: length 97.2
  IN6 w0.089: v2(227.77,115.05) 227.76,115.06 226.9,115.06 226.41,115.56 226.41,117.78 224.95,119.24 224.95,120.7 225.78,121.52 225.78,122.95 224.33,124.4 223.58,124.4 214.09,133.88 208.05,133.88 205.43,136.5 205.43,142.34 204.7,143.07 204.7,148.99 204.77,149.06 204.77,149.08 208.08,152.39 208.08,155.71 210.87,158.5 210.87,160.12 211.43,160.68 212.51,160.68 214,162.17 218.68,162.17 220.88,164.37 220.88,165.6 224.34,169.06 227.45,169.06 228.98,170.59 231.66,170.59 233.76,168.49 234.35,168.49 235.26,167.59 235.26,166.75 v2(235.29,166.72)
  BOTTOM w0.101: UG9.BG14 v2(227.77,115.05)
  BOTTOM w0.107: v2(235.29,166.72) 235.1,166.91 235.1,169.02 CV31.1
GPU_DP_N3_C: length 2.8
  BOTTOM w0.107: CV31.2 235.15,170.25 235.15,171.19 235.37,171.41 JDP.12
GPU_DP_P0: length 84.5
  IN6 w0.089: v2(229.79,115.7) 229.81,115.69 230.32,115.69 230.46,115.83 230.46,115.91 230.46,115.92 230.46,121.85 224.34,127.98 222.83,127.98 214.89,135.91 209.65,135.91 208.19,137.37 208.19,143.3 206.87,144.62 206.87,147.96 206.87,148.49 209.99,151.6 209.99,153.53 212.73,156.28 214.42,156.28 216.12,157.97 216.91,157.97 218,159.06 222.36,159.06 223.48,160.19 223.48,161.92 223.8,162.24 223.8,164.2 224.9,165.3 225.2,165.3 226.9,167 229.78,167 229.98,166.8 229.98,166.57 v2(230.16,166.39)
  BOTTOM w0.101: UG9.BH17 230.04,115.45 v2(229.79,115.7)
  BOTTOM w0.107: CV26.1 229.95,168.15 229.95,168.15 229.95,166.6 v2(230.16,166.39)
GPU_DP_P0_C: length 8.4
  BOTTOM w0.107: JDP.3 233.07,174.39 233.07,174.54 232.91,174.7 232.5,174.7 231.73,173.93 231.73,171.96 229.7,169.93 229.7,169.07 229.81,168.96 230.18,168.96 CV26.2
GPU_DP_P1: length 104.5
  TOP w0.107: v2(242.03,167.13) 241.87,167.29 241.57,167.29 241.32,167.54 241.32,168.2 241.74,168.62 241.74,169.04 CV28.1
  IN6 w0.089: v2(229.07,115.05) 229.07,114.87 229.17,114.77 229.37,114.77 229.47,114.87 229.47,115.22 229.24,115.45 229.05,115.45 228.87,115.62 228.87,116.97 230.01,118.1 230.01,121.34 223.87,127.47 222.62,127.47 214.69,135.41 209.44,135.41 206.96,137.9 206.96,143.17 206.37,143.76 206.37,148.65 209.52,151.8 209.52,154.08 213.15,157.71 213.15,158.02 213.61,158.48 216.74,158.48 217.99,159.73 222.28,159.73 222.98,160.43 222.98,162.15 223.26,162.44 223.26,164.4 224.11,165.25 224.11,166.6 225.07,167.56 232.03,167.56 232.41,167.17 232.41,166.3 233.87,164.84 238.24,164.84 238.63,164.46 240.86,164.46 241.37,164.96 241.37,167.16 241.47,167.25 241.91,167.25 v2(242.03,167.13)
  BOTTOM w0.101: UG9.BG15 v2(229.07,115.05)
