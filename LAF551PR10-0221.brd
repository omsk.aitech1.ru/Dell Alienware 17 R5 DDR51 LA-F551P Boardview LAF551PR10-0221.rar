# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.2V_VCCPLL_OC: length 10.5
  TOP w0.508: v2(136.91,103.04) 136.08,103.87 135.53,103.87 134.83,104.57 134.19,104.57 133.49,103.87 132.29,103.87 v3(131.9,104.26) 131.58,104.59 v2(131.25,104.59) ; RH530.1 v2(160.75,102.3)
  BOTTOM w0.254: UC1.BJ13 136.86,103.09 v2(136.91,103.04) 137.24,103.04 UC1.BH13
  BOTTOM w0.305: v2(168.76,101.67) 169.08,102.01 UC1.G11
  BOTTOM w0.508: C11.1 130.11,104.06 130.64,104.59 v2(131.25,104.59)
+1.2VP: length 49.8
  IN3 w0.254: v2(95.96,50.39) 95.13,50.39 93.58,48.84 v2(93.58,48.21) 93.58,48.02 93.93,47.68 95.14,47.68 96.21,46.61 96.21,43.59 99.83,39.97 99.83,37.77 98.12,36.06 98.12,33.26 97.29,32.44 v2(96.47,32.44)
  IN3 w0.508: v2(96.85,32.95) 97.61,33.71 97.61,36.31 99.3,38 99.3,39.78 95.68,43.4 95.68,45.44 94.08,47.04 92.15,47.04 91.39,46.28 v2(90.31,46.28)
  BOTTOM w0.203: v2(93.58,48.21) 93.49,48.12 PU201.5 ; PU201.19 90.39,46.2 v2(90.31,46.28)
  BOTTOM w0.254: v2(95.96,50.39) 94.65,50.39 PR205.2
  vias: v1(94.53,25.78) v2(94.08,29.19) v2(94.08,28.55) v2(94.08,27.92) v2(94.08,27.28) v2(94.71,29.19) v2(94.71,28.55) v2(94.71,27.92) v2(94.71,27.28) v2(95.35,29.19) v2(95.35,28.55) v2(95.35,27.92) v2(95.35,27.28) v2(95.98,29.19) v2(95.98,28.55) v2(95.98,27.92) v2(95.98,27.28) v2(96.62,29.19) v2(96.62,28.55) v2(96.62,27.92) v2(96.62,27.28)
+1.5VS_SNB1: length 3.2
  TOP w0.102: PR8204.2 v1(263.22,32.69)
  TOP w0.254: PC8210.1 265.12,32.2 PR8204.2
+1.8V_PRIM: length 17.3
  TOP w0.381: 206.13,33.46 205.59,33.99 205.59,36.98 206.59,37.98 206.59,38.77 206.32,39.04 205.88,39.04 205.61,39.31 205.61,40.68 205.88,40.95 207.65,40.95 208.23,41.52
  IN6 w0.508: v2(211.06,34.32) 211.59,34.32 213.13,35.86 213.44,35.86 213.78,36.19 213.78,36.72 v2(213.86,36.81)
  BOTTOM w0.254: UH1.BB11 v2(213.86,36.81) ; UH1.AN15 v2(209.97,34.32) ; UH1.AR15 v2(211.06,34.32)
  vias: v1(208.06,32.83) v2(206.25,32.07)
+1.8VA_TBTA_LDO: length 3.1
  TOP w0.203: v1(196.71,167.38) v2(197.34,167.38)
  TOP w0.508: CT100.1 197.79,166.93 v2(197.34,167.38)
  BOTTOM w0.203: v2(197.34,167.38) 197.34,167.17 198.15,166.37 UT4.K1
+1.8VALW: length 605.8
  TOP w0.381: v2(211.09,38.02) 211.36,38.28 212.35,38.28 212.62,38.01 RH599.2 ; v2(221.64,162.37) 221.33,162.68 UX1.5
  TOP w0.508: 189.14,74.72 189.14,74.31 192.24,71.21 192.24,69.89 194.37,67.76 194.37,67.16 ; PR6406.2 310.26,57.99 310.56,58.3 310.56,60.05 v2(310.31,60.31) ; 200.82,62.09 202.64,60.28 204.16,60.28 204.64,59.79 204.64,59.19 204.53,59.07 204.53,56.87 203.98,56.32 203.98,55.6 204.34,55.24 207.24,55.24 210.3,52.18 210.3,49.25 211.08,48.47 211.08,47.49 208.43,44.83 208.43,43.92 208.42,43.91 ; 200.82,62.09 200.28,61.55 196.39,61.55 195.94,61.1 195.28,61.1 193.88,59.7 193.16,57.94 191.88,56.67 191.88,50.59 190.34,49.05 v2(190.34,47.42) ; 200.82,62.09 200.82,63.54 201.68,64.41 v2(201.68,65.88) ; v2(274.49,154.97) v1(274.49,154.26) 274.49,153 273.94,152.44 273.94,149.83 272.63,148.52 272.63,146.89 273.77,145.75 276.37,145.75 PR6037.2
  TOP w0.762: 193.95,115 193.94,115.01 189.7,115.01 189.08,114.39 187.53,114.39 185.87,112.73 185.87,99.67 187.49,98.06 187.49,96.46 189.14,94.8 189.14,74.72 ; 200.36,66.18 195.35,66.18 194.37,67.16
  IN2 w0.508: v2(190.34,47.42) 190.31,47.39 187.51,47.39 184.22,44.1 181.8,44.1 179.59,41.89 170.89,41.89 169.92,42.85 169.92,47.31 169.41,47.82 164.46,47.82 163.65,47.01 162.73,47.01 161.92,47.82 156.14,47.82 155.4,47.07 154.31,47.07 152.97,48.42 145.36,48.42 144.76,47.82 132.07,47.82 131.17,46.92 130.34,46.92 129.44,47.82 123.92,47.82 123.42,48.31 106.66,48.31 105.81,47.46 99.22,47.46 98.86,47.82 97.16,47.82 96.52,48.46 95.16,48.46 94.54,49.08 92.61,49.08 91.8,48.26 86.93,48.26 86.66,48 66.97,48 65.62,49.35 64.4,49.35 63.78,48.73 57.98,48.73 57.55,49.17 48.37,49.17 48.07,48.86 37.47,48.86 36.43,49.9 v2(35.06,49.9) ; v2(222.97,171.38) 222.92,171.33 222.92,162.85 222.4,162.33 221.67,162.33 v2(221.64,162.37)
  IN3 w0.381: 210.87,41.8 211.09,41.57 v2(211.09,38.02)
  IN3 w0.508: v2(211.96,159.12) 212.29,159.12 212.86,159.69 212.86,160.59 213.14,160.87 213.14,161.76 214.51,163.13 218.18,163.13 218.79,163.74 220.76,163.74 221.14,163.36 221.14,162.87 v2(221.64,162.37)
  IN3 w1.016: 223.63,48.78 224.93,47.49 228.09,47.49 229.01,48.41 233.3,48.41 233.86,47.85 234.04,47.67 243.1,47.67 243.65,48.21 244.8,48.21 246.1,49.51 246.1,50.22 246.81,50.93 274.11,50.93 274.79,50.26 278.1,50.26 ; 308.35,60.54 307.06,60.54 306.58,60.06 300.86,60.06 300.67,59.87 298.08,59.87 297.14,58.93
  IN4 w0.508: v2(274.49,154.97) 273.35,156.11 264.65,156.11 263.76,157 242.84,157 241.05,158.78 241.05,162.93 239.11,164.87 239.11,167.77 238.07,168.81 235.85,168.81 235.58,168.55 229.04,168.55 226.2,171.38 v2(222.97,171.38) 220.1,171.38 218.94,172.53 216.31,172.53 214.58,170.81 209.96,170.81 207.7,168.54 207.7,167.65 205.05,165.01 205.05,163 204.54,162.49 203.69,162.49 203.06,161.85 200.97,161.85 199.41,160.29 196.55,160.29 195.49,159.23 195.49,157.83 194.73,157.07 194.73,151.85 197.37,149.21 197.54,149.03 197.54,148.57 197.87,148.24 197.87,144.49 197.71,144.32 197.71,126.92 197.79,126.84 197.79,124.23 195.14,121.59 195.14,119.24 195.53,118.86 195.53,116.89
  IN4 w1.016: 193.33,115.37 191.47,113.52 191.47,112.5 ; 199.92,67.22 198,69.14 193.17,69.14 190.75,71.56 190.75,79.02 190.07,79.7 190.07,81.13 190.97,82.03 190.97,99 190.25,99.71 190.25,103.31
  BOTTOM w0.356: CV1056.1 211.41,158.26 211.22,158.45 UX2.5 211.5,158.94 211.78,158.94 v2(211.96,159.12)
  BOTTOM w0.508: CV20.1 222.17,161.84 v2(221.64,162.37) ; RH181.1 215.24,47.02 v2(215.02,46.8) 214.89,46.68 RH603.1 RH182.1 RH180.1
  BOTTOM w2.54: 204.74,64.69 209.64,59.79
  vias: v2(194.27,116.3) v2(194.42,115.67) v2(194.88,115.26) v2(194.89,114.66) v2(195.18,115.78) v2(195.6,115.36) v2(200.68,66.86) v2(201.18,66.37) v2(201.67,66.78) v2(202.19,66.35) v2(202.61,65.9) v2(208.86,43.36) v2(221.43,49.39) v2(221.43,48.76) v2(222.07,49.41) v2(222.06,48.76) v2(222.67,48.75) v2(222.68,49.38)
+1.8VD_TBTA_LDO: length 2.6
  BOTTOM w0.254: 198.38,161.33 198.41,161.36 198.41,161.62 UT4.A2
  BOTTOM w0.508: 198.38,161.33 197.86,160.81 197.33,160.81 196.87,160.35 CT99.1
+1.8VS_AUDIO: length 316.4
  IN2 w0.508: v2(33.38,22.31) 33.38,21.99 34.55,20.82 34.55,18.09 34.62,18.02 v2(34.62,16.06)
  IN2 w1.016: 277.5,10.02 277.5,11.61 276.36,12.75 260.93,12.75 256.99,8.82 ; 229.18,6.02 230.51,7.36 252.74,7.36
  IN4 w1.016: 328.18,13.96 328.18,9.54 327.46,8.82 325.57,8.82 325.13,9.26 ; 318.78,10.85 314.4,10.85 312.11,13.14 312.11,14.98 ; 309.7,14.91 309.7,13.64 308.3,12.25 306.83,12.25 305.43,10.85 302.14,10.85 300.94,9.64 290.65,9.64 289.44,10.85 280.04,10.85 278.65,9.45 ; 52.65,14.67 49.02,18.3 44.52,18.3 41.03,21.8 41.03,27.5 41.66,28.13 41.66,32.52 40.85,33.33
  IN6 w1.016: 53.48,13.01 53.48,11.67 56.71,8.44 60.27,8.44 61.07,7.64 65.5,7.64 66.68,8.82 71.48,8.82 71.79,8.51 88.16,8.51 91.39,11.74 103.89,11.74 108.91,6.72 134.5,6.72 136.98,4.25 136.98,3.1 138.31,1.77 152.54,1.77 155.71,4.94 172.67,4.94 175.97,8.25 175.97,10.15 177.49,11.67 181.87,11.67 187.33,6.21 191.91,6.21 192.54,5.58 ; 201.3,4.94 201.37,4.88 226.89,4.88
  vias: v1(40.09,34.38) v2(34.11,22.41) v2(40.09,33.77) v2(40.6,34.14) v2(53.23,13.9) v2(53.83,13.91) v2(228.16,4.88) v2(228.67,5.2) v2(277.19,9.13) v2(277.77,9.13) v2(326.59,14.21) v2(327.17,14.21)
+1.8VSP:
  vias: v1(220.34,45.02)
+1.8VSP_AUDIO: length 1.5
  BOTTOM w0.102: v1(30.06,21.07) 30.3,20.83 31.49,20.83
+1.35VS_B+: length 23.9
  IN4 w0.508: v2(242.63,37.07) 243.49,36.21 243.49,33.54 242.79,32.84 242.79,32.12 243.3,31.61 247.01,31.61 248.86,29.77 256.95,29.77 v2(258.33,28.39)
  BOTTOM w0.508: PR8201.2 241.47,37.18 242.5,37.18 242.6,37.07 v2(242.63,37.07)
  vias: v1(258.7,32.87) v2(258.43,26.63) v2(258.43,26.05) v2(258.43,25.46) v2(259.01,26.63) v2(259.01,26.05) v2(259.01,25.46) v2(259.6,26.63) v2(259.6,26.05) v2(259.6,25.46)
+1.35VS_VGA: length 497.9
  IN1 w0.305: v2(194.63,83.25) v2(194.63,83.9)
  IN1 w0.381: v2(243.61,62.68) 243.64,62.71 v2(244.39,62.71) v2(245.19,62.71)
  IN1 w0.4: v2(201.03,80.85) v2(201.03,81.65) v2(201.83,81.65) ; v2(259.59,62.71) v2(259.59,61.91) ; v2(259.59,62.71) v2(260.39,62.71) v2(261.19,62.71) ; v2(259.59,62.71) v2(258.79,62.71) ; v2(194.63,80.05) v2(194.63,80.85) v2(193.83,80.85) ; v2(226.19,57.11) v2(226.79,57.11) ; v2(223.79,62.71) v2(224.59,62.71) ; v2(224.59,62.71) v2(224.59,61.91) ; v2(224.59,62.71) v2(225.39,62.71) v2(226.19,62.71) ; v2(261.79,57.11) v2(261.19,57.11) ; v2(276.15,81.36) v2(276.95,81.36) v2(277.75,81.36) ; v2(281.75,98.16) v2(280.95,97.36) ; v2(279.35,99.76) v2(279.35,100.36) ; v2(274.55,98.16) v2(274.55,98.96) v2(274.55,99.76) ; v2(274.55,98.16) v2(274.55,97.36) ; v2(274.55,98.16) v2(275.35,98.16) ; v2(226.19,55.51) v2(226.79,55.51) ; v2(196.23,83.9) v2(196.23,83.25) ; v2(242.79,59.51) 243.25,59.04 243.28,59.04 v2(243.6,58.72) ; v2(226.19,57.91) v2(226.79,57.91) ; v2(274.55,118.76) v2(274.55,117.96) v2(274.55,117.16) ; v2(224.59,55.51) v2(223.79,56.31) ; v2(274.55,83.76) v2(274.55,82.96) v2(274.55,82.16) ; v2(280.15,100.36) v2(280.15,99.76) ; 281.75,100.16 v2(281.75,99.76) ; v2(197.03,80.05) v2(196.23,79.25) ; v2(261.19,55.51) v2(261.79,55.51) ; v2(261.19,57.91) v2(261.79,57.91)
  IN1 w0.508: v2(281.75,100.36) 281.75,100.16
  IN6 w0.4: v2(252.39,59.51) v2(252.39,60.31) v2(252.39,61.11) v2(252.39,61.91) ; v2(280.95,107.56) v2(280.95,106.91) ; v2(273.75,109.16) v2(274.55,109.16) v2(274.55,109.96) ; v2(280.95,71.91) v2(280.95,72.56) ; v2(274.55,74.96) v2(274.55,74.16) v2(273.75,74.16) ; v2(201.03,73.65) v2(201.03,72.85) v2(201.03,72.05) ; v2(198.63,74.45) v2(199.43,74.45) v2(200.23,74.45) ; v2(217.39,59.51) v2(217.39,60.31) v2(217.39,61.11) v2(217.39,61.91) ; v2(274.55,90.16) v2(274.55,89.36) v2(274.55,88.56) ; v2(272.15,74.16) v2(272.15,74.96) ; v2(277.75,90.96) v2(276.95,90.96) 276.15,90.96 v2(276.13,90.95) 276.12,90.96 v2(275.35,90.96) ; v2(282.55,106.91) v2(282.55,107.56) ; v2(249.99,62.71) v2(250.79,62.71) v2(251.59,62.71) ; v2(197.03,73.65) v2(197.83,74.45) ; v2(282.55,71.91) v2(282.55,72.56) ; v2(214.99,62.71) v2(215.79,62.71) v2(216.59,62.71) v2(216.59,63.51) ; v2(279.35,107.56) v2(279.35,106.91) ; v2(279.35,71.91) v2(279.35,72.56)
  BOTTOM w0.25: UG9.K12 v2(226.97,89.15)
  BOTTOM w0.254: v2(194.63,91.05) 194.64,91.04 CG391.1 194.64,87.82 RG155.1 ; UG3.F1 v2(249.99,58.71) 250.39,59.11 ; v2(192.29,102.86) 192.33,102.9 v2(193.03,102.9) ; CG392.1 CG390.1 CG208.1
  BOTTOM w0.3: UG9.M43 v2(248.07,90.55) ; UG9.K41 v2(246.67,89.15) ; UG9.AJ43 v2(248.07,101.85) ; UG9.AK43 v2(248.07,103.15) ; UG9.AN43 v2(248.07,105.25) ; UG9.M10 v2(225.57,90.55) ; UG9.AM43 v2(248.07,103.95)
  BOTTOM w0.305: v2(281.75,111.56) UG2.R10 ; UG2.R10 v2(280.95,110.76) UG2.P11 ; UG2.R10 281.2,111.32 v2(280.95,111.56) ; UG6.D12 235.99,64.71 v2(236.39,65.11) UG6.D11 v2(237.18,64.32) UG6.E10 ; v2(241.19,55.51) 241.59,55.91 UG6.R5 ; UG5.D3 216.99,56.71 v2(217.39,56.31) ; UG6.L4 v2(242.79,59.51) UG6.K3 v2(242.79,60.31) ; UG4.T3 282.33,81.59 282.33,81.58 v2(282.55,81.36) ; RG132.1 227.47,58.59 v2(226.79,57.91) v2(226.19,57.91) 225.79,58.31 UG5.F14 ; UG7.K3 v2(200.23,99.85) 200.63,99.45 UG7.L4 ; UG6.T3 v2(243.59,54.71) ; UG6.L11 236.79,59.11 v2(237.19,58.71) ; v2(201.83,75.25) 202.23,75.65 UG8.E5 ; UG6.B14 234.19,66.31 v2(233.79,66.71) 233.3,66.71 233.18,66.59 CG172.1 ; UG2.E5 v2(273.75,115.56) ; UG6.G11 UG6.F12 ; UG6.F12 v2(235.59,63.51) ; UG6.F12 UG6.G13 UG6.H12 ; 200.63,92.25 v2(200.23,92.65) UG7.K12 ; 200.63,92.25 v2(201.03,92.65) 201.43,93.05 UG7.M12 v2(201.03,93.45) UG7.L11 ; 200.63,92.25 v2(201.03,91.85) 200.63,91.45 UG7.L14 v2(201.03,91.05) 201.43,91.45 UG7.M14 v2(201.83,91.05) ; 200.63,92.25 UG7.L13 ; UG5.T14 v2(226.19,66.71) 226.31,66.59 227.08,66.59 ; v2(271.35,80.56) 271.6,80.32 271.6,80.32 UG4.C5 ; UG6.L13 235,59.3 234.58,59.3 UG6.L14 234.27,58.99 234.27,58.43 UG6.M14 ; UG6.L13 235.55,58.75 v2(235.55,58.75) UG6.M12 v2(235.59,57.91) ; UG6.L13 UG6.K12 v2(236.39,60.31) ; UG5.P3 v2(217.39,64.31) ; UG2.B14 270.95,107.36 v2(270.95,107.36) v2(270.95,106.71) 270.85,106.61 CG102.1 ; UG3.P12 259.19,64.71 v2(258.79,65.11) UG3.P11 v2(257.99,64.31) UG3.N10 ; UG8.P3 v2(194.63,74.45) ; v2(279.35,111.56) UG2.N10 v2(280.15,110.76) UG2.P11 ; UG5.K3 v2(217.39,61.11) ; UG4.R10 281.75,76.56 v2(281.75,76.56) ; UG4.R10 v2(280.95,75.76) ; UG4.R10 v2(280.95,76.56) ; v2(274.81,72.33) 274.81,72.82 UG4.G14 ; v2(214.39,54.71) v2(214.99,54.71) UG5.B1 ; UG5.F1 v2(214.99,57.91) ; UG4.M14 v2(279.35,72.56) v2(279.35,71.91) 279.35,71.43 279.4,71.38 CG120.1 ; UG6.F14 234.21,63.11 v2(233.81,63.51) ; UG8.D12 v2(203.43,80.85) UG8.D11 v2(202.63,80.05) UG8.E10 202.23,79.65 v2(201.83,80.05) ; UG5.R10 v2(222.99,65.91) ; UG5.L2 v2(215.79,62.71) ; v2(252.39,61.11) 251.99,61.51 ; 251.99,61.51 v2(252.39,61.91) 252.59,62.12 UG3.L4 ; 251.99,61.51 UG3.K3 ; v2(281.75,74.96) UG4.T12 ; UG8.L13 UG8.K12 v2(198.63,80.85) ; UG8.L13 197.51,82.14 197.51,82.77 UG8.L14 v2(197.03,83.25) ; UG8.L13 v2(197.03,81.65) 196.63,81.25 UG8.M12 v2(196.23,81.65) ; v2(272.15,74.16) 272.55,74.56 UG4.D12 v2(272.15,74.96) UG4.D11 v2(272.95,75.76) UG4.E10 ; UG6.P1 v2(245.19,56.31) ; v2(194.63,83.25) UG8.P14 ; UG3.F3 252.16,58.48 v2(252.39,58.71) UG3.G4 v2(252.39,59.51) 251.99,59.91 ; UG8.F12 v2(201.83,81.65) ; UG8.F12 v2(201.03,80.85) UG8.G11 ; UG8.F12 201.43,81.25 v2(201.03,81.65) UG8.G13 v2(200.23,81.65) UG8.H12 ; v2(274.55,83.76) UG4.G1 v2(274.55,82.96) UG4.G2 v2(274.55,82.16) UG4.F3 ; UG1.G14 v2(278.55,99.76) ; CG277.1 193.32,84.9 193.03,84.61 v2(193.03,83.9) v2(193.03,83.25) UG8.T14 ; UG3.P14 v2(261.19,65.11) 262.36,66.28 CG280.1 ; UG7.C5 194.03,98.45 v2(193.83,98.25) ; UG4.F12 v2(274.55,74.16) 274.95,73.76 ; UG4.F12 v2(274.55,74.96) UG4.G11 ; UG4.F12 v2(273.75,74.16) ; v2(270.55,118.76) UG2.B1 ; UG7.H3 v2(197.83,99.85) 197.43,99.45 UG7.G4 v2(197.03,99.85) UG7.F3 ; v2(245.19,57.91) UG6.M1 ; UG7.R10 203.83,94.65 v2(204.23,94.25) ; UG8.R10 194.23,79.65 v2(194.63,80.05) UG8.P11 ; UG8.R10 194.63,79.25 v2(194.63,79.25) ; UG8.R10 v2(193.83,79.25) ; v2(216.59,63.51) UG5.M3 v2(216.59,62.71) ; v2(271.35,115.56) 271.54,115.37 271.54,115.37 UG2.C5 ; UG2.P11 v2(280.95,109.96) UG2.P12 ; UG2.E10 v2(272.95,110.76) 272.55,110.36 UG2.D11 272.55,110.36 v2(272.15,109.96) UG2.D12 v2(272.15,109.16) ; v2(242.79,56.31) 243.19,56.71 UG6.P3 ; UG1.D1 v2(280.95,88.56) v2(280.95,87.96) ; UG2.T12 282.01,109.7 v2(281.75,109.96) ; CG86.1 278.72,120.09 278.55,119.92 v2(278.55,119.41) v2(278.55,118.76) UG2.L1 278.1,118.32 278.1,118.2 278.07,118.16 278.07,117.76 278.1,117.72 278.1,117.61 UG2.L2 v2(278.55,117.16) UG2.M3 ; UG2.R5 v2(281.75,114.76) ; v2(281.75,90.16) 282.15,90.56 UG1.B3 ; UG7.G13 197.43,92.25 v2(197.03,92.65) 196.63,93.05 UG7.F12 v2(196.23,92.65) ; UG7.G13 197.55,92.13 197.55,91.57 UG7.G14 v2(197.03,91.05) 196.63,91.45 UG7.F14 v2(196.23,91.05) ; UG7.G13 UG7.H12 v2(198.63,93.45) ; v2(253.99,53.11) 254.33,52.77 CG282.1 ; UG6.C5 v2(241.99,65.91) ; v2(273.75,96.56) 273.75,96.56 UG1.N10 v2(272.95,96.56) 272.55,96.96 UG1.P11 v2(272.15,97.36) 272.55,97.76 UG1.P12 ; UG7.T3 204.81,100.43 204.81,100.44 v2(205.03,100.65) ; v2(271.33,81.38) 271.11,81.6 UG4.B3 ; UG4.N5 279.53,80.38 279.53,80.38 v2(279.35,80.56) ; v2(276.15,81.36) UG4.H3 v2(275.35,81.36) UG4.G4 ; UG4.P1 v2(280.95,83.76) v2(280.95,84.41) 280.95,84.92 281.05,85.02 CG118.1 ; UG1.T3 270.95,90.56 v2(271.35,90.16) ; CG80.1 283.54,86.73 282.91,87.36 282.91,87.6 v2(282.55,87.96) v2(282.55,88.56) UG1.B1 v2(281.75,89.36) ; UG7.D14 v2(194.63,91.05) ; UG2.B3 270.95,116.76 v2(271.35,116.36) ; UG5.M12 v2(224.59,62.71) 224.99,62.31 UG5.L13 ; v2(197.03,71.4) v2(197.03,72.05) UG8.L1 197.43,72.45 v2(197.03,72.85) UG8.L2 197.43,73.25 v2(197.03,73.65) 196.63,74.05 UG8.M3 ; UG8.B3 v2(204.23,74.45) ; v2(204.23,93.45) 204.38,93.3 UG7.T12 ; UG8.D1 v2(203.43,72.05) ; 202.94,84.45 202.94,83.54 v2(203.03,83.45) UG8.D14 ; UG6.F3 v2(243.61,62.68) 243.99,62.31 UG6.G2 v2(244.39,62.71) UG6.G1 v2(245.19,62.71) ; UG8.P11 v2(195.43,80.05) UG8.N10 196.23,79.25 v2(196.23,79.25) ; UG8.P11 v2(194.63,80.85) UG8.P12 ; UG7.R5 v2(204.23,99.05) ; UG6.D14 234.19,64.71 v2(233.79,65.11) 233.3,65.11 233.01,64.81 CG155.1 ; UG7.G11 197.03,94.25 v2(197.03,94.25) ; UG3.R5 v2(253.19,65.91) ; v2(197.03,102.25) UG7.G1 v2(197.03,101.45) UG7.G2 ; UG6.D3 v2(243.59,64.31) ; v2(225.39,62.71) 225.79,62.31 UG5.L14 ; v2(273.75,91.76) 273.75,91.76 UG1.N5 ; UG6.C10 v2(237.19,65.91) ; UG1.L13 v2(274.55,98.96) UG1.L14 v2(274.55,99.76) ; UG1.L13 v2(275.35,98.16) UG1.K12 ; UG1.L13 v2(274.55,98.16) UG1.M12 v2(274.55,97.36) UG1.L11 ; UG5.N10 v2(222.99,64.31) UG5.P11 v2(223.79,65.11) 224.19,64.71 UG5.P12 ; v2(222.19,55.51) 222.59,55.91 UG5.C10 ; v2(193.03,73.65) 193.43,74.05 UG8.T3 ; UG6.G4 UG6.H3 v2(242.79,61.11) ; UG5.T1 215.28,66.42 v2(214.99,66.71) ; v2(278.55,84.41) v2(278.55,83.76) UG4.L1 ; v2(198.63,74.45) UG8.K3 v2(197.83,74.45) 197.43,74.85 UG8.L4 ; 274.95,73.76 UG4.G13 ; 274.95,73.76 v2(275.35,74.16) UG4.H12 ; UG6.P14 234.39,56.71 v2(233.99,56.31) ; UG2.M14 v2(279.35,107.56) v2(279.35,106.91) ; UG5.B14 v2(226.19,55.51) v2(226.79,55.51) ; v2(194.63,71.4) v2(194.63,72.05) UG8.P1 ; 250.39,59.11 UG3.G1 UG3.G2 ; UG3.T12 v2(259.59,66.71) ; UG4.D14 272.55,72.36 v2(272.55,72.36) 272.55,71.88 272.31,71.64 CG121.1 ; UG8.B14 204.63,83.45 v2(204.63,83.45) 204.63,84.58 205.23,85.18 CG208.1 ; UG8.F1 v2(201.83,72.05) ; UG7.M1 v2(201.43,102.45) ; UG5.L11 v2(223.79,62.71) ; UG6.P11 v2(236.39,56.31) 235.99,56.71 UG6.P12 ; UG6.P11 UG6.R10 ; UG6.P11 v2(237.19,57.11) UG6.N10 v2(237.99,57.91) ; UG1.D11 v2(280.95,97.36) UG1.D12 ; UG6.G14 234.21,62.31 v2(233.81,62.71) ; v2(235.59,66.71) UG6.B12 ; UG1.F3 v2(278.55,90.96) UG1.G4 v2(277.75,90.96) UG1.H3 v2(276.95,90.96) ; UG2.P14 v2(280.95,107.56) v2(280.95,106.91) 280.95,106.43 280.93,106.41 CG98.1 ; v2(271.35,91.76) 271.53,91.94 271.53,91.94 UG1.R5 ; v2(257.04,57.51) UG3.E10 v2(257.99,57.11) UG3.D11 v2(258.79,56.31) 259.04,56.56 UG3.D12 ; CG101.1 281.36,119.83 v2(280.95,119.41) v2(280.95,118.76) UG2.P1 ; UG5.D11 v2(223.79,56.31) 224.19,56.71 UG5.D12 ; UG7.B12 193.43,93.05 v2(193.83,92.65) ; UG2.T1 v2(282.55,118.76) v2(282.55,119.41) 283.14,120 CG103.1 ; UG3.D14 v2(261.19,57.11) v2(261.79,57.11) 262.42,57.11 262.52,57.01 CG268.1 ; UG2.T3 v2(282.55,117.16) ; UG6.B3 v2(242.79,65.91) ; v2(218.99,55.51) 218.59,55.91 UG5.C5 ; UG5.G14 225.67,59.23 225.11,59.23 UG5.G13 ; UG4.L11 v2(278.55,75.76) ; CG85.1 280.16,101.12 280.15,101.11 v2(280.15,100.36) v2(280.15,99.76) UG1.D14 ; UG7.P14 v2(203.43,91.05) ; UG8.F3 201.43,74.05 v2(201.03,73.65) 200.63,73.25 UG8.G2 v2(201.03,72.85) 200.63,72.45 UG8.G1 v2(201.03,72.05) ; UG8.T1 v2(193.03,72.05) v2(193.03,71.4) 193.03,70.9 192.97,70.84 CG274.1 ; v2(223.79,58.71) UG5.F12 v2(224.59,58.71) 224.99,59.11 UG5.G13 ; UG3.G11 258.39,59.11 v2(257.99,58.71) ; UG7.E10 v2(195.83,95.2) ; v2(245.19,58.71) UG6.L1 v2(244.39,58.71) UG6.L2 243.99,59.11 v2(243.6,58.72) UG6.M3 ; v2(276.95,109.96) UG2.K12 UG2.L13 v2(278.55,109.16) UG2.M12 v2(279.35,109.16) ; UG1.M14 v2(273.75,99.76) ; UG2.F1 273.96,118.55 v2(273.75,118.76) ; CG279.1 261.78,67.3 v2(261.19,66.71) UG3.T14 ; UG4.L4 v2(277.75,81.36) UG4.K3 v2(276.95,81.36) ; UG2.G4 275.35,116.36 v2(275.35,116.36) UG2.H3 v2(276.15,116.36) ; UG3.B14 260.96,55.28 260.96,55.28 v2(261.19,55.51) v2(261.79,55.51) 261.93,55.51 262.84,54.6 CG226.1 ; v2(274.55,88.56) UG1.L1 274.95,88.96 v2(274.55,89.36) ; CG87.1 270.66,100.35 270.55,100.24 v2(270.55,99.76) UG1.T14 ; UG3.B1 v2(249.99,54.71) v2(249.39,54.71) 248.88,54.71 248.66,54.93 CG136.1 ; UG6.R10 v2(237.99,56.31) ; UG6.R10 237.59,55.91 v2(237.99,55.51) ; UG1.P3 v2(272.95,90.96) ; UG8.D3 v2(202.63,73.65) ; v2(274.55,89.36) UG1.L2 274.95,89.76 v2(274.55,90.16) UG1.M3 274.15,90.56 v2(273.75,90.16) ; v2(274.55,89.36) 274.15,88.96 UG1.M1 274.15,88.96 v2(273.75,88.56) ; UG2.M1 v2(279.35,118.76) v2(279.35,119.41) 279.59,119.65 CG100.1 ; UG4.R5 281.53,79.98 v2(281.75,79.76) ; CG382.1 231.78,57.03 CG278.1 232.51,56.19 v2(233.99,54.71) 234.39,55.11 UG6.T14 ; UG5.K12 v2(224.59,61.91) ; UG5.T12 v2(224.59,66.71) ; UG3.L11 v2(258.79,62.71) UG3.M12 v2(259.59,62.71) 259.99,62.31 UG3.L13 v2(260.39,62.71) 260.79,62.31 UG3.L14 v2(261.19,62.71) ; UG4.K12 v2(276.95,74.96) ; v2(196.23,102.9) v2(196.23,102.25) UG7.F1 ; v2(205.03,72.05) UG8.B1 ; UG5.G2 v2(215.79,58.71) 215.39,59.11 UG5.G1 v2(214.99,58.71) ; v2(280.95,81.36) 280.68,81.63 280.68,81.63 UG4.P3 ; v2(202.63,99.85) 202.8,100.03 UG7.P3 ; v2(195.43,102.25) v2(195.43,102.9) ; v2(196.23,75.25) 195.83,75.65 UG8.N5 ; UG1.P1 v2(272.15,88.56) ; v2(245.19,63.51) UG6.F1 ; v2(273.75,80.56) 273.54,80.35 UG4.E5 ; v2(279.35,76.56) UG4.N10 v2(280.15,75.76) UG4.P11 v2(280.95,74.96) UG4.P12 ; UG4.M3 v2(278.55,82.16) UG4.L2 v2(278.55,82.96) ; v2(250.79,62.71) UG3.L2 251.19,62.31 v2(251.59,62.71) UG3.M3 v2(251.59,63.51) ; UG4.T1 v2(282.55,83.76) v2(282.55,84.41) ; UG2.L11 v2(278.55,110.76) ; v2(214.99,63.51) UG5.M1 ; v2(281.75,100.36) v2(281.75,99.76) 281.95,99.56 281.95,99.56 UG1.B14 ; CG82.1 278.55,86.65 v2(278.55,87.96) v2(278.55,88.56) UG1.G1 278.15,88.96 v2(278.55,89.36) UG1.G2 ; v2(249.99,58.71) v2(249.39,58.71) 249.23,58.87 248.83,58.87 248.64,59.06 CG126.1 ; UG7.B14 v2(193.03,91.05) ; v2(193.03,102.9) v2(193.03,102.25) UG7.B1 ; CG134.1 248.95,55.87 v2(249.39,56.31) v2(249.99,56.31) 250.39,56.71 UG3.D1 ; UG3.C5 253.59,55.91 v2(253.99,55.51) ; UG5.G11 v2(222.99,58.71) ; UG5.B3 v2(217.39,55.51) ; UG1.R10 v2(271.35,96.56) ; UG3.L1 v2(249.99,62.71) ; UG7.P1 v2(203.03,102.45) ; UG5.N5 v2(218.19,63.51) ; UG5.E10 v2(222.04,57.51) ; v2(253.99,57.91) UG3.E5 ; UG6.B1 v2(245.19,66.71) ; UG5.L4 v2(217.39,61.91) ; UG8.L11 v2(197.03,80.05) ; CG207.1 204.97,89.68 205.03,89.73 v2(205.03,91.05) UG7.T14 ; UG3.P1 v2(249.99,65.11) ; UG3.M14 v2(261.19,63.51) ; UG2.N5 279.54,115.37 279.54,115.37 v2(279.35,115.56) ; UG5.G13 UG5.H12 ; UG1.F1 v2(279.35,88.56) v2(279.35,87.96) 279.35,87.45 279.4,87.41 CG104.1 ; UG2.C10 271.56,110.97 v2(271.35,110.76) ; UG7.N5 201.83,99.05 v2(201.83,99.05) ; CG88.1 272.63,106.04 272.55,106.11 v2(272.55,106.71) v2(272.55,107.36) 272.55,107.36 UG2.D14 ; v2(272.95,82.16) 272.75,81.96 272.75,81.96 UG4.D3 ; v2(279.35,74.16) UG4.M12 v2(278.55,74.16) 278.15,73.76 UG4.L13 278.03,73.64 278.03,73.08 UG4.L14 v2(278.55,72.56) ; v2(258.78,58.72) UG3.F12 v2(259.59,58.71) 259.99,59.11 UG3.G13 ; UG2.G11 v2(274.55,109.96) ; UG2.L4 v2(277.75,116.36) UG2.K3 v2(276.95,116.36) ; v2(272.15,118.76) UG2.D1 ; UG5.L1 v2(214.99,62.71) ; v2(245.19,65.11) UG6.D1 ; UG3.M1 v2(249.99,63.51) ; v2(276.95,97.36) UG1.H12 UG1.G13 v2(278.55,98.16) UG1.F12 v2(279.35,98.16) ; UG4.C10 v2(271.35,75.76) ; v2(204.23,91.05) 204.23,90.57 204.11,90.45 CG209.1 ; UG4.B14 270.95,72.36 v2(270.95,72.36) 270.53,71.94 CG122.1 ; UG3.K12 v2(259.59,61.91) ; UG1.T1 v2(270.55,88.56) ; v2(250.78,53.11) 251.09,52.81 CG132.1 ; v2(270.55,74.16) 270.95,74.56 UG4.B12 ; UG2.F3 v2(274.55,117.16) UG2.G2 v2(274.55,117.96) UG2.G1 v2(274.55,118.76) ; RG121.1 CG123.1 262.47,58.59 ; v2(214.38,56.44) 214.52,56.31 v2(214.99,56.31) UG5.D1 ; v2(280.95,116.36) 280.74,116.57 UG2.P3 ; UG8.F14 v2(201.43,83.45) ; UG8.B12 v2(204.23,80.85) ; UG6.N5 v2(241.99,57.91) ; UG8.R5 v2(193.83,76.05) ; UG8.T12 v2(193.83,80.85) ; UG3.B12 259.19,55.11 v2(258.79,54.71) ; CG224.1 282.27,71.05 282.55,71.33 v2(282.55,71.91) v2(282.55,72.56) UG4.T14 ; 262.47,58.59 v2(261.79,57.91) v2(261.19,57.91) 260.79,58.31 UG3.F14 ; 262.47,58.59 261.79,58.59 261.67,58.71 v2(261.19,58.71) 260.79,59.11 UG3.G14 260.67,59.23 260.11,59.23 UG3.G13 ; UG1.F14 v2(279.35,99.76) v2(279.35,100.36) 278.66,101.05 CG84.1 RG110.1 ; UG8.M14 v2(196.23,83.25) v2(196.23,83.9) 196.23,84.56 196.17,84.61 CG203.1 ; UG7.N10 v2(202.63,94.25) UG7.P11 v2(203.43,93.45) UG7.P12 203.03,93.05 v2(202.63,92.65) ; v2(258.79,60.31) UG3.H12 UG3.G13 ; v2(257.19,55.51) 257.59,55.91 UG3.C10 ; UG7.D12 v2(194.63,93.45) UG7.D11 ; v2(252.39,55.51) UG3.B3 ; UG1.L4 v2(275.35,90.96) 275.35,90.96 UG1.K3 v2(276.13,90.95) ; v2(273.75,109.16) UG2.F12 v2(274.55,109.16) UG2.G13 v2(275.35,109.16) UG2.H12 ; CG119.1 279.27,85 279.35,84.92 v2(279.35,84.41) v2(279.35,83.76) UG4.M1 ; v2(252.39,60.31) 251.99,59.91 ; 251.99,59.91 UG3.H3 ; v2(272.15,83.76) 272.38,83.54 UG4.D1 ; UG2.L14 v2(278.55,107.56) v2(278.55,106.91) ; UG5.T3 v2(216.59,66.71) ; UG6.E5 v2(241.99,63.51) ; v2(216.59,57.91) UG5.F3 v2(217.39,58.71) UG5.G4 217.79,59.11 v2(217.39,59.51) UG5.H3 ; UG7.B3 v2(193.83,99.85) ; UG8.G14 v2(200.63,83.45) ; UG1.B12 v2(281.75,98.16) ; v2(249.99,66.71) UG3.T1 ; v2(270.55,83.76) 270.8,83.52 UG4.B1 ; UG5.B12 v2(224.59,55.51) ; UG3.R10 v2(257.99,65.91) ; UG6.T1 v2(245.19,54.71) ; UG1.C10 v2(281.75,95.76) ; v2(274.95,107.36) 274.95,107.96 UG2.G14 ; UG7.D3 v2(194.63,99.85) ; UG8.M1 v2(196.23,72.05) v2(196.23,71.4) 196.23,70.9 196.36,70.76 CG285.1 ; CG83.1 272.44,100.53 272.15,100.24 v2(272.15,99.76) UG1.P14 ; UG2.D3 272.55,116.76 v2(272.95,117.16) ; UG5.M14 v2(226.19,63.51) ; v2(218.99,57.91) UG5.E5 ; v2(280.95,71.91) v2(280.95,72.56) 280.76,72.75 UG4.P14 ; UG5.P14 v2(226.19,65.11) ; UG7.T1 v2(204.63,102.45) ; UG8.C5 v2(204.23,75.25) ; v2(201.83,100.65) UG7.M3 201.43,100.25 v2(201.03,100.65) UG7.L2 v2(201.03,101.45) UG7.L1 200.63,102.17 200.83,102.38 v2(200.83,102.46) ; UG1.T12 v2(270.55,98.16) ; UG5.R5 v2(218.19,65.91) ; UG4.F1 v2(273.75,83.76) ; UG8.C10 v2(204.23,80.05) ; v2(252.39,64.31) UG3.P3 ; UG1.D3 v2(280.95,90.96) ; UG3.N5 v2(253.19,63.51) ; UG3.T3 v2(251.59,66.71) ; v2(282.55,106.91) v2(282.55,107.56) UG2.T14 ; CG266.1 227.3,57.08 227.27,57.11 v2(226.79,57.11) v2(226.19,57.11) UG5.D14 ; UG1.E5 v2(279.35,92.56) ; UG4.F14 v2(274.15,72.36) ; v2(252.39,56.31) 251.99,56.71 UG3.D3 ; UG5.P1 v2(214.99,65.11) ; v2(270.55,109.16) 270.78,109.39 UG2.B12 ; UG7.C10 v2(193.83,95.05) ; v2(274.15,107.36) 274.15,107.96 UG2.F14 ; v2(200.23,74.45) 200.63,74.85 UG8.G4 ; v2(194.69,102.89) 194.63,102.83 v2(194.63,102.25) UG7.D1 ; UG1.E10 v2(279.75,95.61) ; UG1.C5 v2(281.75,92.56) ; UG8.H3 v2(199.43,74.45) ; v2(236.39,55.51) UG6.T12 ; UG7.E5 v2(196.23,98.25) ; UG1.G11 v2(278.55,96.56)
  BOTTOM w0.381: v2(196.23,102.9) 196.23,104.06 CG287.1 ; CG220.1 270.66,102.43 CG87.1 ; v2(284.29,113.78) CG81.1 ; CG83.1 272.44,102.68 CG117.1 ; 227.08,66.59 228.15,66.59 CG219.1 229.18,66.67 CG368.1 ; CG243.1 202.94,85.28 202.94,84.45 ; CG271.1 v2(247.21,52.95) ; v2(284.45,117.53) CG97.1 ; CG283.1 204.11,88.18 CG209.1
  BOTTOM w0.508: v2(245.17,52.76) CG273.1 ; CG222.1 236.36,52.44 v2(236.99,53.08) ; v2(259.41,53.27) 259.66,53.01 259.66,52.19 CG133.1 CG228.1 ; CG221.1 v2(284.22,111.37) ; CG284.1 193.67,104.17 193.03,103.52 v2(193.03,102.9) ; v2(224.3,53.11) 224.24,53.05 CG286.1 ; v2(190.94,80.05) 190.57,79.69 CG276.1 ; CG116.1 285.25,73.78 v2(285.99,73.78) ; CG225.1 285.12,81.21 v2(284.81,80.89) 284.81,80.57 CG281.1 ; v2(235.37,53.11) 235.16,52.9 CG160.1 ; CG383.1 232,64.71 CG155.1 ; CG115.1 284.33,76.95 283.94,76.56 v2(283.35,76.56) ; CG227.1 v2(257.31,53.08) ; v2(241.5,52.95) 242.2,52.25 CG223.1 ; v2(219.7,52.33) 219.49,52.12 CG161.1 ; v2(244.24,52.76) CG159.1
  vias: v2(192.23,95.05) v2(192.23,92.65) v2(202.38,69.3) v2(203.59,69.33) v2(204.47,69.31) v2(205.09,69.32) v2(205.83,80.05) v2(214.39,58.71) v2(214.39,53.91) v2(222.99,67.51) v2(223.79,60.31) v2(225.57,103.15) v2(225.57,101.85) v2(225.57,101.05) v2(225.57,99.75) v2(225.57,98.95) v2(225.57,97.65) v2(225.57,96.85) v2(225.57,95.55) v2(225.57,94.75) v2(225.57,93.45) v2(225.57,92.65) v2(225.57,91.35) v2(226.32,103.1) v2(226.32,101.9) v2(226.32,101) v2(226.32,98.9) v2(226.32,97.7) v2(226.32,96.8) v2(226.32,95.6) v2(226.32,93.5) v2(226.32,92.6) v2(226.32,91.4) v2(227.72,90) v2(227.77,89.15) v2(229.07,89.15) v2(229.87,89.15) v2(231.12,89.9) v2(231.17,89.15) v2(231.97,89.15) v2(233.27,89.15) v2(234.12,89.9) v2(234.07,89.15) v2(235.37,89.15) v2(236.17,89.15) v2(236.37,89.96) v2(237.19,67.51) v2(237.42,89.9) v2(237.47,89.15) v2(238.27,89.15) v2(239.57,89.15) v2(240.37,89.15) v2(240.42,89.9) v2(241.62,89.9) v2(241.67,89.15) v2(242.47,89.15) v2(243.72,89.9) v2(243.77,89.15) v2(244.57,89.15) v2(245.82,89.9) v2(245.87,89.15) v2(247.32,106.1) v2(247.32,104) v2(247.32,103.1) v2(247.32,101.9) v2(247.32,101) v2(247.32,98.9) v2(247.32,97.7) v2(247.32,96.8) v2(247.32,95.6) v2(247.32,94.7) v2(247.32,92.6) v2(247.32,91.4) v2(248.07,106.05) v2(248.07,101.05) v2(248.07,99.75) v2(248.07,98.95) v2(248.07,97.65) v2(248.07,96.85) v2(248.07,95.55) v2(248.07,94.75) v2(248.07,93.45) v2(248.07,92.65) v2(248.07,91.35) v2(257.99,67.51) v2(261.63,50.07) v2(261.63,49.46) v2(261.63,48.82) v2(261.63,48.19) v2(262.26,50.07) v2(262.26,49.46) v2(262.26,48.82) v2(262.26,48.19) v2(262.9,50.07) v2(262.9,49.46) v2(262.9,48.82) v2(262.9,48.19) v2(263.53,50.07) v2(263.53,49.46) v2(263.53,48.82) v2(263.53,48.19) v2(264.17,50.07) v2(264.17,49.46) v2(264.17,48.82) v2(264.17,48.19) v2(264.8,50.07) v2(264.8,49.46) v2(264.8,48.82) v2(264.8,48.19) v2(265.44,50.07) v2(265.44,49.46) v2(265.44,48.82) v2(265.44,48.19) v2(266.07,50.07) v2(266.07,49.46) v2(266.07,48.82) v2(266.07,48.19) v2(266.71,50.07) v2(266.71,49.46) v2(266.71,48.82) v2(266.71,48.19) v2(267.34,50.07) v2(267.34,49.46) v2(267.34,48.82) v2(267.34,48.19) v2(267.98,50.07) v2(267.98,49.46) v2(267.98,48.82) v2(267.98,48.19) v2(268.61,50.07) v2(268.61,49.46) v2(268.61,48.82) v2(268.61,48.19) v2(269.25,50.07) v2(269.25,49.46) v2(269.25,48.82) v2(269.25,48.19) v2(269.75,96.56) v2(269.75,86.16) v2(269.88,50.07) v2(269.88,49.46) v2(269.88,48.82) v2(269.88,48.19) v2(270.52,50.07) v2(270.52,49.46) v2(270.52,48.82) v2(270.52,48.19) v2(270.65,64.32) v2(270.65,63.68) v2(270.65,63.05) v2(270.65,62.41) v2(271.05,86.16) v2(272.51,86.16) v2(275.6,106.21) v3(256.73,48.95)
+1.35VS_VGA_PGOOD: length 203.7
  TOP w0.381: v1(240.72,50.63) 241.54,49.81 v2(245.02,49.81) 245.98,49.81 246.8,50.63 248.13,50.63 250.01,48.75 250.01,44.85 246.77,41.61 246.77,37.73 v2(245.98,36.95)
  TOP w0.508: v2(280.69,146.7) 280.69,146.52 280.33,146.17 280.28,146.17 279.75,145.63 279.73,145.63 279.39,145.29 UG29.1
  IN1 w0.508: v2(280.69,146.7) 280.69,147.03 280.33,147.39 280.23,147.39 280.16,147.46 v2(276.37,147.46) 275.73,147.46 274.46,146.19 271.48,146.19 270.46,145.16 270.46,143.83 272.41,141.88 272.41,140.22 273.27,139.35 273.27,137.75 274.7,136.33 276.37,136.33 277.84,134.85 283.19,134.85 287.98,130.06 287.98,97.55 288.81,95.04 289.42,93.46 294.43,83.29 294.43,75.44 v2(297.88,71.99)
  IN3 w0.508: v2(297.88,71.99) 297.88,64.9 296.11,63.14 296.11,53.73 293.38,51.01 288.86,51.01 288.52,50.67 280.27,50.67 280.06,50.88 278.9,50.88 278.25,51.53 275.34,51.53 274.17,52.7 262.86,52.7 261.99,51.82 246.32,51.82 245.02,50.52 v2(245.02,49.81)
  BOTTOM w0.203: PU8200.13 244.73,36.74 244.69,36.78 244.69,37.9 PR8203.1
  BOTTOM w0.254: v2(245.98,36.95) 245.98,37.05 245.75,37.29 245.75,37.45 PR8203.1
+1.35VS_VGAP: length 25.3
  TOP w0.508: v2(244.12,39.73) 244.12,39.73 244.24,39.61 PC8218.1
  IN2 w0.254: v2(266.01,41.08) 264.73,42.36 246.58,42.36 244.12,39.9 v2(244.12,39.73)
  BOTTOM w0.203: PR8209.2 244.1,39.72 v2(244.12,39.73)
  vias: v1(270.32,44.47)
+1V8_AON: length 543
  TOP w0.254: QG511.2 311.25,54.64 v2(311.77,55.16) ; v2(244.99,39.74) 244.99,38.58 244.63,38.23 242.96,38.23 242.08,39.11 235.66,39.11 233.3,41.46 233.3,49.55 231.75,51.11 225.51,51.11 224.58,50.18 219.99,50.18 219.15,49.34 v2(219.15,48.82) ; CG479.1 280.29,163.07 UG28.5 280.29,161.05 279.55,160.32 279.55,158.69 v2(279.03,158.18) 278.96,158.25 278.22,158.25 277.92,157.95 277.92,157.24 277.64,156.96 CG478.1 277.07,156.67 UG26.5
  TOP w0.356: UG29.5 280.42,145.34 281,145.91 CG483.1 281.46,146.17 281.46,146.53 v2(281.59,146.66) ; RG16.2 222.87,113.27 RG503.2 ; UG22.5 215.32,160.16 v2(215.9,160.73) 215.71,160.93 CG246.1 ; RG516.1 211.73,160.72 211.64,160.81 211.63,160.81 211.45,160.99 211.45,161 211.38,161.08 v2(211.38,161.19)
  TOP w0.381: v2(218.56,114.34) 218.79,114.57 RG504.2 ; v2(223.84,113.15) 222.99,113.15 RG503.2 ; UG27.5 314.05,62.38 CG476.1 314.75,62.12 v2(315.11,62.47) ; v2(224.97,110.85) 226.52,110.85 226.75,110.62 CG291.1 227.54,110.62 v2(227.82,110.9) 227.9,110.98 227.9,111.52 v2(227.77,111.65)
  TOP w0.457: RG85.2 199.65,111.97 v2(199.42,111.73)
  TOP w0.508: v2(193.48,112.36) 193.21,112.63 192.45,112.63 RG510.1 ; RG581.1 216.23,155.94 v2(215.74,155.45) ; 202.52,111.37 202.59,111.31 202.97,111.31 203.01,111.35 203.44,111.35 v2(203.46,111.37) 203.53,111.31 RG78.2 ; 202.52,111.37 202.52,111.72 202.56,111.76 202.56,111.8 202.84,112.08 RG82.2 202.97,112.32 204.21,112.32 RG79.2 ; 202.52,111.37 RG81.2 ; RG83.2 217.88,114.85 218.39,114.34 v2(218.56,114.34) ; v2(221.38,160.76) 221.04,160.76 220.56,160.28 RX5.1 220.56,159.1 v3(219.46,158) 219.33,157.86 v2(219.33,157.41)
  IN1 w0.508: v2(279.03,158.18) 276.96,156.1 274.31,156.1 273.55,155.34 271.29,155.34 270.57,156.06 265.31,156.06 264.29,157.08 246.64,157.08 244.87,158.85 v2(243.66,158.85) ; v2(215.74,155.45) 215.74,156.85 v2(214.58,158.02) 214.58,158.04 215.27,158.74 217.9,158.74 ; v2(215.44,163.84) 215.45,163.83 215.45,161.18 v2(215.9,160.73) 217.05,160.73 217.9,159.88 217.9,158.74 ; 217.9,158.74 218.7,158.74 219.33,158.12 v2(219.33,157.41)
  IN2 w0.254: v2(311.77,55.16) 311.77,56.47 313.58,58.28 313.58,60.95 v2(315.11,62.47) ; v2(244.99,39.74) 244.99,40.23 246.73,41.98 264.43,41.98 265.81,40.59 266.96,40.59 273.05,34.51 273.05,33.71 273.75,33.01 274.8,33.01 275.93,31.88 279.32,31.88 283.13,28.07 288.18,28.07 293.22,23.03 297.06,23.03 297.47,23.43 298.51,23.43 299.19,22.75 300.84,22.75 300.93,22.85 300.98,22.85 302.32,24.18 302.38,24.18 302.38,24.18 303.83,24.18 306.01,24.18 306.73,24.9 v2(306.73,25.05)
  IN2 w0.508: v2(211.38,161.19) 212.29,162.11 214.52,162.11 v2(215.9,160.73) ; v2(208.14,125.88) 207.91,126.11 208.03,126.24 208.03,130.07 207.95,130.16 207.95,130.66 208.03,130.75 208.03,142.19 213.42,147.58 215.27,147.58 216.58,148.89 216.58,150.89 214.7,152.77 211.92,152.77 211.25,153.45 211.25,154.06 211.74,154.55 214.84,154.55 v2(215.74,155.45)
  IN4 w0.254: v2(219.15,48.82) 219.15,49.27 218.18,50.23 216.31,50.23 215.71,50.83 214.41,50.83 212.38,52.87 212.38,56.12 210.02,58.48 210.02,63.4 210.45,63.83 210.45,104.17 208.3,106.32 208.3,109.95 v2(208.66,110.3) ; v2(306.73,25.05) 306.74,25.05 307.97,25.05 310.9,27.99 318.14,27.99 319.86,29.71 327.11,29.71 328.27,30.87 328.34,30.87 329.7,32.22 331.82,32.22 335.65,36.06 335.65,44.59 332.24,48 332.24,48.34 331.58,49 322.09,49 320.37,50.73 320.37,53.01 320.86,53.51 320.86,59.06 318.26,61.66 315.57,61.66 315.11,62.12 v2(315.11,62.47)
  IN4 w0.508: 234.77,121.38 234.77,121.19 232.55,118.96 230.67,118.96 228.47,116.77 228.47,112.88 227.97,112.39 227.97,112.22 ; v2(281.59,146.66) 281.53,146.73 281.53,147.05 281.46,147.11 281.46,154.49 278.96,156.99 278.96,158.11 v2(279.03,158.18)
  IN6 w0.254: v2(184.92,53.84) 184.92,54.8 186.63,56.51 187.06,56.51 187.37,56.82 187.77,56.82 187.92,56.67 188.76,56.67 189,56.43 193.19,56.43 194.84,58.08 194.88,58.31 194.95,58.47 195.12,58.87 195.18,58.97 195.46,59.38 195.89,59.81 196.18,60 196.4,60.15 196.66,60.26 196.77,60.31 196.8,60.36 197.01,60.58 199.18,60.58 201.16,58.59 201.24,58.51 203.73,58.51 203.73,58.51 204.54,58.51 204.57,58.48 204.87,58.48 204.99,58.6 206.09,58.6 206.78,57.91 208.63,57.91 210.58,55.96 210.58,54.74 210.59,54.73 210.59,54.22 213.68,51.12 216.03,51.12 216.36,50.8 216.64,50.51 217.24,50.51 217.34,50.41 217.81,50.41 219.15,49.08 v2(219.15,48.82)
  IN6 w0.508: v2(200.92,109.72) 201.18,109.72 201.68,109.21 201.68,108.51 200.71,107.53 198.99,107.53 198.07,106.61 198.07,106.1 v2(198.21,105.96) ; v2(243.66,158.85) 241.2,158.85 237.65,162.4 235.15,162.4 234.65,161.9 232.58,161.9 230.26,159.58 226.4,159.58 223.16,156.34 216.63,156.34 v2(215.74,155.45)
  BOTTOM w0.25: v2(227.82,110.9) 227.82,111 UG9.BB14 ; UG9.BC14 v2(227.77,111.65)
  BOTTOM w0.254: RG574.2 RG573.2 185.37,54.28 v2(184.92,53.84) ; PR8203.2 244.99,39.73 v2(244.99,39.74)
  BOTTOM w0.3: UG9.BA10 v2(224.97,110.85)
  BOTTOM w0.305: RG530.1 207.77,126.25 v2(208.14,125.88)
  BOTTOM w0.356: 198.54,125.33 RG9.2 ; 198.54,125.33 198.54,125.39 198.93,125.78 v2(199.12,125.78) ; 198.54,125.33 RG13.2 ; RG502.1 211.91,124.9 v2(211.65,124.64) ; v2(198.21,105.96) 198.12,105.87 CG1.1 ; UG10.5 200.56,121.65 200.97,121.24 RG14.2 201.55,120.83 v2(201.58,120.87) ; RG21.2 196.67,120.74 v2(196.6,120.8) 196.6,120.93 196.25,121.29 RG522.2
  BOTTOM w0.381: v2(221.38,160.76) 220.84,160.76 220.76,160.68 219.76,160.68 RV648.1 ; RG2.2 v2(235.3,122.08) ; RG8.2 215.73,113.53 215.64,113.44 215.14,113.44 214.85,113.15 214.13,113.15 v2(214.02,113.04) 213.78,112.8 RG15.2
  BOTTOM w0.457: v2(210.51,121.72) 210.2,121.72 210.18,121.7 209.93,121.7 RG19.2
  BOTTOM w0.508: v2(214.58,158.02) 214.58,158.04 214.7,158.17 214.7,158.46 RX7.1 ; v2(215.44,163.84) 215.13,164.15 214.32,164.15 213.81,163.64 RV652.1 ; RG20.2 206.82,119.76 207.27,119.31 v2(207.28,119.31) ; v2(212.23,108.02) 211.83,107.62 CG66.1 UG13.3 ; v2(212.86,116.59) 212.62,116.35 RG147.1 ; v2(200.92,109.72) 201.32,110.11 RG84.2 ; RG80.2 v2(214.13,117.34) ; v2(207.34,123.03) 207.73,122.63 RG11.1 RG12.1 ; v2(212.52,113.1) CG241.1 211.6,113.4 UG15.3 ; RG74.1 v2(213.5,109.91)
  vias: v2(192.95,112.02) v2(193.65,110.77) v2(193.82,111.36) v2(194.42,111.27) v2(194.47,111.9) v2(199.59,114.6) v2(199.82,115.19) v2(199.88,115.78) v2(200.45,116.31) v2(200.47,115.73) v2(200.95,116.67) v2(205.7,123.5) v2(206.13,123.94)
+1V8_MAIN: length 392.5
  TOP w0.381: v2(306.09,62.5) 306.23,62.64 RG533.1
  TOP w0.508: LG4.1 222.96,119.45 CG20.1 CG21.2 222.96,122.2 223.39,122.64 224.31,122.64 LG5.1 224.53,121.66 225.51,120.68 v2(225.51,120.26) 225.62,120.14 LG3.1 ; RG515.1 192.31,106.06 v2(191.96,106.42) 191.22,106.42 190.71,105.91 RG512.1
  IN2 w0.508: v2(306.09,62.5) 306.09,61.89 308.02,59.96 309.6,59.96 310.33,59.22 310.33,55.31 313.01,52.63 318.93,52.63 319.7,51.87 322.31,51.87 322.89,51.29 326.74,51.29 329.22,48.81 329.22,43.18 v2(328.81,42.78) ; v2(225.51,120.26) 225.69,120.08 225.69,118.95 226.45,118.19 226.45,112.28 226.39,112.22 226.39,109.57 v2(226.32,109.5) ; 240.19,109.73 244.64,109.73 245.21,110.3 245.21,111.43 246.13,112.36 251.1,112.36 261.77,123.03 281.95,123.03 v2(282.71,123.79)
  IN4 w0.508: v2(191.96,106.42) 192.52,105.86 192.52,104.96 193.82,103.65 196.39,103.65 196.8,103.24 206.22,103.24 207.25,102.21 207.25,70.62 203.78,67.15 203.78,65.19 202.32,63.73 202.32,61.81 202.66,61.47 202.66,55.92 203.59,54.99 208.02,54.99 209.64,53.37 209.64,49.32 211.29,47.67 213.4,47.67 214.17,46.9 214.17,46.34 214.85,45.66 224.56,45.66 225.15,46.26 228.06,46.26 229.24,45.08 233.28,45.08 233.87,45.66 240.09,45.66 240.89,46.46 246.24,46.46 247.78,44.91 259.36,44.91 259.93,44.34 266.2,44.34 273.27,37.27 277.36,37.27 277.78,37.68 290.75,37.68 291.2,38.13 291.97,38.13 293.24,36.86 297.29,36.86 300.87,40.44 300.96,40.44 300.99,40.47 304.26,40.47 304.62,40.82 307.33,40.82 307.37,40.78 310.98,40.78 311.95,41.75 312.53,42.33 318.72,42.33 319.09,41.96 320.3,41.96 321.06,41.2 325.46,41.2 327.03,42.78 v2(328.81,42.78)
  IN6 w0.508: v2(242.24,161.08) 242.09,160.93 242.09,160.21 242.6,159.71 243.86,159.71 244.33,159.24 244.33,157.79 246.25,155.87 251.99,155.87 252.86,155 255.67,155 257.17,153.49 263.88,153.49 265.07,152.3 265.07,150.55 267.6,148.02 272.56,148.02 273.02,148.48 277.29,148.48 277.75,148.02 281.79,148.02 283.13,146.68 283.13,141.86 282.71,141.44 v2(282.71,123.79)
  BOTTOM w0.254: UG9.BD21 233.17,112.45 v2(233.43,112.45)
  BOTTOM w0.508: v2(242.24,161.08) RX3.1
  vias: v2(198.27,112.03) v2(198.28,111.45) v2(198.45,112.61) v2(198.85,112.06) v2(198.87,111.45) v2(199.03,112.61) v2(204.48,108.89) v2(205.11,108.89) v2(205.62,108.48) v2(216.23,108.1) v2(216.66,108.51) v2(225.63,109.5) v2(225.57,108.15) v2(225.57,107.35) v2(225.57,106.05) v2(225.57,105.25) v2(225.57,103.95) v2(226.32,108.2) v2(226.32,107.3) v2(226.32,106.1) v2(226.32,105.2) v2(226.32,104) v2(236.17,111.65) v2(236.22,110.9) v2(237.42,110.9) v2(237.47,111.65) v2(238.27,111.65) v2(238.32,110.9) v2(239.57,112.35) v2(239.57,111.65) v2(240.37,111.65) v2(240.42,110.9) v3(215.79,104.7)
+1V_MPHY: length 45.2
  TOP w0.381: CH187.1 194.82,17.17 195.36,17.17 v2(195.4,17.14) ; v2(203.13,32.11) v2(202.36,32.11)
  IN2 w0.381: v2(201.11,21.33) 201.11,19.03 200.73,18.65 196.97,18.65 195.46,17.14 v2(195.4,17.14)
  IN2 w0.508: v2(199.4,42.85) 199.35,42.8 196.6,42.8 196.33,42.54 194.53,42.54 193.98,41.99 192.67,41.99 192.47,42.19 191.65,42.19 v2(191.25,42.6)
  IN3 w0.381: v2(202.36,32.11) 201.88,32.59 201.88,36.82 201.62,37.07 201.62,37.81 201.59,37.85 201.59,38.69 199.14,41.14 199.14,42.6 v2(199.4,42.85)
  IN4 w0.381: v2(202.36,32.11) 201.3,31.06 201.3,28.95 201.05,28.69 201.05,26.5 201.46,26.09 202.53,26.09 v2(203.13,26.69)
  BOTTOM w0.152: UH1.P3 200.14,40.11 UH1.P2
  BOTTOM w0.254: UH1.W19 v2(203.13,32.11) UH1.W20 ; v2(202.36,32.11) UH1.V19 ; 200.43,40.77 200.43,41.56 199.4,42.58 v2(199.4,42.85) ; v2(203.13,26.69) UH1.W31
  vias: v1(199.28,22.41)
+1V_PCH: length 2.4
  BOTTOM w0.305: UH1.W22 v2(202.36,30.56) UH1.W23
  BOTTOM w0.381: v2(200.78,44.12) 200.78,43.73 201.16,43.35 RH71.1
  vias: v1(200.91,43.34) v2(200.16,44.12) v2(206.07,43.04) v2(206.13,43.62) v2(206.83,35.36) v2(207.59,34.98) v2(207.59,34.34) v2(209.5,33.26) v2(209.94,35.11)
+1V_VCCDSW: length 0.5
  BOTTOM w0.254: UH1.BG45 UH1.BG46
+1VALW: length 204.1
  TOP w0.356: JPCMC.22 116.71,157.11
  TOP w0.381: 116.71,157.11 v2(116.67,157.15)
  TOP w0.508: v2(129.22,161.6) 129.22,160.73 RC353.1
  IN2 w0.508: v2(174.44,153.72) 174.98,154.26 183.5,154.26 189.87,147.88 189.87,129.66 181.99,121.77 181.99,107.33 179.64,104.99 179.64,94.93 179.59,94.88 179.59,94.72 178.34,93.48 178.34,90.01 178.89,89.46 178.89,82.41 177.36,80.89 177.36,76.83 178.13,76.06 v2(178.49,76.06)
  IN3 w0.508: v2(129.22,161.6) 129.22,161.87 128.33,162.76 117.55,162.76 115.13,160.34 115.13,157.66 115.64,157.15 116.67,157.15 v2(116.67,157.15)
  IN4 w0.508: v2(151.65,159.76) 150.34,161.06 143.4,161.06 143.12,160.79 140,160.79 137.97,158.75 137.03,158.75 135.67,160.11 130,160.11 129.22,160.9 v2(129.22,161.6)
  IN6 w0.508: v2(151.65,159.76) 155.65,155.76 160.41,155.76 160.85,155.31 172.47,155.31 174.06,153.72 v2(174.44,153.72)
  BOTTOM w0.254: UH1.AF31 v2(205.46,26.69) ; UH1.V28 v2(202.36,28.24) UH1.V27 ; UH1.V28 v2(202.36,27.46) UH1.V30 ; UH1.V28 201.58,28.24 ; UH1.V28 UH1.U29 ; v2(206.23,27.46) UH1.AF30 v2(205.46,27.46) ; UH1.AB27 v2(203.91,28.24) UH1.AB28 ; UH1.AB27 v2(204.68,29.01) UH1.AD27 ; UH1.AB27 v2(204.68,28.24) ; UH1.AD28 v2(205.46,27.46) ; UH1.AD28 v2(204.68,27.46) ; UH1.AD28 v2(204.68,28.24) ; v2(205.46,27.46) UH1.AD30 v2(204.68,27.46) ; UH1.E1 UH1.D1 195.11,41.27 193.79,42.6 v2(193.62,42.6) ; UH1.AG31 v2(206.23,26.69) ; v2(203.91,30.56) UH1.AB22 v2(204.68,30.56) ; v2(203.91,30.56) UH1.AB23 ; v2(203.91,30.56) UH1.AA23 v2(203.91,29.79) UH1.AB23 ; v2(203.91,30.56) UH1.AA22 ; UH1.AB23 v2(204.68,30.56) ; v2(204.68,30.56) UH1.AD23 v2(205.46,30.56) UH1.AF23 v2(206.23,30.56) ; UH1.AD27 v2(204.68,28.24) ; UH1.AD27 v2(205.46,29.01) UH1.AF27 v2(206.23,29.01) ; UH1.AB28 v2(203.91,27.46) UH1.AB30 v2(204.68,27.46) ; UH1.AB28 v2(204.68,27.46) ; UH1.AB28 v2(204.68,28.24) ; v2(204.68,31.34) UH1.AD20 ; UH1.V30 UH1.U29 ; UH1.V30 v2(201.58,26.69) UH1.V31 v2(202.36,26.69) UH1.V30 ; UH1.U29 201.58,28.24 ; UH1.AB20 v2(204.68,32.11) ; UH1.V27 UH1.U26 ; UH1.V27 v2(202.36,29.01) UH1.V25 201.7,29.08 UH1.U26 ; UH1.U26 201.58,28.24 ; UH1.AD31 v2(204.68,26.69) ; v2(205.05,33.41) UH1.AE17
  BOTTOM w0.508: CH181.1 202.8,15.35 202.8,16.27 v2(202.78,16.28)
  vias: v2(181.29,79.66) v2(181.29,78.96) v2(181.29,78.32) v2(181.29,77.69) v2(181.29,77.05) v2(181.29,76.42) v2(181.99,79.66) v2(181.99,78.32) v2(181.99,77.69) v2(181.99,77.05) v2(197.24,31.23) v2(197.89,31.2) v2(197.94,30.6) v2(201.2,34.73) v2(202.38,34.66) v2(203.36,34.55) v2(203.91,35.17) v2(204.99,34.73) v2(233.94,35.78) v2(233.94,35.2) v2(234.53,35.78) v2(239.78,30.92) v2(239.78,30.28) v2(239.78,29.65) v2(239.78,29.01) v2(240.29,31.23) v2(240.29,30.6) v2(240.29,29.96) v2(240.29,29.33) v2(240.8,30.92) v2(240.8,30.28) v2(240.8,29.65) v2(241.39,30.28) v2(244.29,28.69) v2(244.86,28.82) v2(245.06,29.39) v2(245.5,28.82) v2(245.68,29.38) v2(246.33,29.45) v3(198.17,29.25)
+1VALWP: length 18.7
  TOP w0.254: v2(248.99,16.31) v1(248.4,16.31)
  TOP w0.508: PR307.2 240.92,15.56 241.18,15.29 242.77,15.29 243.28,15.8 v2(243.28,15.94)
  IN6 w0.254: v2(248.99,16.31) 248.19,15.51 243.79,15.51 243.36,15.94 v2(243.28,15.94)
  BOTTOM w0.254: v2(248.99,16.31) 248.99,18.71 248.6,19.1 247.85,19.1 246.45,20.5 246.45,23.36
+1VALWP_B+:
  vias: v1(260.4,21.58)
+1VALWP_PGOOD: length 89.2
  TOP w0.102: PU300.1 243.1,21.81 242.85,22.06 242.85,22.88 243.36,23.39 243.36,23.63 243.61,23.88 PR301.2 243.65,24.18 244.22,24.76 246.9,24.76 v1(248.15,26.01) 249.31,27.17 v2(249.31,28.18) ; v2(305.38,20.69) 306.3,21.61 UE5.122
  IN4 w0.102: v2(306.27,32.88) 304.84,32.88 304.13,32.17 298.95,32.17 298.22,32.91 276.37,32.91 274.82,31.36 268.98,31.36 265.77,28.15 264.93,28.15 263.94,27.16 260.9,27.16 260.31,27.76 257.99,27.76 256.6,29.14 250.26,29.14 v2(249.31,28.18)
  BOTTOM w0.102: v2(305.38,20.69) 305.52,20.69 306.35,21.53 306.35,23.53 303.6,26.28 303.6,28.57 304.87,29.84 304.87,31.49 v2(306.27,32.88)
+2.5V_MEM: length 88.7
  IN6 w1.016: 179.71,50.28 179.71,52.7 178.89,53.52 171.4,53.52 170.7,52.82 170.7,49.9 169.49,48.7 110.18,48.7
  BOTTOM w1.016: 179.9,50.12 179.9,52.18 180.41,52.7 180.41,56.54 181.04,57.17 181.04,60.03 179.39,61.68
  vias: v2(109.93,47.43) v2(109.93,46.73) v2(178.77,60.63) v2(178.78,60.05) v2(179.08,48.76) v2(179.52,49.2) v3(178.18,60.15)
+2.5V_MEMP: length 1.6
  BOTTOM w0.254: PC1303.1 v1(101.1,38.83)
+2.5VOUT: length 12.7
  TOP w0.203: v2(130.35,153.27) v1(129.83,153.27)
  BOTTOM w0.254: UM8.41 134.11,162.19 CM9.1 ; CM35.1 129.6,155.17 UM8.14 ; UM8.36 131.61,161.33 CM36.1 ; UM8.51 137.7,157.48 v2(137.74,157.44) ; UM8.9 132.11,154.63 131.12,153.65 CM32.1
  BOTTOM w0.508: v2(131.45,162.5) 131.15,162.19 CM36.1 ; CM9.1 134.29,162.19 v2(134.76,162.67) ; CM32.1 v2(130.35,153.27) CM35.1 ; CM34.1 138.33,157.44 v2(137.74,157.44)
+2.5VSP_ADJ: length 3.8
  BOTTOM w0.254: PU1300.7 100.25,43.97 PR1304.2 99.35,43.97 PR1305.1 99.35,43.53 99.7,43.17 PC1305.2
+2.5VSP_ON: length 4.6
  BOTTOM w0.254: PR1301.1 v1(97.27,52.52)
  BOTTOM w0.508: PU1300.2 100.25,52.39 PC1301.1 PR1302.1 PR1301.1
+2.5VSP_PGOOD: length 4.9
  BOTTOM w0.127: v1(95.63,51.27) 96.31,51.27 96.99,50.6 PR1300.2
  BOTTOM w0.254: PR1300.2 98.05,50.06 98.05,49.97 98.24,49.77 98.69,49.77 98.98,50.06 PU1300.1
+2.5VSP_VIN: length 1.6
  BOTTOM w0.203: 103.12,55.67 103.83,55.67 v1(104.48,56.32)
+3.3V_1.8V_DVDD: length 45.9
  TOP w0.203: v2(36.5,16.05) 36.5,15.92 36.25,15.67 UA4.16
  TOP w0.381: v2(36.51,18.78) 36.51,18.98 v1(36.9,19.36) 37.63,19.36 37.9,19.09 37.9,18.21 RA70.1
  IN1 w0.508: v2(36.51,18.78) 36.51,21.48 37.98,22.95 38.72,22.95 40.59,24.82 40.59,28.67 40.18,29.07 40.18,29.77 40.47,30.06 40.47,30.85 40.07,31.24 v2(39.94,31.24)
  IN3 w0.508: v2(34.3,39.3) 34.4,39.3 37.41,36.29 37.41,33.18 38.09,32.49 v2(39.06,32.49)
  BOTTOM w0.203: CA12.1 37.38,32.25 36.43,32.25 36.18,32.51 UA1.7
  BOTTOM w0.356: v2(34.3,39.3) 34.2,39.3 RA21.1
  BOTTOM w0.457: CA12.1 CA13.1 38.92,32.36 v2(39.06,32.49) ; RA32.1 39.03,30.59 39.68,31.24 v2(39.94,31.24) ; CA65.1 36.45,17.71 35.65,17.71 RA66.1
  BOTTOM w0.508: RA53.1 RA50.1 40.15,14.84 39.38,15.61 38.23,15.61 38.05,15.43 37.12,15.43 v2(36.5,16.05) 36.51,16.06 CA64.1 CA65.1 v2(36.51,18.78)
+3.3V_1.8V_DVDD_IO:
  vias: v1(33.36,27.65)
+3.3V_ANA_PCIE: length 1.4
  TOP w0.254: v2(183.25,167.56) UT1.L16
  BOTTOM w0.254: CT85.1 183.82,168.05 183.32,167.56 v2(183.25,167.56)
+3.3V_ANA_USB2: length 1
  TOP w0.254: UT1.J16 v2(182.6,167.56)
  BOTTOM w0.381: v2(182.6,167.56) 182.63,167.59 CT86.1
+3.3V_ELC: length 586.7
  TOP w0.254: UE3.27 226.07,161.16 225.24,160.33 CE24.1 ; CE6.1 313.79,9.6 UE1.1 313.79,12.02 313.24,12.58 UE1.48 311.29,12.58 CE60.1 ; CE59.1 313.52,20.62 313.79,20.34 UE1.36 ; UE4.27 188.6,24.69 188.74,24.83 188.74,25.37 188.6,25.5 CE25.1 ; CE168.1 302.81,37.2 303.67,38.05 303.67,38.52 303.92,38.78 UE8.27 ; UE1.24 322.38,18.08 CE1.1
  TOP w0.508: v2(322.72,17.26) 322.72,17.88 CE1.1 ; v2(312.3,26.72) 312.89,27.31 313,27.31 ; v2(224.05,161.69) 225.19,160.54 CE24.1 ; v2(224.05,161.69) 224.05,162.56 224.47,162.98 RE25.1 ; v2(224.05,161.69) 223.53,161.17 223.53,160.39 222.77,159.63 222.77,158.17 223.27,157.66 RE40.1 RE43.1 ; 313,27.31 RE657.1 ; 313,27.31 313.29,27.6 313.29,28.32 LE4.1 313.03,28.58 CE170.1 311.55,28.58 310.64,27.66 RE2.1 RE1.1 ; RE4.2 324.3,9.83 v2(324.56,10.09) ; v2(314.97,23.09) 315.43,23.09 316.05,22.47 RE6.2 RE7.2 ; RE23.1 324.79,38.93 324.29,38.93 v2(324.24,38.98) ; v2(290.72,35.72) v3(290.72,31.4) RE15.1 ; CE59.1 313.52,21.64 312.94,22.23 RE8.1 312.35,22.46 v2(311.86,21.96) ; CE6.1 v2(313.58,8.75) ; RE165.1 303.34,31.09 v2(303.22,30.98) ; v2(183.8,26.95) 184.94,26.95 RE26.1 185.12,27.62 185.94,28.44 188.97,28.44 189.95,27.46 RE32.1 189.67,26.83 189.51,26.83 189.29,26.6 189.29,26.25 188.9,25.86 CE25.1 ; CE168.1 301.7,37.4 301.7,37.84 300.78,38.76 RE166.1 300.78,39.36 v2(301.25,39.83)
  IN1 w0.508: v2(313.58,8.75) 314.41,9.58 318.46,9.58 318.54,9.5 323.97,9.5 v2(324.56,10.09)
  IN2 w0.508: v2(311.86,21.96) 313.44,21.96 314.58,23.09 v2(314.97,23.09) ; v2(230.2,45.71) 229.07,44.58 225.48,44.58 223.87,46.19 214.58,46.19 214.22,46.55 214.22,46.89 213.88,47.23 210.32,47.23 209.73,46.64 203.34,46.64 200.41,49.57 196.26,49.57 192.85,46.16 190.63,46.16 188.74,44.27 185.68,44.27 184.78,43.36 v2(182.32,43.36)
  IN2 w1.016: 165.4,24.22 150.97,24.22 149.47,25.72 127.89,25.72 122.33,20.16 104.52,20.16 104.5,20.15 ; 167.84,24.22 180.62,24.22 183.35,26.95 v2(183.8,26.95) ; 310.66,49.08 307.5,52.24 307.5,58.29 305.82,59.96 299.7,59.96 299.01,60.64 299.01,62.31 299.59,62.89 299.59,63.42 298.95,64.97 298.41,65.51 298.41,69.88 294.28,74.01 294.28,80.03 294.32,80.07 294.64,82.2 291.99,87.64 289.05,93.22 288.98,93.26 288.92,93.46 288.82,93.66 288.25,95.45 287.8,97.26 287.52,98.21 287.52,98.39 287.51,98.4 287.51,143.03 282.47,148.07 278.51,148.07 270.6,155.98 267.09,155.98 264.85,153.75 257.29,153.75 255.98,155.06 252.13,155.06 250.58,153.51 243.72,153.51 242.36,154.87 238.17,154.87 236.89,153.59 230.12,153.59 228.89,154.82 225.27,154.82
  IN3 w0.508: v2(290.72,35.72) 290.01,36.43 284.75,36.43 282,39.18 279.19,39.18 277.52,37.51 273.96,37.51 267.17,44.3 249.49,44.3 246.83,41.65 246.83,40.25 245.02,38.44 236.08,38.44 230.2,44.32 v2(230.2,45.71) ; v2(102.94,15.23) 102.9,15.19 v2(101.09,15.19) ; v2(303.22,30.98) 303.09,31.11 303.09,33.11 301.86,34.34 300.81,34.34 299.25,35.91 299.25,38.47 300.61,39.83 v2(301.25,39.83) ; v2(183.8,26.95) 182.98,26.13 181.4,26.13 179.61,27.92 179.61,32.06 181.63,34.08 181.63,42.68 v2(182.32,43.36)
  IN4 w0.508: v2(312.3,26.72) 312.3,25.67 311.48,24.85 311.45,24.85 310.93,24.34 310.93,22.89 v2(311.86,21.96) ; v2(301.25,39.83) 304.53,39.83 304.88,40.19 307.07,40.19 307.11,40.15 311.24,40.15 312.21,41.11 314.4,41.11 314.41,41.1 316.92,41.1 320.28,37.73 322.36,37.73 323.6,38.98 v2(324.24,38.98) ; v2(322.72,17.26) 322.72,17.64 317.27,23.09 v2(314.97,23.09)
  IN6 w0.508: v2(303.22,30.98) 303.26,30.98 303.75,30.48 309.08,30.48 309.76,29.8 310.24,29.8 312.3,27.74 v2(312.3,26.72)
  BOTTOM w0.508: v2(322.72,17.26) 322.72,17.01 323.92,15.8 324.62,15.8 325.38,15.04 325.38,10.59 324.88,10.09 v2(324.56,10.09) ; v2(324.24,38.98) 324.15,38.98 322.62,40.51 322.62,42.03 321.61,43.04 320.87,43.04 319.03,44.89 318.08,44.89 317.57,45.39 317.57,47.39 320.03,49.84 v2(323.35,49.84) ; v2(102.94,15.23) RE12.1 103.45,16.08 104.4,17.03 104.4,19.74 v2(103.89,20.25) ; RE14.1 v2(101.09,15.19)
  vias: v2(102.36,28.93) v2(103.08,27.4) v2(103.26,20.25) v2(159.65,23.04) v2(160.47,23.04) v2(166.31,24.25) v2(166.89,24.25) v2(223.9,155.4) v2(224.48,155.4) v2(324.11,49.84)
