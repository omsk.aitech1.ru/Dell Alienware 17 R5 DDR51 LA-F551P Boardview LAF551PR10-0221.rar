# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N29702919: length 0.9
  TOP w0.102: LX2.1 213.7,163.23 RX32.2
N29702925: length 2
  TOP w0.102: v1(215.14,164.31) 214.98,164.31 214.35,163.68 RX31.2 214.27,163.19 LX1.1
N30070819: length 2.4
  TOP w0.102: v2(234.79,61.11) 234.79,61.19 235.21,61.61 v1(235.21,62.14)
  TOP w0.305: RG131.1 234.24,61.11 v2(234.79,61.11)
  BOTTOM w0.107: UG6.J13 v2(234.79,61.11)
N30070822: length 2
  TOP w0.102: v1(244.89,60.61) 244.99,60.71 v2(245.39,60.71)
  TOP w0.305: v2(245.39,60.71) 245.41,60.68 RG127.1
  BOTTOM w0.305: UG6.J1 v2(245.39,60.71)
N30070830: length 2.7
  TOP w0.102: RG129.1 v1(239.89,60.07)
  TOP w0.305: v2(238.14,60.76) 238.71,60.19 RG129.1
  BOTTOM w0.102: v2(238.14,60.76) 238.09,60.71 UG6.J10
N30816588: length 1.5
  TOP w0.254: UA2.B2 22,30.08 RA84.1 RA85.1
N30963031: length 3.8
  TOP w0.102: v1(187.49,112.37) 187.89,112.78 RG509.2 188.49,112.77 QG503.5 189.84,112.77 190,112.6 190,112.2 189.92,112.12 QG503.6
N30963037: length 1.1
  TOP w0.432: QG503.3 192,113.42 RG510.2
N30963062: length 3.8
  TOP w0.102: QG504.6 188.89,108.32 189.02,108.19 189.43,108.19 189.54,108.31 QG504.5 189.54,109.33 189.63,109.41 RG511.2 v1(190.61,109.85)
N30963079: length 2.9
  TOP w0.102: RG512.2 188.22,105.91 v1(188.11,105.79)
  TOP w0.432: RG512.2 189.8,106.09 190.19,106.48 QG504.3
N30963101: length 4.4
  TOP w0.102: QG505.6 192.58,108.29 192.55,108.26 ; v1(191.27,107) RG513.2 191.6,108.26 192.55,108.26 ; QG505.5 193.23,108.38 193.11,108.26 192.55,108.26
N30963122: length 2.6
  TOP w0.102: RG514.2 195.98,106.94 v1(196.26,107.22)
  TOP w0.508: RG514.2 194.04,106.94 QG505.3
N30964064: length 3.1
  BOTTOM w0.102: QG507.5 QG507.6 289.34,85.93 RG541.2 v1(288.12,84.93)
N30964087: length 1.1
  BOTTOM w0.102: RG542.2 v1(290.88,90.29)
N31201664: length 2.5
  TOP w0.102: v1(278.44,157.83) 278.74,157.53 RG545.1 278.37,156.59 UG26.4
N31204217: length 2.2
  TOP w0.102: RG568.2 306.96,61.12 306.65,61.42 v1(306.65,61.79) 306.65,61.95 307.22,62.53 RG533.2
N31214366: length 2.4
  TOP w0.102: v1(213.11,155.78) 212.7,156.2 RG553.2 QG502.2
N31214429: length 2
  TOP w0.102: v2(217.06,159.6) 216.66,160.01 UG22.4
  BOTTOM w0.102: RG554.1 217.06,159.08 v2(217.06,159.6) 217.06,159.86 v1(216.63,160.29)
N31214439: length 6.6
  TOP w0.102: v2(213.92,158.02) 213.92,158.26 213.65,158.52 213.14,158.52 212.86,158.8 212.86,159.25 212.7,159.41 QG502.5
  BOTTOM w0.102: RG554.2 216.9,158.59 v1(216.01,158.59) 215.01,157.58 214.02,157.58 213.92,157.69 v2(213.92,158.02)
N31227786: length 3.1
  BOTTOM w0.102: v1(288.36,83.11) 289.57,83.11 RG543.2 289.74,82.94 QG508.5 QG508.6
N31227804: length 1.2
  BOTTOM w0.102: RG544.2 v1(287.96,78.96)
N31483113: length 3.7
  BOTTOM w0.102: v1(238.83,29.45) 239.16,29.78 PR8214.2
  BOTTOM w0.203: PQ8202.2 238.45,31.99 238.25,31.79 PC8222.1
  BOTTOM w0.254: PC8222.1 238.25,31.52 238.75,31.03 238.75,30.85 239.16,30.43 PR8214.2
N31483116: length 5
  TOP w0.102: v2(239.92,33.69) 239.43,33.69 v1(239.35,33.77)
  TOP w0.254: PR8215.1 240.45,32.68 239.92,33.21 v2(239.92,33.69)
  BOTTOM w0.254: v2(239.92,33.69) 239.74,33.51 238.21,33.51 237.8,33.1 PQ8202.3
N31483118: length 1
  BOTTOM w0.102: PR8220.2 v1(238.74,37.04)
N31787119: length 1.2
  TOP w0.102: PR6107.1 v1(253.84,155.58)
N32274706: length 18.4
  TOP w1.016: 298.97,49.98 298.97,48.12 297.89,47.04 293.53,47.04 289.91,50.66 284.32,50.66
  vias: v1(281.4,53.31) v2(283.98,51.55) v2(284.62,51.55)
N32295361: length 10.7
  IN6 w1.016: 295.16,45.2 298.71,45.2 303.03,49.52 304.11,49.52
  vias: v1(306.5,49.41) v2(289.72,52.16) v2(290.31,52.16) v2(293.12,45.33) v2(293.76,45.33) v2(305.38,49.71) v2(306.02,49.71)
N32548345: length 111.2
  TOP w0.089: 215.02,122.06 v1(215.6,122.06) 216.43,121.24 216.43,119.38 217.29,118.52 v2(218.27,118.52)
  TOP w0.102: v2(197.95,119.55) 198.28,119.22 199.36,119.22 199.46,119.32 200.14,119.32 200.71,119.88 200.71,120.57 204.58,124.44 208.1,124.44 208.81,123.73 211.71,123.73 213.37,122.06 215.02,122.06
  TOP w0.254: UG29.4 280.42,143.74 280.93,143.23 v2(281.22,143.23)
  IN4 w0.089: 229.73,122.36 229.73,119.81 228.11,118.2 226.71,118.2 226.38,117.87 222.67,117.87 221.31,119.23 219.17,119.23 219.11,119.29 218.67,119.29 218.27,118.89 v2(218.27,118.52)
  IN4 w0.102: 229.73,122.36 229.73,123.68 230.16,124.11 236.48,124.11 239.77,127.4 262.61,127.4 265.34,130.13 276.71,130.13 279.05,132.47 279.05,134.06 280.07,135.08 280.07,136.3 279.74,136.63 279.74,142.61 280.36,143.23 v2(281.22,143.23)
  BOTTOM w0.102: v2(197.95,119.55) 197.9,119.6 RG1.2
N32794300: length 2.4
  TOP w0.102: v2(226.07,153.91) 226.07,154.08 v1(226.45,154.46)
  TOP w0.254: PR6202.1 225.98,153.83 v2(226.07,153.91)
  BOTTOM w0.305: PU6200.2 226.22,153.77 v2(226.07,153.91)
N32795713: length 7.3
  TOP w0.254: v2(224.09,151.41) 223.63,151.87 223.63,154.61 v1(223.45,154.8) 222.98,155.26 PC6203.1
  BOTTOM w0.254: PU6200.24 224.2,151.3 v2(224.09,151.41) 223.91,151.41 223.27,150.78 PR6204.2
N32805176: length 14.2
  TOP w0.254: v2(279.49,146.82) 279.49,146.98 279.76,147.26 v1(281.58,147.26) 282.03,147.26 282.72,146.56 282.72,143.39 v2(281.19,141.85)
  BOTTOM w0.254: v2(279.49,146.82) 279.49,146.55 279.09,146.15 PR6040.2 279.92,145.23 279.92,143.98 279.65,143.72 PR6045.2 ; PC6015.1 v2(281.19,141.85) PR6063.2
N32805666: length 3.2
  BOTTOM w0.203: PU6000.25 271.79,139.87 v1(271.62,139.7) 271.31,139.7 271.04,139.44 PC6001.1
  BOTTOM w0.254: PR6007.2 270.67,139.45 PC6001.1
N32805668: length 2.1
  BOTTOM w0.102: PR6005.2 268.25,140.35 v1(267.86,139.97)
  BOTTOM w0.254: PR6007.1 269.74,140.35 PR6005.2
N32805796: length 4.8
  BOTTOM w0.254: PR6022.2 269.04,146.62 268.79,146.37 v1(268.79,146.36) 268.79,145.73 PR6019.1 PC6007.1 PC6005.1
N32805986: length 1.8
  BOTTOM w0.254: PC6017.2 PR6018.1 PR6016.1
N32806265: length 5.7
  BOTTOM w0.203: PR6024.1 271.92,145.33 271.92,144.64 v1(272.42,144.14) 273.61,142.95 PU6000.31
  BOTTOM w0.254: PR6024.1 PC6011.2 PR6022.1
N32806285: length 47.4
  TOP w0.203: PR6023.1 PR6021.1 v1(247.99,124.65) v2(247.99,125.33)
  IN2 w0.254: v2(247.99,125.33) 258.25,125.33 259.22,126.3 262.22,126.3 263.8,127.88 263.8,128.45 264.38,129.02 264.99,129.02 269.57,133.59 269.57,141.66 v2(271.64,143.73)
  IN6 w0.254: v2(271.64,143.73) 271.79,143.88 271.79,145.91 v2(273.31,147.44)
  BOTTOM w0.254: v2(273.31,147.44) PC6010.2 PC6009.1 PR6024.2 271.53,147.23 PR6068.1
N32806326: length 3.1
  BOTTOM w0.102: v1(268.55,144.88) 268.4,144.73 268.4,143.45 PC6005.2
  BOTTOM w0.254: PR6017.2 269.72,142.97 PC6005.2
N32806527: length 1.8
  TOP w0.102: v2(281.19,140.95) 281.66,140.95 v1(281.69,140.91)
  BOTTOM w0.254: PR6031.2 v2(281.19,140.95) 281.21,140.92 PR6038.2
N32806709: length 3
  BOTTOM w0.102: v1(266.63,140.52) 267.29,141.18 PR6015.1
  BOTTOM w0.254: PR6016.2 268.21,141.19 267.86,141.53 PR6015.1
N32856423: length 0.9
  BOTTOM w0.102: v2(227.96,153.9) 227.96,154.61 v1(228.1,154.75)
N32856454: length 0.8
  TOP w0.102: v2(228.6,153.88) 228.6,153.85 228.72,153.73 v1(228.72,153.17)
N32856474: length 1.3
  TOP w0.102: PC6202.1 229.8,155.95 v1(229.96,156.1)
N32858912: length 1.7
  BOTTOM w0.305: PU6200.26 224.37,152.3 PR6201.1
N32868428:
  vias: v2(214.21,153.91)
N32868572: length 2.8
  BOTTOM w0.254: PC6216.1 PR6211.2 209.79,150.99 210.09,151.3 210.59,151.3
  BOTTOM w0.305: PU6201.24 210.59,151.3
N32868706: length 2.3
  BOTTOM w0.305: PU6201.26 211.31,153.12 210.97,153.47 210.55,153.47 210.42,153.34 PR6208.1
N32868738: length 3.4
  BOTTOM w0.102: PR6209.1 211.25,154.79 v1(210.69,155.35)
  BOTTOM w0.305: PU6201.2 212.56,153.62 212.49,153.69 212.49,153.96 212.24,154.21 212.17,154.21 212.07,154.31 212.02,154.31 211.65,154.68 PR6209.1
N32872459: length 1.4
  TOP w0.102: v1(240.19,155.62) 241.14,154.66 PR6114.2
  vias: v2(241.43,153.91)
N32872467: length 1
  TOP w0.102: v1(242.66,153.19) 242.39,153.46 242.39,153.56 v2(242.02,153.93)
N32872469: length 1.6
  TOP w0.102: PC6115.1 243.21,156.07 v1(243.71,156.57)
N32872562: length 3.6
  TOP w0.102: v2(237.75,151.44) 238.06,151.44 v1(238.26,151.23)
  TOP w0.254: PC6116.1 PR6113.2 237.24,151.95 v2(237.75,151.44)
  BOTTOM w0.305: PU6101.24 237.83,151.36 v2(237.75,151.44)
N32872704: length 3
  BOTTOM w0.102: v1(236.97,151.18) 236.97,152.22 PR6110.1
  BOTTOM w0.305: PU6101.26 238.03,152.36 237.77,152.63 PR6110.1
N32872742: length 2.4
  TOP w0.254: v2(239.78,153.98) 239.68,153.88 PR6111.1
  BOTTOM w0.102: v2(239.78,153.98) v1(239.78,154.8)
  BOTTOM w0.305: PU6101.2 239.93,153.77 239.78,153.91 v2(239.78,153.98)
N32872879: length 0.8
  BOTTOM w0.102: v2(255.21,153.98) v1(255.21,154.76)
N32872885: length 0.9
  TOP w0.102: v1(256.33,153.34) 256.33,153.48 v2(255.81,153.99)
N32873027: length 3.7
  TOP w0.127: v2(251.53,151.5) 251.79,151.5 v1(252.12,151.17)
  TOP w0.254: PC6103.1 PR6106.2 251.02,152.01 v2(251.53,151.5)
  BOTTOM w0.305: PU6100.24 251.61,151.43 v2(251.53,151.5)
N32873161: length 2.7
  BOTTOM w0.102: v1(250.8,151.57) 251.15,151.92 PR6103.1
  BOTTOM w0.305: PR6103.1 251.43,152.7 251.7,152.43 PU6100.26
N32873197: length 2.4
  TOP w0.254: PR6104.1 253.49,153.82 v2(253.71,154.04)
  BOTTOM w0.102: v2(253.71,154.04) 253.69,154.06 253.69,154.45 v1(253.4,154.74)
  BOTTOM w0.305: v2(253.71,154.04) PU6100.2
N32889750: length 2.6
  BOTTOM w0.102: v1(282.15,143.96) 281.81,143.61 PR6061.1
  BOTTOM w0.254: PR6053.2 PR6061.1
N32890192: length 3.3
  TOP w0.102: v2(279.03,141.47) v1(279.7,141.47)
  TOP w0.254: PC6016.2 278.64,141.09 v2(279.03,141.47)
  BOTTOM w0.203: PU6000.2 v2(279.03,141.47) 279.27,141.47 PR6063.1
N32892915: length 1.1
  TOP w0.203: PR6411.1 299.31,57.72 PC6426.2
N32894520: length 3.3
  TOP w0.203: PR6420.1 302.27,59.15 PR6419.2 302.31,58.36 v1(302.46,58.21) 303.04,57.62 PU6400.9
N33144860: length 2.8
  BOTTOM w0.102: v1(272.21,148.82) PR6068.2
  BOTTOM w0.254: PC6011.1 270.65,147.26 PR6068.2
N33334796: length 3.4
  TOP w0.102: v1(281.44,151.27) PR6069.2
  TOP w0.254: PR6069.2 279.64,151.27 279.23,151.68 PQ8203.5 PQ8203.6
N37205985: length 6.5
  BOTTOM w0.107: RH519.2 127.76,119.6 v1(128.55,120.39) 129.23,120.39 130.24,119.38 130.81,119.38 131.43,118.76 132.61,118.76 UC1.BR33
N37206101: length 9.9
  TOP w0.089: v2(168.78,103.27) 169.16,103.66 172.15,103.66
  TOP w0.102: RH154.2 173.66,103.44 173.51,103.6 173.51,104.59 173.41,104.69 v1(173.21,104.69) 173.1,104.59 173.1,103.8 173,103.7 172.8,103.7 172.7,103.8 172.7,104.59 172.6,104.69 172.39,104.69 172.29,104.59 172.29,103.8 172.15,103.66
  BOTTOM w0.076: UC1.H13 168.41,103.64 v2(168.78,103.27)
N37206112: length 7
  BOTTOM w0.107: UC1.BP31 133.31,117.93 131.45,117.93 131.2,118.19 131.2,118.55 130.68,119.07 v1(128.53,119.07) 128.49,119.07 128.24,118.81 128.19,118.81 127.96,118.58 RH155.2
N37239953: length 7.6
  TOP w0.089: RH192.2 v1(173.44,111.91) 171.62,111.91 171.21,111.5 169.13,111.5 v2(168.74,111.89)
  BOTTOM w0.076: v2(168.74,111.89) 168.11,111.89 UC1.J23
N37239957: length 99.8
  TOP w0.089: 174.88,110.85 174.38,110.35 171.52,110.35 171.14,110.73 169.14,110.73 v2(168.76,111.12)
  TOP w0.114: 174.88,110.85 174.99,110.96 176.44,110.96 178.23,109.17 178.23,103.26 180.25,101.25 180.25,97.93 181.38,96.8 183.72,96.8 186.7,93.82 v1(186.7,75.81) 186.7,73.46 189.89,70.27 189.89,68.7 189.75,68.56 189.75,67.98 190.52,67.21 190.52,62.26 191,61.77 192.46,61.77 193.77,63.08 198.83,63.08 199.25,62.67 v2(199.4,62.67)
  IN1 w0.081: v2(199.4,62.67) 199.47,62.67 201.89,60.25 204.03,60.25 204.73,59.55 204.73,59.06 v2(205.72,58.07)
  BOTTOM w0.089: v2(168.76,111.12) 168.38,111.49 UC1.H23
  BOTTOM w0.102: v2(205.72,58.07) 205.77,58.12 206.32,58.12 208.05,56.39 208.05,55.13 208.19,54.99 210.81,52.37 210.81,51.98 210.91,51.88 210.91,51.57 211.81,50.66 211.81,48.86 211.65,48.69 211.65,47.74 209.53,45.62 RH167.2
N37345395: length 1.1
  TOP w0.122: v2(208.73,24.82) 208.41,25.15 T135.1
  BOTTOM w0.122: v2(208.73,24.82) 208.67,24.82 208.36,24.51 UH1.AL35
N37890445: length 9.5
  TOP w0.102: v2(185.98,6.24) v1(185.98,6.9) 185.98,7.06 CT115.1
  BOTTOM w0.102: QT2.5 185.53,13.01 185.17,12.65 185.17,11.59 RT90.1 185.4,10.95 185.4,6.83 185.98,6.25 v2(185.98,6.24)
N37890455: length 1.9
  BOTTOM w0.102: v1(182.83,12.82) 182.86,12.86 RT89.2 183.68,13.77 QT2.3
N37890462: length 10.5
  TOP w0.102: v2(186.39,5.82) 186.67,6.1 186.67,6.84 187.66,7.83 RT88.2 v1(188.69,7.83)
  BOTTOM w0.102: QT2.6 185.89,12.17 RT90.2 185.69,11.19 185.69,8.07 186.39,7.37 v2(186.39,5.82)
N37890499: length 2.7
  TOP w0.102: UT5.6 193.2,9.94 192.77,9.52 192.25,9.52 ; 192.25,9.52 192.25,9.63 192.6,9.99 v1(192.6,10.44) ; 192.25,9.52 CT117.1
N38701284: length 8.9
  TOP w0.102: UE1.25 319.3,20.59 318.56,21.33 318.21,21.33 318.02,21.52 318.02,22.31 316.46,23.87 DE1.2 315.1,23.87 313.85,22.62 RE8.2
N38702841: length 2.9
  TOP w0.102: v1(322.97,15.17) 322.51,15.62 RE651.1 322.04,16.18 321.94,16.08 UE1.20
N38755071: length 3.3
  TOP w0.102: v1(164.19,184.39) RV675.2 165.17,184.29 165.17,182.87 165.12,182.82 JEDP.28
N38961275: length 3
  TOP w0.089: RG567.2 215.54,111.38 UG30.2 215.97,111.94 216.11,112.08 216.52,112.08 216.62,111.98 UG30.3 216.62,110.94 v1(216.54,110.86)
N39960403: length 3.6
  TOP w0.102: UU8.6 31.95,51.49 31.76,51.68 31.76,52.11 CU92.1 31.77,52.87 v1(31.39,52.49)
N40259586: length 267.5
  TOP w0.102: v1(200.81,162.09) 200.4,162.51 v2(200.4,162.94) ; RT109.2 RT108.1 v2(318.4,55.17)
  IN1 w0.102: v2(200.35,133.85) 199.9,134.3 199.9,144.36 201.34,145.79 201.34,150.39 202.83,151.88 205.49,151.88 205.88,152.26 205.88,153.61 204.96,154.52 204.53,154.52 202.19,156.86 202.19,160.1 201.41,160.87 201.41,161.33 200.4,162.35 v2(200.4,162.94)
  IN2 w0.102: v2(192.2,65.18) 191.03,66.34 191.03,68.31 189.74,69.61 189.44,69.61 183.19,75.85 180.88,75.85 180.54,76.19 180.54,80.45 186.42,86.33 186.42,94.03 185.34,95.11 185.34,103.36 186.82,104.84 186.82,111.18 188.92,113.29 188.92,122.67 200.1,133.85 v2(200.35,133.85)
  IN6 w0.102: v2(318.4,55.17) 316.3,53.08 310.4,53.08 309.83,53.65 304.87,53.65 304.75,53.52 298.23,53.52 293.22,48.5 278.51,48.5 277.67,49.35 273.06,49.35 271.73,50.68 260.77,50.68 259.7,49.61 250.36,49.61 249.14,50.83 231.99,50.83 231.59,51.24 228.25,51.24 227.47,52.02 223.94,52.02 223.62,51.7 217.1,51.7 216.51,52.28 214.16,52.28 211.77,54.68 211.77,56.54 209.1,59.21 209.1,64.9 208.83,65.18 201.73,65.18 199.92,66.99 195.59,66.99 194.6,65.99 194.6,65.66 194.6,65.02 194.34,64.76 192.61,64.76 v2(192.2,65.18)
  BOTTOM w0.089: UT4.D6 200.66,163.2 v2(200.4,162.94)
N41521526: length 7.9
  TOP w0.102: RE85.1 309.76,12.89 CE51.1 309.27,11.45 309.27,10.74 309.88,10.13 310.04,10.13 310.46,9.71 310.46,9.13 309.22,7.89 QE2.2 309.15,6.56 v1(309.1,6.51)
N46084233: length 5.8
  BOTTOM w0.102: QX2.2 228.43,166.09 228.54,165.99 230.46,165.99 v1(231.06,166.59) 231.25,166.78 RX2.1
N123247790: length 1.3
  BOTTOM w0.203: C2507.1 65.2,14.12 65.09,14.23 U17.10
N123252636: length 1.2
  BOTTOM w0.203: C2506.1 64.28,14.23 64.29,14.23 U17.12
N124009550: length 1.3
  TOP w0.102: v2(199.14,164.74) 199.22,164.74 T63.1
  BOTTOM w0.089: v2(199.14,164.74) 199.27,164.87 UT4.G4
N124752685: length 2.6
  TOP w0.127: CH101.2 155.34,57 v1(154.66,57.68)
  TOP w0.508: CH101.2 RH211.1
N124753277: length 0.9
  TOP w0.508: RH212.1 CH100.2
N203830181: length 2.9
  TOP w0.102: PR11.1 295.54,43.3 PD5.3 294.83,42.39 295.17,42.05 v1(295.94,42.05)
N210597020: length 3.2
  TOP w0.102: PR8210.2 v1(254.29,32.76)
  TOP w0.254: PC8219.1 252.48,32.2 PR8210.2
N212152397: length 7.2
  TOP w0.254: PR2.2 294.86,40.86 295.28,40.44 v1(295.28,40.31) 295.28,39.17 294.84,38.73 293.76,38.73 293.44,38.41 v2(293.44,37.52)
  BOTTOM w0.254: JRTC1.1 292.69,38.27 v2(293.44,37.52)
N213961754: length 5.9
  TOP w0.254: PC14.2 81.01,9.11 80.75,8.86 v1(78.24,8.86) 78.12,8.86 PR28.2 77.01,9.61 76.7,9.31 PQ8.2
N1240135923: length 2.6
  BOTTOM w0.076: UT4.B2 198.66,162.47 198.51,162.62 197.69,162.62 197.51,162.44 197.46,162.44 197.25,162.23 197.25,161.88
  BOTTOM w0.089: 197.25,161.88 T64.1
N1240135924: length 4.1
  BOTTOM w0.076: 196.65,162.07 196.73,162.15 196.73,162.28 197.13,162.68 197.16,162.68 197.6,163.12 198.52,163.12 198.66,162.98 UT4.C2
  BOTTOM w0.089: 196.65,162.07 196.37,161.79 196.22,161.79
  BOTTOM w0.102: T65.1 195.91,161.57 196.12,161.79 196.22,161.79
N1240135925: length 2.2
  TOP w0.102: 203.91,163.5 203.91,163.96 T114.1
  TOP w0.107: 203.91,163.5 v2(203.91,163.44)
  BOTTOM w0.076: UT4.D10 202.66,163.4 202.88,163.62 203.73,163.62
  BOTTOM w0.089: 203.73,163.62 203.78,163.57
  BOTTOM w0.102: 203.78,163.57 v2(203.91,163.44)
N1240135926: length 1.3
  TOP w0.102: T120.1 203.78,165.09 v2(203.78,164.98)
  BOTTOM w0.102: v2(203.78,164.98) 203.67,164.87 UT4.G11
N1240135928: length 2.2
  BOTTOM w0.076: 203.78,164.09 203.75,164.12 202.87,164.12 202.66,163.9 UT4.E10
  BOTTOM w0.102: T121.1 204.29,164.09 203.78,164.09
N1240135929: length 2.9
  BOTTOM w0.076: 203.78,165.39 203.61,165.39 203.34,165.12 202.85,165.12 202.66,164.92 UT4.G10
  BOTTOM w0.102: 204.92,165.82 205.05,165.94 T122.1
  BOTTOM w0.107: 203.78,165.39 203.81,165.42 204.52,165.42 204.92,165.82
N1240135930: length 1.2
  TOP w0.102: v2(200.98,162.87) 201.18,163.07 T70.1
  BOTTOM w0.089: UT4.D7 201.16,163.05 v2(200.98,162.87)
N1240135963: length 1.3
  TOP w0.102: T62.1 199.51,164.16 v2(199.14,164.16)
  BOTTOM w0.089: v2(199.14,164.16) 199.35,164.37 UT4.F4

## Copper pours and planes (outline as drawn)
1.2V_B+ on TOP (solid shape): 93.04,38.03 93.04,34.85 93.16,34.73 93.42,34.73 93.54,34.6 93.54,33.84 93.48,33.77 90.33,33.77 89.95,34.15 88.02,34.15 87.77,34.41 87.77,35.61 87.32,36.06 87.32,37.14 87.45,37.27 89.16,37.27 89.73,37.84 89.73,38.98 89.86,39.11 91.96,39.11
1V8_ENP on BOTTOM (solid shape): 228.52,41.45 228.52,41.28 227.27,40.03 223.13,40.03 223.07,40.09 223.07,40.65 223.11,40.69 226.82,40.69 227.64,41.52 228.45,41.52
3/5V_B+ on TOP (solid shape): 56.4,41.46 56.4,38.85 55.32,37.77 55.32,35.57 55.31,35.56 55.29,35.42 55.31,35.29 55.32,35.28 55.32,34.98 55.31,34.98 55.29,34.84 55.31,34.7 55.32,34.69 55.32,34.39 55.31,34.38 55.29,34.24 55.31,34.11 55.32,34.1 55.32,33.46 55.25,33.39 53.6,33.39 53.35,33.14 53.35,32.15 53.35,32.06 52.93,31.64 50.28,31.64 49.98,31.93 49.98,33.77 50.91,34.7 51.14,34.7 51.47,35.03 51.47,37.9 51.82,38.26 51.82,39.93 51.7,40.06 50.87,40.06 50.62,39.81 47.57,39.81 47.56,39.8 43.98,39.8 43.82,39.96 43.82,42.54 45.2,43.92 53.94,43.92
3/5V_B+ on BOTTOM (solid shape): 55.19,42.35 55.19,38.34 54.87,38.03 51,38.03 50.55,38.47 50.55,42.66 51.32,43.42 54.11,43.42
3VS on BOTTOM (solid shape): 70.31,17.02 70.31,16.54 69.76,16.54 69.76,15.99 70.31,15.99 70.31,15.74 69.76,15.74 69.76,15.19 70.31,15.19 70.31,13.03 69.97,12.69 66.99,12.69 66.47,13.21 65.9,13.21 65.69,13.41 65.69,13.98 65.39,14.29 65.39,15.18 65.45,15.24 66.02,15.24 66.28,15.5 66.28,16.2 66.42,16.34 68.19,16.34 68.97,17.11 70.22,17.11
5VS on BOTTOM (solid shape): 60.31,16.33 62.31,16.33 63.4,15.24 63.93,15.24 63.99,15.18 63.99,14.29 63.79,14.09 63.79,13.48 63.66,13.35 61.2,13.35 59.88,14.67 59.4,14.67 59.4,15.19 58.9,15.19 58.9,14.67 58.6,14.67 58.6,15.19 58.1,15.19 58.1,14.67 57.15,14.67 56.91,14.92 56.91,16.4 57.07,16.56 60.08,16.56
+0.6VS on TOP (solid shape): 179.9,54.28 179.9,52.31 179.43,51.84 179.43,49.68 179.08,49.33 178.44,49.33 178.06,49.71 178.06,52.31 178.25,52.51 178.51,52.51 178.7,52.7 178.7,54.22 178.95,54.47 179.71,54.47
+0.6VS on TOP (solid shape): 181.62,43.04 181.62,36.06 181.3,35.74 179.78,35.74 179.65,35.87 179.65,41.2 179.46,41.39 179.46,41.9 179.02,42.35 179.02,43.49 179.14,43.62 181.05,43.62
+0.6VS on BOTTOM (solid shape): 179.78,43.49 179.78,42.73 179.46,42.41 178.76,42.41 178.06,41.71 178.06,40.57 177.81,40.57 177.81,42.73 178.7,43.62 179.65,43.62
+0.6VS on BOTTOM (solid shape): 93.8,54 93.8,52.82 93.67,52.7 91.77,52.7 91.45,53.01 91.45,54.01 91.59,54.15 93.65,54.15
+0.6VS on BOTTOM (solid shape): 178.1,54.38 178.1,52.59 178.25,52.44 178.51,52.44 178.82,52.12 178.82,51.49 178.44,51.11 178.06,51.11 177.81,51.36 177.81,54.4 177.9,54.49 178,54.49
+0.6VS on IN2 (solid shape): 94.28,54.43 94.28,53.4 93.51,52.63 91.51,52.63 91.19,52.95 91.19,54.73 91.66,55.2 93.52,55.2
+0.6VS on IN2 (solid shape): 179.15,53.66 179.15,51.45 178.72,51.03 177.88,51.03 177.6,51.31 177.6,52.13 177.61,52.22 177.6,52.3 177.6,53.67 177.73,53.8 179.01,53.8
+0.6VS on IN6 (solid shape): outline of 306 points within 175.78,42.21 179.78,52.89
+0.6VSP on BOTTOM (solid shape): 92.88,52 93.32,52 93.32,52.53 93.77,52.53 93.86,52.44 93.86,50.98 93.29,50.41 92.21,50.41 91.83,50.03 91.83,48.44 91.95,48.32 91.95,48.31 92.4,47.86 92.4,46.97 92.34,46.9 92.25,46.9 92.19,46.96 92.19,47.75 91.88,48.06 91.27,48.06 90.88,47.66 90.88,46.9 91.07,46.71 91.53,46.71 91.59,46.65 91.59,46.55 91.53,46.49 90.67,46.49 90.31,46.85 90.31,48.24 90.37,48.3 90.37,48.31 90.69,48.63 90.69,52.38 90.84,52.53 92.88,52.53
+0.9V_CIO on TOP (solid shape): 180.14,165.81 180.33,165.7 180.52,165.81 180.79,165.81 180.84,165.75 180.91,165.71 180.96,165.7 181.1,165.56 181.1,165.22 180.99,165.11 180.28,165.11 180.15,164.98 179.71,164.98 179.55,164.82 179.52,164.79 179.46,164.73 179.24,164.73 179.21,164.78 179.17,164.81 179.13,164.84 179.06,164.86 179.04,164.89 179.03,165.05 178.94,165.19 178.92,165.2 178.92,165.26 178.95,165.3 179.01,165.36 179.13,165.36 179.14,165.35 179.35,165.28 179.56,165.35 179.58,165.36 180.03,165.81
+0.9V_CIO on BOTTOM (solid shape): 180.91,165.7 180.91,165.51 180.97,165.45 181.45,165.45 181.48,165.42 181.48,165.03 181.42,164.97 180.45,164.97 180.23,164.75 179.75,164.75 179.65,164.65 179.65,164.17 179.59,164.11 179.2,164.11 179.13,164.17 179.13,165.06 179.32,165.25 179.43,165.26 179.54,165.3 179.55,165.31 180.27,165.31 180.38,165.41 180.38,165.74 180.47,165.83 180.78,165.83
+0.9V_DP on TOP (solid shape): 179.14,167.33 179.14,166.25 179.05,166.16 179.03,166.16 178.9,166.12 178.82,166.01 178.81,166 178.63,166 178.54,166.09 178.51,166.12 178.2,166.43 178.2,166.58 178.39,166.77 178.39,167.04 178.24,167.2 178.24,167.28 178.29,167.33 178.32,167.36 178.47,167.51 178.47,167.62 178.62,167.78 178.69,167.78
+0.9V_DP on TOP (solid shape): 181.42,164.54 181.42,164.53 181.47,164.47 181.53,164.43 181.53,164.42 181.57,164.38 181.57,164.22 181.74,164.05 181.74,163.91 181.71,163.88 181.68,163.84 181.58,163.84 181.52,163.9 181.44,163.98 181.3,163.99 181.19,163.98 181.16,163.95 181.05,163.87 180.96,163.96 180.66,164.09 180.36,163.98 180.33,163.96 180.3,163.98 180.27,164 180.25,164.04 180.26,164.07 180.35,164.35 180.18,164.59 180.15,164.6 180.15,164.73 180.28,164.85 181.1,164.85
+0.9V_DP on BOTTOM (solid shape): 176.28,156.08 176.28,154.63 176.24,154.58 174.16,154.58 173.94,154.8 173.94,156.07 173.94,156.16 174,156.23 176.13,156.23
+0.9V_DP on BOTTOM (solid shape): 181.75,164.62 181.81,164.62 181.82,164.62 181.94,164.6 182.06,164.62 182.09,164.62 182.15,164.56 182.15,164.1 182.11,164.06 181.26,164.06 181.22,164.02 180.89,164.02 180.71,164.09 180.53,164.07 180.5,164.06 180.39,164.17 180.39,164.49 180.67,164.77 181.59,164.77
+0.9V_DP on BOTTOM (solid shape): 178.71,167.86 178.8,167.86 178.95,167.72 178.95,167.69 178.98,167.69 179,167.67 179.4,167.67 179.71,167.36 179.71,167.35 179.97,167.2 180.26,167.3 180.4,167.3 180.65,167.2 180.91,167.3 181.05,167.3 181.23,167.21 181.42,167.22 181.51,167.21 181.56,167.12 181.56,166.81 181.5,166.76 180.98,166.76 180.9,166.68 180.64,166.68 180.57,166.6 180.51,166.58 179.19,166.58 179.16,166.55 179.08,166.55 179.08,166.47 179.07,166.46 179.07,166.2 178.89,166.02 178.47,166.02 178.45,166.05 178.45,166.55 178.37,166.55 178.37,166.74 178.38,166.76 178.41,166.91 178.38,167.06 178.37,167.07 178.37,167.74 178.49,167.86
+0.9V_DP on IN2 (solid shape): outline of 540 points within 174.32,155.76 182.44,164.77
+0.9V_DP on IN5: 180.39,164.07 180.22,164.24 180.22,165.45 179.69,165.98 178.61,165.98 178.51,166.08 178.51,167.19 181.17,167.19 181.17,165.56 181.58,165.15 181.56,165.13 181.56,164.07
+0.9V_LVR_OUT on BOTTOM (solid shape): 183.78,170.87 183.78,169.84 183.75,169.82 183.65,169.74 183.58,169.63 183.58,169.62 183.56,169.6 183.56,169.25 183.65,169.15 183.65,168.24 183.35,167.95 182.95,167.95 182.95,168.13 182.95,168.17 182.94,168.22 182.94,168.62 182.95,168.71 182.94,168.8 182.94,169.03 182.27,169.03 181.7,168.46 181.63,168.43 181.56,168.46 181.05,168.46 181.05,167.96 181.08,167.92 180.98,167.82 180.98,167.71 180.96,167.66 180.95,167.6 180.78,167.43 180.49,167.43 180.36,167.55 180.36,167.61 180.35,167.65 180.35,168.66 180.88,168.66 180.88,169.15 181.22,169.15 181.3,169.15 181.38,169.15 181.88,169.15 181.96,169.15 182.06,169.15 182.08,169.17 182.21,169.25 182.29,169.38 182.29,169.39 182.38,169.47 182.38,170.87 182.44,170.93 183.71,170.93
+0.9V_PCIE on TOP (solid shape): 188.03,161.12 188.03,158.81 188.08,158.76 188.08,158.41 188.02,158.35 187.69,158.35 187.59,158.44 187.59,161.11 187.65,161.16 188,161.16
+0.9V_PCIE on TOP (solid shape): 183.66,167.33 183.9,167.22 184.15,167.33 184.31,167.33 184.35,167.3 184.35,167.19 184.29,167.13 184.24,167.06 184.15,166.97 184.15,166.83 183.99,166.67 183.99,166.48 183.99,166.47 184.01,166.46 184.13,166.34 184.14,166.18 184.37,165.95 184.37,165.89 184.33,165.85 184.29,165.81 183.52,165.81 183.46,165.86 182.95,166.38 182.26,166.38 182.25,166.41 181.96,166.59 181.67,166.42 181.61,166.41 181.55,166.44 181.49,166.5 181.49,166.9 181.52,166.98 181.59,167 181.7,167.01 181.8,167.08 182.11,167.08 182.28,167 182.45,167.08 182.5,167.08 182.57,167.14 182.65,167.17 182.72,167.13 182.87,167.01 183.05,167.03 183.07,167.05 183.25,167.22 183.27,167.23 183.39,167.25 183.5,167.33
+0.9V_PCIE on BOTTOM (solid shape): 183.59,167.12 184.1,167.12 184.16,167.06 184.16,166.17 184.2,166.13 184.2,165.98 184.26,165.92 184.67,165.92 184.79,165.79 184.79,165.41 184.73,165.34 184.22,165.34 184.16,165.41 184.16,165.73 184.04,165.84 183.52,165.84 183.46,165.9 183.38,165.94 183.37,165.94 183.33,165.98 183.02,165.98 182.89,166.11 182.89,166.42 182.85,166.46 182.85,166.54 182.77,166.54 182.7,166.61 182.62,166.62 181.87,166.62 181.75,166.74 181.75,167.06 181.87,167.19 183.52,167.19
+0.9V_PCIE on IN2 (solid shape): outline of 377 points within 181.24,158.15 189.81,167.37
+0.9V_PCIE on IN5: 187.76,158.3 187.59,158.46 187.59,162.53 186.55,163.57 184.2,163.57 182.36,165.41 182.04,165.41 181.68,165.77 181.68,167.19 188.18,167.19 189.68,165.68 189.68,159.04 188.94,158.3
+0.9V_SVR on TOP (solid shape): 180.11,167.95 180.1,167.84 180.12,167.8 180.12,167.61 180.24,167.48 180.19,167.43 180.18,167.43 180.05,167.31 180.05,167.1 180.22,166.93 180.22,166.78 180.13,166.68 180.1,166.55 180.11,166.52 180.03,166.44 179.58,166.44 179.52,166.5 179.52,167.97 179.58,168.03 180.03,168.03
+0.9V_SVR on TOP (solid shape): 181.36,170.39 181.55,170.2 181.55,170.08 181.68,169.95 181.73,169.89 181.8,169.85 181.83,169.81 181.96,169.81 182.44,169.33 182.44,169.11 182.33,169 180.34,169 180.22,169.13 180.22,169.25 180.31,169.38 180.33,169.54 180.33,169.57 180.36,169.6 180.41,169.62 180.44,169.63 180.61,169.63 181.01,170.03 181.01,170.15 181.25,170.39
+0.9V_SVR on BOTTOM (solid shape): 174,175.26 174,174.98 174.47,174.51 174.76,174.51 174.93,174.34 174.93,172.68 174.84,172.58 171.05,172.58 170.92,172.46 170.92,172.21 170.78,172.06 169.99,172.06 169.78,172.27 169.78,174.58 170.57,175.38 173.88,175.38
+0.9V_SVR on BOTTOM (solid shape): 179.46,171.76 179.46,171.44 179.46,171.44 179.46,171.32 179.53,171.25 181.65,171.25 181.74,171.15 181.74,170.43 181.64,169.96 182.11,169.82 182.21,169.82 182.25,169.73 182.25,169.52 182.01,169.28 180.67,169.28 180.48,169.47 180.48,170.17 180.31,170.33 180.26,170.41 180.18,170.46 180.1,170.54 179.66,170.54 179.58,170.47 179.58,170.2 179.58,170.2 179.23,170.2 179.21,170.21 179.21,170.29 179.05,170.45 179.05,171.78 179.06,171.79 179.43,171.79
+0.9V_SVR on IN2 (solid shape): outline of 982 points within 169.82,169.22 184.03,176.87
+0.9V_SVR on IN3 (solid shape): outline of 257 points within 179.17,166.89 182.71,170.88
+0.9V_USB on IN2 (solid shape): outline of 323 points within 182.43,158.3 187.39,165.15
+1.0VS_VGAP on BOTTOM (solid shape): 242.99,48.57 242.99,46.39 242.38,45.77 241.21,45.77 241.15,45.83 241.15,46.52 240.97,46.7 238.62,46.7 237.5,45.58 237.5,44.12 237.37,44 236.9,44 236.8,44.09 236.8,44.57 235.8,45.57 235.8,46.37 235.53,46.63 233.69,46.63 233.12,47.2 233.12,47.96 233.13,47.96 235.42,47.96 235.42,47.95 236.15,48.68 241.2,48.68 241.28,48.76 242.81,48.76
+1.2V_DDR on TOP (solid shape): 128.84,30.24 120.84,30.24 120.84,38.24 128.84,38.24
+1.2V_DDR on TOP (solid shape): outline of 30973 points within 97.58,24.82 174.05,104.16
+1.2V_DDR on BOTTOM (solid shape): 129.36,101.99 129.36,97.94 129.07,97.64 128.4,97.64 128.3,97.74 128.3,98.54 128.46,98.7 128.46,99.93 128.46,99.94 128.46,102.11 128.53,102.19 129.17,102.19
+1.2V_DDR on BOTTOM (solid shape): 153.71,52.45 153.71,51.83 154.16,51.38 154.24,51.31 154.33,51.25 154.39,51.19 154.38,51.12 154.35,50.86 154.49,50.65 154.49,50.42 154.19,50.12 149.5,50.12 149.44,50.22 149.36,50.3 149.19,50.48 148.95,50.64 148.67,50.69 148.18,50.69 147.9,50.64 147.66,50.48 147.3,50.12 139.73,50.12 138.97,50.88 138.97,51.61 139.14,51.78 139.14,52.21 139.43,52.51 153.65,52.51
+1.2V_DDR on BOTTOM (solid shape): 149.18,39.68 153.35,39.68 153.65,39.37 153.65,38.69 153.42,38.45 153.08,38.45 152.99,38.5 152.99,38.6 152.66,39.1 152.34,38.6 152.33,38.5 152.24,38.45 147.88,38.45 147.84,38.41 139.28,38.41 138.92,38.76 138.92,39.45 139.12,39.65 147.94,39.65 148.24,39.96 148.9,39.96
+1.2V_DDR on BOTTOM (solid shape): outline of 84 points within 138.4,60.87 154.97,65.87
+1.2V_DDR on BOTTOM (solid shape): outline of 155 points within 98.56,32.82 110.88,43.17
+1.2V_DDR on IN2 (solid shape): outline of 287 points within 98.56,32.82 110.88,43.17
+1.2V_DDR on IN5: 108.76,38.22 108.28,38.7 108.28,46.56 111.38,49.66 111.38,78.87 119.33,86.82 119.33,87.73 119.31,87.74 119.31,97.78 119.93,98.39 122.77,98.39 122.88,98.5 122.88,97.1 130.33,89.65 170.99,89.65 173.47,92.13 179.07,86.54 179.01,39.29 179.01,38.9 178.32,38.22
+1.2V_VCCPLL_OC on TOP (solid shape): outline of 179 points within 168.28,101.46 170.89,102.99
+1.2V_VCCPLL_OC on BOTTOM (solid shape): 130.37,104.19 130.37,103.71 130.28,103.62 129.64,103.62 129.46,103.43 128.62,103.43 128.47,103.58 128.47,104.23 128.62,104.38 130.18,104.38
+1.2V_VCCPLL_OC on IN6 (solid shape): outline of 1374 points within 136.27,101.28 169.53,105.34
+1.2VP on TOP (solid shape): 97.35,25.01 97.16,24.82 94.31,24.82 93.73,25.39 93.73,30.53 94.12,30.92 94.43,30.92 97.04,33.52 97.35,33.52
+1.2VP on BOTTOM (solid shape): outline of 292 points within 89.99,26.91 98.34,39.04
+1.8V_PRIM on TOP (solid shape): outline of 99 points within 207.93,41.35 211.01,42.56
+1.8V_PRIM on TOP (solid shape): outline of 452 points within 206.05,31.78 214.38,37.07
+1.8VALW on TOP (solid shape): 209.05,44.18 209.05,43.3 208.92,43.17 208.11,43.17 208.02,43.27 208.02,43.69 207.98,43.72 207.98,44.03 208.22,44.26 208.96,44.26
+1.8VALW on TOP (solid shape): 36.27,50.92 36.27,50.47 36.08,50.28 35.63,50.28 35.38,50.03 35.38,49.71 35.25,49.58 34.43,49.58 34.24,49.77 34.24,50.98 34.36,51.11 36.08,51.11
+1.8VALW on BOTTOM (solid shape): 195.37,116.63 195.37,115.97 195.49,115.85 195.79,115.85 195.93,115.7 195.93,115.12 195.94,115.11 195.94,115 195.96,114.97 195.96,114.27 195.91,114.21 194.07,114.21 193.73,114.55 193.73,116.22 193.89,116.39 193.9,116.39 194.27,116.75 195.25,116.75
+1.8VALW on BOTTOM (solid shape): 205.79,65.65 205.89,65.37 206.16,65.27 211.23,60.2 211.23,59.24 211.72,58.75 212.63,58.75 213.18,58.2 213.18,53.75 214.04,52.89 216.18,52.89 217.38,51.68 221.76,51.68 222.91,50.52 222.91,48.66 222.03,47.78 222.03,47.26 222,47.22 221.64,47.22 221.64,47.75 221.14,47.75 221.14,47.22 220.84,47.22 220.84,47.75 220.34,47.75 220.34,47.22 219.97,47.22 219.96,47.23 219.96,48.24 220.08,48.36 220.89,48.36 220.99,48.46 221.05,48.51 221.1,48.56 221.3,48.77 221.3,49.25 220.65,49.9 220.59,49.9 220.46,50.03 215.07,50.03 212.45,52.65 212.45,53.05 210.71,54.78 210.71,56.05 208.86,57.9 208.86,58.62 202.65,64.84 201.34,64.84 199.7,66.48 199.7,67.29 199.89,67.47 203.96,67.47
+1.8VALW on IN3 (solid shape): 224.21,49.57 224.21,48.58 224.09,48.46 221.31,48.46 221.22,48.55 221.22,48.71 221.19,48.74 221.19,49.64 221.31,49.77 224.02,49.77
+1.8VALW on IN3 (solid shape): 309.45,61.04 309.49,61.04 309.63,60.96 309.76,60.94 310.24,60.94 310.61,60.57 310.61,60.2 310.25,59.83 307.54,59.83 307.34,60.04 307.34,60.6 307.78,61.04 308.88,61.04 308.89,61.04 309.02,61.01 309.14,61.04 309.15,61.04
+1.8VALW on IN3 (solid shape): 297.66,58.94 297.66,58.59 297.57,58.35 297.66,58.12 297.66,56.56 297.66,56.28 297.63,56.21 297.56,56.18 297.25,55.97 297.3,55.59 297.32,55.53 297.3,55.46 297.25,55.09 297.56,54.88 297.63,54.85 297.66,54.78 297.66,54.02 293.26,49.62 277.34,49.62 277.21,49.75 277.21,50.74 277.41,50.94 278.16,50.94 278.74,50.37 280.03,50.37 280.11,50.28 288.67,50.28 288.76,50.37 293.16,50.37 293.42,50.63 293.54,50.63 296.49,53.57 296.49,59.12 296.67,59.3 297.3,59.3
+1.8VALW on IN3 (solid shape): outline of 162 points within 208.39,41.27 211.34,43.68
+1.8VALW on IN4 (solid shape): 200.45,67.53 201.33,67.53 203.02,65.84 203.02,65.27 202.27,64.52 201.53,64.52 199.45,66.6 199.45,67.14 199.86,67.54 200.44,67.54
+1.8VALW on IN4 (solid shape): 195.84,116.89 195.84,115.18 195.03,114.37 193.73,114.37 193.47,114.63 193.28,114.63 193.18,114.74 192.99,114.74 192.54,115.18 192.54,115.51 194.06,117.02 195.72,117.02
+1.8VALW on IN4 (solid shape): outline of 213 points within 189.18,102.48 192.22,113.15
+1.8VALW on TOP: 195.22,116.54 195.87,115.89 195.87,115.27 195.01,114.41 194.16,114.41 193.53,115.04 193.53,116.41 193.66,116.54
+1.8VALW on TOP: 221.31,49.65 222.89,49.65 222.96,49.58 222.96,48.32 222.8,48.16 221.85,48.16 219.4,45.71 210.51,45.71 209.85,46.37 209.85,49.41 210.09,49.65 213.91,49.65 215.15,48.42 220.79,48.42 221.19,48.81 221.19,49.53
+1.8VALW on TOP: 201.87,67.16 202.89,66.15 202.89,64.71 201.68,63.5 201.19,63.5 199.44,65.26 199.44,66.28 200.31,67.16
+1.8VALW on IN5: 214.17,47.11 197.94,63.34 197.94,88.23 195.27,90.9 195.27,100.36 194.06,101.57 194.06,116.41 194.23,116.58 199.21,116.58 199.21,105.61 199.74,105.08 206.6,105.08 206.83,104.85 206.83,96.17 205.88,95.22 205.88,58.94 214.91,49.9 223.34,49.9 223.34,47.53 222.92,47.11
+1.8VS_AUDIO on TOP (solid shape): 327.52,14.68 327.52,14.07 327.41,13.96 326.53,13.96 325.95,14.53 325.07,14.53 325,14.6 325,14.66 325.13,14.79 327.41,14.79
+1.8VS_AUDIO on TOP (solid shape): 41.08,34.33 41.08,34.32 41.17,34.24 41.17,33.35 41.13,33.31 40.14,33.31 39.86,33.59 39.86,34.4 40.03,34.57 40.84,34.57
+1.8VS_AUDIO on TOP (solid shape): 37.22,17.45 37.22,17.01 37.16,16.95 36.58,16.95 36.46,16.82 36.46,16.63 36.15,16.32 36.15,16.06 35.96,15.87 35.96,14.79 35.89,14.73 35.79,14.73 35.74,14.78 35.74,15.83 35.64,15.93 35.64,16.31 35.52,16.43 35.19,16.43 35.19,16.43 35.15,16.4 35.14,16.4 35.01,16.31 34.92,16.18 34.92,16.17 34.88,16.13 34.88,15.93 34.69,15.74 34.53,15.74 34.34,15.55 34.34,14.76 34.3,14.73 34.19,14.73 34.14,14.78 34.14,15.65 34.37,15.88 34.37,16.2 34.48,16.32 34.49,16.32 34.8,16.63 34.81,16.63 34.81,17.47 34.86,17.52 37.16,17.52
+1.8VS_AUDIO on BOTTOM (solid shape): 34.93,23.97 34.93,22.86 34.15,22.09 32.52,22.09 32.39,22.22 31.38,22.22 31.31,22.28 31.31,22.47 31.35,22.5 31.35,23.71 31.44,23.8 31.44,23.9 31.48,23.93 31.9,23.93 31.91,23.92 31.91,23.55 32.4,23.05 34.08,23.05 34.35,23.32 34.35,23.94 34.4,23.99 34.91,23.99
+1.8VS_AUDIO on IN1 (solid shape): outline of 370 points within 32.91,21.91 41.17,34.88
+1.8VS_AUDIO on IN1 (solid shape): outline of 519 points within 34.24,32.82 41.16,50.38
+1.8VS_AUDIO on IN2 (solid shape): 230.13,6.59 230.13,6.12 228.64,4.63 228.16,4.63 227.91,4.88 227.91,5.77 229.05,6.91 229.82,6.91
+1.8VS_AUDIO on IN2 (solid shape): 278.01,10.09 278.01,9.01 277.82,8.82 277.06,8.82 276.93,8.94 276.93,10.09 277.06,10.21 277.88,10.21
+1.8VS_AUDIO on IN2 (solid shape): outline of 255 points within 252.17,6.75 257.92,9.1
+1.8VS_AUDIO on IN4 (solid shape): 279.35,9.64 279.35,9.26 278.96,8.88 277.06,8.88 276.93,9.01 276.93,9.39 277.25,9.71 277.88,9.71 278.08,9.9 279.09,9.9
+1.8VS_AUDIO on IN4 (solid shape): 53.55,14.46 54.05,14.46 54.25,14.25 54.25,13.85 53.98,13.58 53.07,13.58 52.28,14.37 52.28,14.65 52.62,14.99 53.02,14.99
+1.8VS_AUDIO on IN4 (solid shape): 41.66,33.92 41.66,32.57 41.28,32.19 40.83,32.19 39.86,33.16 39.86,33.72 39.86,33.77 39.86,34.16 40.23,34.54 41.05,34.54
+1.8VS_AUDIO on IN4 (solid shape): 328.75,14.85 328.75,13.77 328.56,13.58 327.33,13.58 327.09,13.68 326.85,13.59 326.83,13.58 326.71,13.58 326.7,13.59 326.58,13.66 326.45,13.68 326.43,13.68 326.14,13.96 326.14,14.72 326.4,14.98 328.62,14.98
+1.8VS_AUDIO on IN4 (solid shape): 312.62,15.48 312.62,14.41 312.37,14.15 311.86,14.15 311.48,14.53 311.18,14.53 311.17,14.56 311.13,14.6 311.09,14.64 311.05,14.67 311,14.7 310.95,14.72 310.9,14.73 310.84,14.74 310.79,14.73 310.73,14.72 310.68,14.7 310.63,14.67 310.59,14.64 310.55,14.6 310.52,14.56 310.5,14.53 309.44,14.53 309.16,14.82 309.16,15.64 309.24,15.73 310.36,15.73 310.36,15.67 310.37,15.62 310.38,15.57 310.41,15.52 310.44,15.48 310.47,15.44 310.51,15.41 310.56,15.38 310.61,15.36 310.66,15.35 310.71,15.34 310.77,15.35 310.82,15.36 310.87,15.38 310.92,15.41 310.96,15.44 310.99,15.48 311.02,15.52 311.05,15.57 311.06,15.62 311.07,15.67 311.07,15.73 311.06,15.78 311.05,15.83 311.02,15.88 310.99,15.92 310.96,15.96 310.92,16 310.87,16.02 310.82,16.04 310.77,16.05 310.71,16.06 310.66,16.05 310.61,16.04 310.56,16.02 310.51,16 310.47,15.96 310.44,15.92 310.41,15.88 310.38,15.83 310.37,15.78 310.36,15.73 309.24,15.73 309.76,16.25 311.86,16.25
+1.8VS_AUDIO on IN4 (solid shape): outline of 318 points within 318.59,8.69 325.64,11.87
+1.8VS_AUDIO on IN6 (solid shape): 54.11,14.09 54.11,13.07 53.79,12.75 53.09,12.75 52.84,13.01 52.84,13.96 53.09,14.21 53.98,14.21
+1.8VS_AUDIO on IN6 (solid shape): 228.93,5.29 228.93,4.91 228.32,4.31 226.45,4.31 226.2,4.56 226.2,5.26 226.4,5.46 228.76,5.46
+1.8VS_AUDIO on IN6 (solid shape): outline of 98 points within 191.97,3.99 202.32,6.28
+1.8VSP on BOTTOM (solid shape): 227.46,50.03 227.46,46.42 227.29,46.24 223.26,46.24 222.78,45.76 222.78,45.76 222.78,44.39 222.63,44.24 220.98,44.24 220.76,44.41 220.49,44.37 220.49,44.63 219.97,45.15 219.97,47.08 219.99,47.09 222.17,47.09 223.11,48.03 225.02,48.03 225.21,47.95 225.42,47.99 225.77,48.03 225.92,48.35 225.9,48.47 225.85,48.59 225.85,49.97 225.95,50.06 227.42,50.06
+1.8VSP_AUDIO on BOTTOM (solid shape): 31.57,21.96 31.57,21.52 31.63,21.45 32.14,21.45 32.2,21.52 32.2,21.96 32.39,21.96 32.58,21.77 34.11,21.77 34.24,21.64 34.24,20.5 34.11,20.37 32.65,20.37 32.2,19.93 32.2,19.55 32.01,19.36 31.44,19.36 31.12,19.68 31.12,21.83 31.31,22.03 31.5,22.03
+1.35VS_B+ on TOP (solid shape): 260.93,27.04 260.93,25.64 260.74,25.45 260.74,24.82 260.55,24.63 259.79,24.63 259.66,24.76 257.69,24.76 257.44,24.5 256.93,24.5 256.8,24.63 256.8,25.07 256.66,25.21 256.66,25.42 256.61,25.42 256.61,26.98 256.87,27.23 260.74,27.23
+1.35VS_B+ on BOTTOM (solid shape): outline of 190 points within 255.85,22.91 261.56,33.07
+1.35VS_VGA on TOP (solid shape): outline of 56614 points within 189.81,47.81 287.09,120.06
+1.35VS_VGA on BOTTOM (solid shape): 271.53,64.44 271.53,61.27 271.28,61.01 267.6,61.01 267.22,61.4 267.22,64.44 267.6,64.82 271.15,64.82
+1.35VS_VGA on BOTTOM (solid shape): 248.56,107.12 248.56,106.29 248.49,106.2 248.46,106.11 248.45,106.09 248.26,105.89 248.21,105.86 248.18,105.83 247.96,105.83 247.83,105.96 247.67,105.97 247.52,105.96 247.42,105.86 247.19,105.86 247.1,105.95 247.1,106.19 247.48,106.58 247.63,106.58 248.27,107.23 248.45,107.23
+1.35VS_VGA on BOTTOM (solid shape): 270.77,50.22 270.77,47.43 270.32,46.97 269.59,46.97 269.59,47.53 268.84,47.53 268.84,46.97 268.39,46.97 268.39,47.53 267.64,47.53 267.64,46.97 264.31,46.97 264.31,47.49 263.56,47.49 263.56,46.95 263.11,46.95 263.11,47.5 262.36,47.5 262.36,46.95 261.59,46.95 261.06,47.49 261.06,50.16 261.31,50.41 270.58,50.41
+1.35VS_VGA on BOTTOM (solid shape): 247.14,93.09 247.18,93.16 247.26,93.19 247.27,93.19 247.33,93.15 247.35,93.08 247.56,92.75 247.93,92.87 248.17,92.87 248.21,92.84 248.46,92.59 248.46,92.57 248.51,92.47 248.59,92.38 248.59,91.62 248.5,91.51 248.45,91.38 248.45,91.36 248.34,91.25 247.78,91.25 247.77,91.25 247.67,91.27 247.57,91.25 247.56,91.25 247.24,91.25 247.14,91.35
+1.35VS_VGA on BOTTOM (solid shape): 229.6,90.15 229.68,90.11 229.7,90.03 229.7,89.99 229.69,89.95 229.65,89.87 229.56,89.85 229.18,89.69 229.29,89.29 229.29,89.1 228.93,88.74 228.87,88.7 228.82,88.65 227.97,88.65 227.96,88.68 227.89,88.78 227.78,88.85 227.77,88.85 227.59,89.02 227.59,89.33 227.69,89.55 227.59,89.77 227.59,90.05 227.69,90.15
+1.35VS_VGA on BOTTOM (solid shape): 246.02,90 246.02,89.75 245.95,89.55 246.02,89.35 246,88.88 245.89,88.77 245.87,88.77 245.73,88.74 245.62,88.65 244.77,88.65 244.76,88.68 244.69,88.78 244.58,88.85 244.57,88.85 244.35,89.07 244.35,89.29 244.41,89.34 244.46,89.41 244.53,89.47 244.62,89.44 244.63,89.43 245.06,89.36 244.99,89.79 244.99,89.79 244.93,89.84 244.94,89.87 244.94,89.92 244.93,89.97 244.95,90.06 245.03,90.1 245.92,90.1
+1.35VS_VGA on BOTTOM (solid shape): 226.53,99.49 226.57,99.41 226.57,95.47 226.45,95.35 226.3,95.35 226.25,95.41 226.16,95.41 226.15,95.41 225.91,95.46 225.71,95.33 225.51,95.33 225.12,95.72 225.12,96.65 225.16,96.71 225.18,96.79 225.43,97.04 225.46,97.06 225.66,97.06 225.74,96.98 225.8,96.98 225.81,96.97 226.19,97.02 226.25,97.4 226.25,97.41 226.25,97.44 226.12,97.56 225.97,97.57 225.84,97.56 225.78,97.51 225.74,97.47 225.71,97.44 225.48,97.44 225.27,97.65 225.27,97.66 225.2,97.77 225.1,97.84 225.07,97.85 225.07,98.7 225.14,98.78 225.18,98.87 225.18,98.89 225.43,99.14 225.45,99.15 225.72,99.15 225.75,99.12 225.87,99.01 226.15,99.01 226.3,99.16 226.3,99.43 226.31,99.47 226.34,99.48 226.39,99.49 226.43,99.5
+1.35VS_VGA on BOTTOM (solid shape): 225.74,103.33 225.97,103.23 226.19,103.33 226.47,103.33 226.57,103.23 226.57,100.19 226.53,100.11 226.43,100.1 226.36,100.12 226.29,100.12 226.26,100.11 226.21,100.17 226.21,100.17 225.78,100.24 225.85,99.81 225.88,99.78 225.89,99.73 225.84,99.7 225.7,99.55 225.47,99.55 225.17,99.85 225.17,99.86 225.12,99.95 225.05,100.02 225.05,100.8 225.52,101.27 225.71,101.27 226.28,101.37 225.83,101.74 225.82,101.73 225.79,101.73 225.73,101.67 225.45,101.67 225.17,101.95 225.17,101.96 225.13,102.03 225.07,102.1 225.07,102.9 225.12,102.95 225.16,103.01 225.47,103.33
+1.35VS_VGA on BOTTOM (solid shape): 225.8,94.84 225.8,94.65 225.8,94.24 226.21,94.33 226.21,94.34 226.26,94.39 226.29,94.38 226.36,94.38 226.43,94.4 226.53,94.39 226.57,94.31 226.57,91.3 226.44,91.18 226.19,91.18 225.97,91.27 225.75,91.18 225.41,91.18 225.37,91.2 225.33,91.21 225.21,91.33 225.19,91.33 225.14,91.37 225.14,92.42 225.2,92.51 225.22,92.61 225.23,92.63 225.35,92.75 225.36,92.76 225.43,92.79 225.49,92.83 225.69,92.83 225.74,92.78 225.74,92.76 225.76,92.74 225.8,92.74 225.81,92.73 225.97,92.69 226.13,92.73 226.14,92.74 226.17,92.74 226.3,92.87 226.3,92.91 226.3,92.92 226.33,93.05 226.3,93.18 226.29,93.21 226.22,93.3 226.13,93.37 226.11,93.38 225.9,93.4 225.71,93.29 225.48,93.29 225.14,93.63 225.14,94.52 225.19,94.59 225.21,94.66 225.22,94.67 225.52,94.97 225.66,94.97
+1.35VS_VGA on BOTTOM (solid shape): 248.64,104.98 248.64,104.24 248.62,104.23 248.52,104.14 248.46,104.03 248.46,104.01 248.21,103.76 248.17,103.73 247.93,103.73 247.35,103.55 247.93,103.37 248.17,103.37 248.21,103.34 248.27,103.3 248.45,103.12 248.46,103.1 248.49,102.99 248.57,102.9 248.57,102.05 248.51,101.98 248.47,101.91 248.47,101.9 248.27,101.7 248.21,101.66 248.17,101.63 247.93,101.63 247.35,101.45 247.93,101.27 248.17,101.27 248.21,101.24 248.27,101.2 248.39,101.08 248.39,101.07 248.45,100.96 248.54,100.87 248.54,99.9 248.51,99.87 248.48,99.84 248.21,99.56 248.17,99.53 247.93,99.53 247.88,99.59 247.81,99.64 247.75,99.71 247.78,99.8 247.79,99.81 247.86,100.24 247.43,100.17 247.43,100.17 247.38,100.11 247.31,100.12 247.26,100.11 247.18,100.14 247.14,100.21 247.14,104.2 247.63,104.68 247.65,104.68 247.91,104.84 247.87,105.13 247.84,105.2 247.87,105.27 247.99,105.4 248.22,105.4
+1.35VS_VGA on BOTTOM (solid shape): 244.21,90.1 244.29,90.06 244.31,89.97 244.31,89.95 244.27,89.89 244.2,89.87 243.87,89.66 243.99,89.29 243.99,89.05 243.71,88.76 243.69,88.76 243.61,88.73 243.54,88.67 243.35,88.68 242.66,88.68 242.65,88.7 242.58,88.79 242.48,88.85 242.47,88.85 242.25,89.07 242.25,89.29 242.07,89.87 241.89,89.29 241.89,89.12 241.88,89.08 241.53,88.74 241.48,88.71 241.44,88.67 241.26,88.68 240.78,88.68 240.59,88.67 240.54,88.72 240.47,88.75 240.15,89.07 240.15,89.29 239.97,89.87 239.79,89.29 239.79,89.1 239.43,88.74 239.37,88.7 239.32,88.65 238.52,88.65 238.45,88.71 238.38,88.75 238.37,88.75 238.17,88.95 238.15,88.97 238.09,89.03 238.08,89.04 238.05,89.08 238.05,89.29 238.11,89.34 238.16,89.41 238.23,89.47 238.32,89.44 238.34,89.42 238.76,89.36 238.7,89.78 238.69,89.79 238.63,89.85 238.64,89.87 238.64,89.92 238.63,89.97 238.65,90.06 238.73,90.1
+1.35VS_VGA on BOTTOM (solid shape): 247.14,99.39 247.18,99.46 247.26,99.49 247.27,99.49 247.33,99.45 247.35,99.38 247.56,99.05 247.93,99.17 248.17,99.17 248.21,99.14 248.46,98.89 248.46,98.87 248.51,98.77 248.59,98.68 248.59,97.92 248.5,97.82 248.46,97.7 248.45,97.68 248.27,97.5 248.21,97.46 248.17,97.43 247.93,97.43 247.35,97.25 247.93,97.07 248.17,97.07 248.21,97.04 248.27,97 248.62,96.65 248.62,95.83 248.52,95.75 248.46,95.63 248.46,95.61 248.21,95.36 248.17,95.33 247.93,95.33 247.35,95.15 247.93,94.97 248.17,94.97 248.23,94.93 248.29,94.89 248.3,94.89 248.35,94.84 248.35,94.82 248.42,94.66 248.56,94.55 248.59,94.54 248.59,93.72 248.51,93.63 248.46,93.53 248.46,93.51 248.21,93.26 248.17,93.23 247.93,93.23 247.88,93.29 247.81,93.34 247.75,93.41 247.78,93.5 247.79,93.51 247.86,93.94 247.43,93.87 247.43,93.87 247.38,93.81 247.31,93.82 247.26,93.81 247.18,93.84 247.14,93.91
+1.35VS_VGA on BOTTOM (solid shape): 231.12,90.1 237.91,90.1 237.99,90.06 238.01,89.97 238.01,89.95 237.97,89.89 237.9,89.87 237.57,89.66 237.69,89.29 237.69,89.08 237.66,89.05 237.65,89.03 237.37,88.75 237.36,88.75 237.29,88.71 237.22,88.65 236.37,88.65 235.95,89.07 235.95,89.29 235.77,89.87 235.59,89.29 235.59,89.1 235.14,88.65 234.27,88.65 234.26,88.68 234.19,88.78 234.08,88.85 234.07,88.85 233.85,89.07 233.85,89.29 233.67,89.87 233.49,89.29 233.49,89.07 233.17,88.75 233.16,88.75 233.09,88.71 233.02,88.65 232.17,88.65 231.75,89.07 231.75,89.29 231.57,89.87 231.39,89.29 231.39,89.1 231.03,88.74 230.98,88.71 230.94,88.67 230.75,88.68 230.07,88.68 229.89,88.85 229.65,89.1 229.65,89.29 229.77,89.43 229.78,89.62 229.8,89.68 229.85,89.68 229.88,89.67 229.91,89.64 229.91,89.61 230.21,89.29 230.4,89.68 230.4,89.69 230.4,89.89 230.33,89.96 230.32,90.03 230.34,90.11 230.42,90.15 231.07,90.15
+1.35VS_VGA on IN1 (solid shape): outline of 1168 points within 224.67,88.25 238.01,103.4
+1.35VS_VGA on IN1 (solid shape): outline of 1245 points within 238.03,88.25 248.97,106.3
+1.35VS_VGA on IN1 (solid shape): outline of 2977 points within 190.31,88.33 206.86,103.89
+1.35VS_VGA on IN1 (solid shape): outline of 17892 points within 190.31,47.72 286.58,122.25
+1.35VS_VGA on IN2 (solid shape): outline of 16345 points within 188.29,47.94 287.28,119.51
+1.35VS_VGA on IN3 (solid shape): outline of 41751 points within 190.45,53.01 288.17,121.09
+1.35VS_VGA_PGOOD on TOP (solid shape): 277.45,148.43 277.45,147.07 277.36,147.04 277.28,146.98 277.02,147.07 276.77,146.94 276.59,146.94 276.42,147.04 276.23,147.03 276.14,147.11 276.14,148.09 276.36,148.3 276.37,148.3 276.55,148.48 277.4,148.48
+1.35VS_VGAP on BOTTOM (solid shape): 262.96,46.82 263.71,46.82 263.71,47.34 264.16,47.34 264.16,46.82 267.79,46.82 267.79,47.34 268.24,47.34 268.24,46.82 268.99,46.82 268.99,47.34 269.44,47.34 269.44,46.83 270.31,46.83 270.71,46.43 270.71,41.27 269.88,40.44 265.88,40.44 263.6,38.15 253.12,38.15 252.17,39.11 252.17,42.22 254.58,44.63 254.58,46.6 254.96,46.98 260.98,46.98 261.14,46.82 262.51,46.82 262.51,47.34 262.96,47.34
+1V8_AON on BOTTOM (solid shape): 207.11,124.97 207.11,123.38 206.99,123.26 205.45,123.26 205.34,123.37 205.34,125 205.41,125.07 207,125.07
+1V8_AON on BOTTOM (solid shape): 201.39,116.78 201.39,116.64 201.21,116.47 201.21,115.35 200.76,114.9 200.76,114.41 200.55,114.19 199.58,114.19 199.35,114.28 199.11,114.19 198.75,114.19 198.63,114.27 198.48,114.29 198.34,114.27 198.22,114.19 197.45,114.19 197.35,114.29 197.35,114.97 197.62,115.25 198.3,115.25 198.42,115.13 199.23,115.13 199.3,115.2 199.3,115.87 199.69,116.26 200.06,116.26 200.22,116.42 200.29,116.48 200.35,116.55 200.77,116.97 201.2,116.97
+1V8_AON on BOTTOM (solid shape): 193.15,113.13 193.83,112.45 194.12,112.45 194.21,112.54 194.38,112.54 194.79,112.96 195.02,112.96 195.02,112.95 195.93,112.95 195.98,112.91 195.98,111.74 195.58,111.34 195.58,110.55 195.4,110.37 193.33,110.37 193.26,110.4 193.23,110.47 193.23,110.83 192.92,111 192.71,110.94 192.58,110.78 192.51,110.72 192.41,110.75 192.1,111.06 192.1,112.84 192.47,113.22 193.15,113.22
+1V8_AON on BOTTOM (solid shape): outline of 186 points within 201.96,108.24 205.42,116.41
+1V8_AON on IN2 (solid shape): outline of 6255 points within 192.68,107.74 225.75,126.48
+1V8_AON on IN4 (solid shape): 235.91,122.14 235.91,121.48 235.72,121.28 235.35,121.73 235.04,121.24 234.76,121.24 234.68,121.31 234.68,122.13 235.06,122.51 235.54,122.51
+1V8_AON on IN5: 217.81,112.55 217.79,112.58 199.72,112.58 199.72,123.58 200.14,124.01 206.47,124.01 206.6,123.88 217.84,123.88 218.26,123.46 218.26,117.61 218.77,117.11 218.77,113.51
+1V8_MAIN on TOP (solid shape): 204.67,109.34 205.84,109.34 205.99,109.19 205.99,108.33 205.82,108.16 205.48,108.16 205.29,108.36 204.57,108.36 204.05,108.88 201.51,108.88 201.42,108.96 201.42,109.77 201.5,109.85 204.16,109.85
