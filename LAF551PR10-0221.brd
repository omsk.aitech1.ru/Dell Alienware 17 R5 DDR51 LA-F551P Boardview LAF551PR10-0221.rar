# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SPI_CS#: length 239.2
  TOP w0.114: v2(322.4,13.31) 322.18,13.08 UE1.14
  IN3 w0.127: v2(191.37,14.43) 191.37,13.94 191.21,13.77 189.56,13.77 189.11,14.21 188.02,14.21 184.61,17.62 180.57,17.62 180.04,18.15 170.44,18.15 169.24,19.36 136.79,19.36 135.96,18.53 114.69,18.53 110.09,13.93 105.96,13.93 103.63,16.26 v2(103.63,17.2)
  IN4 w0.127: v2(225.78,11.23) 225.95,11.4 225.95,12.32 227.69,14.06 250.98,14.06 251.5,14.58 260.76,14.58 260.97,14.8 264.22,14.8 265.18,15.76 276.54,15.76 276.96,16.18 292.66,16.18 295.07,13.77 303.96,13.77 304.89,14.7 305.82,14.7 307.4,16.27 308.77,16.27 309.17,16.67 312.1,16.67 313.28,15.48 313.48,15.48 314.71,15.48 316.62,13.58 317.12,13.58 317.4,13.31 v2(322.4,13.31)
  IN6 w0.081: v2(225.78,11.23) 225.34,11.67 222.41,11.67 221.52,10.79 207.72,10.79 206.36,12.15 201.21,12.15 199.84,10.79 195.13,10.79 194.68,11.24 193.83,11.24 191.78,13.29 191.78,13.96 191.37,14.37 v2(191.37,14.43)
  BOTTOM w0.114: RE12.2 103.42,17 v2(103.63,17.2) UE2.1
SPI_MISO: length 257.7
  TOP w0.102: UE1.16 321.75,14.08 322.04,14.37 322.93,14.37 323.38,13.92 323.38,13.48 v2(322.4,12.5)
  IN1 w0.102: v2(129.93,24.31) 134.07,28.45 157.29,28.45 158,27.74 160.47,27.74 160.73,27.99 170.39,27.99 185.17,13.21 188.68,13.21 188.74,13.15 189.42,13.15 190.03,12.53 197.65,12.53 198.02,12.16 206.53,12.16 206.86,12.49 215.42,12.49 215.94,13 218.95,13 218.95,13 221.51,13 221.55,13.04 238.36,13.04 240.31,14.99 251.1,14.99 251.99,15.88 255.8,15.88 256.26,15.42 256.26,15.42 257.62,14.06 263.66,14.06 264.06,14.47 264.99,14.47 265.69,15.17 271.9,15.17 272.04,15.31 276.27,15.31 277.42,16.46 280.69,16.46 284.09,19.87 290.66,19.87 292.22,18.3 293.35,18.3 294.41,17.25 298.26,17.25 298.45,17.44 298.98,17.44 299.16,17.25 299.81,17.25 301.27,15.79 301.42,15.79 303.66,13.55 311.16,13.55 313.98,10.72 322.22,10.72 322.4,10.9 v2(322.4,12.5)
  IN6 w0.102: v2(129.93,24.31) 128.75,23.13 114.21,23.13 111.77,20.69 102.37,20.69 v2(101.93,20.25)
  BOTTOM w0.114: RE10.2 101.99,15.03 101.62,14.66 99.87,14.66 98.98,15.55 98.98,19.73 99.5,20.25 v2(101.93,20.25)
SPI_MOSI: length 261.8
  TOP w0.114: v2(324.56,13.06) 324.56,13.33 323.07,14.81 321.95,14.81 321.72,14.58 UE1.17
  IN6 w0.081: v2(324.56,13.06) 324.56,13.14 324.37,13.33 323.67,13.33 323.26,12.91 321.37,12.91 321.1,12.64 319.96,12.64 317.29,9.96 305.18,9.96 301.62,13.52 296.86,13.52 296.83,13.54 292.14,13.54 291.59,13 287.41,13 287.13,13.28 272.09,13.28 271.71,12.9 260.15,12.9 258.05,10.8 255.62,10.8 255.11,10.29 254.43,10.29 253.93,9.8 253.93,8.55 252.88,7.49 238.72,7.49 237.05,9.16 237.05,9.77 236.28,10.54 233.33,10.54 232.2,9.42 229.79,9.42 229.02,8.65 227.74,8.65 226.66,7.57 204.01,7.57 204.01,7.57 203.75,7.83 194.31,7.83 193.14,9.01 190.25,9.01 188.54,10.72 186.63,10.72 178.02,19.34 158.73,19.34 157.6,18.21 129.46,18.21 127.06,15.81 127.06,15.34 124.2,12.49 123.75,12.49 122.83,11.57 122.61,11.57 122.61,11.57 114.43,11.57 109.65,16.34 103.49,16.34 102.2,17.64 94.63,17.64 v2(94.51,17.52)
  BOTTOM w0.114: RE9.2 96.54,22.65 95.72,22.65 94.51,21.44 v2(94.51,17.52)
SPK_L+_CONN: length 26.7
  IN1 w1.016: 43.54,14.37 42.62,13.45 42.62,11.1 41.21,9.69 38.86,9.69 37.11,7.94 36.09,7.94
  IN3 w1.016: 36.78,8.25 37.6,9.07 37.6,14.02 36.46,15.17 32.14,15.17 30.43,16.88 30.43,17.64
  vias: v1(44.74,14.85) v2(29.78,18.73) v2(30.37,18.73) v2(36.01,7.04) v2(36.46,6.66) v2(44.65,14.28) v2(45.28,14.28) v2(47.89,14.28) v2(48.48,14.28)
SPK_L-_CONN: length 29.8
  TOP w0.102: v2(45.54,12.56) v1(44.41,12.56)
  IN1 w1.016: 39.06,6.79 40.33,8.06 42.81,8.06 43.95,9.2 43.95,12.54
  IN3 w1.016: 32.39,17.52 38.61,17.52 40.2,15.93 40.2,11.93 41.16,10.98 41.16,8.82 38.74,6.4
  vias: v2(32.13,18.79) v2(32.72,18.79) v2(39.31,5.65) v2(39.31,5.01) v2(45.54,13.2) v2(47.82,12.47) v2(48.46,12.47)
SPK_R+_CONN: length 24.8
  IN3 w1.016: 28.01,12.44 28.46,11.99 28.46,9.71 28.71,9.45 28.71,7.29 27.76,6.34
  IN4 w1.016: 27.76,6.4 29.6,8.25 31.5,8.25 31.82,7.93 37.28,7.93 39.06,9.71 41.35,9.71 41.54,9.9 44.01,9.9
  vias: v1(28.32,5.03) v2(27.06,13.58) v2(27.06,12.94) v2(27.06,5.64) v2(27.69,5.64) v2(44.97,9.77) v2(45.47,10.15) v2(47.86,10.24) v2(48.49,10.24)
SPK_R-_CONN: length 28.1
  TOP w0.102: v2(45.53,8.04) v1(44.74,8.04)
  IN3 w1.016: 30.17,5.32 30.17,6.72 30.04,6.85 30.04,8.88 30.49,9.33 30.49,12.44 28.01,14.91 28.01,15.61
  IN4 w1.016: 30.49,4.12 32.58,4.12 33.32,4.85 35.33,4.85 35.99,5.52 37.73,5.52 40.22,8 44.59,8
  vias: v2(27.06,16.12) v2(27.06,15.48) v2(28.94,3.42) v2(29.54,3.42) v2(45.51,8.64) v2(47.86,8.2) v2(48.49,8.2)
SRN_CHG: length 1.8
  TOP w0.203: PU700.19 57.84,21.33 57.9,21.27 57.9,20.81 PR723.1
SRP_CHG: length 1.6
  TOP w0.203: PU700.20 58.24,21.1 58.37,20.97 PR722.1
SS: length 10.2
  TOP w0.254: v2(271.5,141.63) 271.19,141.94 267.32,141.94 266.84,142.42 v1(266.56,142.42) v2(265.76,142.42)
  BOTTOM w0.203: PC6017.1 271.07,141.63 v2(271.5,141.63) 271.63,141.63 272.19,141.07 PU6000.28
  BOTTOM w0.254: v2(265.76,142.42) PC6002.2 PR6015.2
STRAP0: length 18.9
  TOP w0.102: v2(220.05,117.87) 219.77,117.59 217.63,117.59 216.86,116.83 v1(216.35,116.83) 215.32,116.83 212.9,114.4 209.81,114.4 206.71,111.31 RG78.1 RG90.2
  BOTTOM w0.1: UG9.BL3 v2(220.05,117.87)
STRAP1: length 20.2
  TOP w0.102: RG79.1 205.25,112.45 RG91.2 204.81,113.27 208.35,113.27 209.71,114.63 212.8,114.63 215.31,117.14 216.91,117.14 217.73,117.97 v1(218.32,117.97) 218.77,118.42 219.5,118.42 219.63,118.29 220.33,118.29 v2(220.77,117.85)
  BOTTOM w0.1: UG9.BL4 v2(220.77,117.85)
STRAP2: length 7.9
  TOP w0.089: v2(220.74,118.58) 220.74,118.57 v1(221.1,118.21)
  IN1 w0.089: v2(216.1,118.23) 217.27,119.4 219.92,119.4 v2(220.74,118.58)
  BOTTOM w0.089: RG80.1 RG92.2 v2(216.1,118.23)
  BOTTOM w0.1: UG9.BM4 v2(220.74,118.58)
STRAP3: length 122.9
  TOP w0.102: v1(200.66,110.48) 200.72,110.42 RG93.2 RG81.1 201.61,111.37 201.43,111.55 v2(201.43,112.77)
  IN4 w0.102: v2(179.6,73.03) 178.28,71.7 178.28,61.8 177.17,60.7 177.17,53.52 177.75,52.95 177.75,50.92 178.82,49.84 179.46,49.84 179.69,49.61 179.69,49.61 179.93,49.37 179.93,48.92 182.8,46.05 182.8,44.36 184.79,42.37 184.79,39.58 v2(185.14,39.23)
  IN6 w0.089: 215.02,117.73 216.21,117.73 217.15,118.67 217.79,118.67 218.35,119.23 220.79,119.23 v2(221.44,118.58)
  IN6 w0.102: 215.02,117.73 214.31,117.73 214.3,117.75 213.96,117.75 213.95,117.73 213.06,117.73 212.77,117.44 212.77,117.24 211.44,115.9 208.9,115.9 208.43,116.37 204.85,116.37 201.43,112.96 v2(201.43,112.77) 201.11,112.45 201.11,111.25 198.63,108.77 197.68,108.77 196.52,107.6 193.96,107.6 193.73,107.37 191.44,107.37 188.54,104.47 188.28,104.47 184.71,100.89 184.71,94.86 185.06,94.5 185.06,78.43 183.07,76.44 182.21,76.44 181.42,75.65 181.2,75.65 180.98,75.44 180.98,74.41 v2(179.6,73.03)
  BOTTOM w0.089: UG9.BM5 v2(221.44,118.58)
  BOTTOM w0.102: v2(185.14,39.23) 185.17,39.27 186.97,39.27 187.12,39.12 187.12,37.92 DG8.2
STRAP3_PCH: length 29.3
  IN4 w0.089: 192.1,32.39 194.05,32.39 195.27,31.17 195.66,31.17 198.45,28.38 198.45,27.21
  IN4 w0.102: v2(185.86,36.49) 186.64,35.72 186.64,34.41 187.28,33.76 187.55,33.49 188.63,33.49 188.86,33.72 190.51,33.72 191.84,32.39 192.1,32.39 ; 198.45,27.21 198.45,25.51 199.01,24.95 199.27,24.95 199.79,24.43 199.79,21.53 199.26,21 v2(199.14,21)
  BOTTOM w0.089: UH1.M45 199.07,20.93 v2(199.14,21)
  BOTTOM w0.102: RG555.2 187.05,35.87 DG8.1 186.76,36.24 186.51,36.49 v2(185.86,36.49)
STRAP4: length 28.2
  TOP w0.102: RG82.1 RG94.2 201.93,113.99 v2(201.81,114.1) 202.12,114.4 v1(202.47,114.4)
  IN6 w0.102: v2(221.47,117.15) 221.84,117.52 221.84,118.71 221.09,119.46 217.78,119.46 217.31,118.99 213.45,118.99 212.39,117.93 212.39,117.18 211.43,116.22 208.9,116.22 208.46,116.67 204.38,116.67 v2(201.81,114.1)
  BOTTOM w0.1: UG9.BK5 v2(221.47,117.15)
STRAP5: length 124.6
  TOP w0.089: RG83.1 218.23,116.25 v1(219.44,116.25) 220.39,116.25 220.58,116.06 221,116.06 v2(221.43,116.49) 221.47,116.53 RG95.2
  TOP w0.102: v2(179.6,72.43) 179.7,72.43 180.29,73.02 RG575.2
  IN4 w0.102: v2(179.6,72.43) 179.33,72.43 178.51,71.61 178.51,61.71 177.4,60.6 177.4,53.86 179.08,52.19 179.08,51.36 180.29,50.16 180.29,48.89 183.03,46.14 183.03,44.46 185.49,42 185.49,39.45 185.54,39.4 185.54,39.02 185.17,38.65 185.17,38.65 v2(185.14,38.65)
  IN6 w0.102: v2(179.6,72.43) 179.68,72.43 181.9,74.65 181.9,75.27 182.57,75.94 183.22,75.94 185.54,78.27 185.54,94.7 185.25,94.99 185.25,100.54 185.72,101.01 185.72,101.15 187.37,102.8 188.41,102.8 189.25,103.64 189.25,104.53 191.64,106.91 193.92,106.91 194.15,107.14 196.39,107.14 198,105.53 200.36,105.53 202.26,107.43 202.26,111.4 203.52,112.67 205.97,112.67 206.96,113.66 213.45,113.66 214.02,114.23 215.65,114.23 216.87,115.45 217.64,115.45 218.02,115.07 220.01,115.07 v2(221.43,116.49)
  BOTTOM w0.089: UG9.BJ5 v2(221.43,116.49)
  BOTTOM w0.102: DG9.2 186.5,38.65 185.17,38.65 v2(185.14,38.65)
STRAP5_PCH: length 38.1
  IN2 w0.089: v2(198.64,17.14) 198.57,17.07 196.47,17.07 196.36,16.96 ; 194.99,16.96 194.89,17.06 194.89,18.34 193.27,19.96
  IN2 w0.102: 196.36,16.96 196.11,16.7 195.25,16.7 194.99,16.96 ; v2(184.18,25.58) 184.29,25.58 184.92,24.95 184.92,22.57 185.02,22.47 189.11,22.47 191.46,20.12 193.11,20.12 193.27,19.96
  BOTTOM w0.089: v2(198.64,17.14) 198.64,17.64 198.8,17.81 UH1.L48
  BOTTOM w0.102: v2(184.18,25.58) 184.18,25.86 184.86,26.53 184.86,32.65 184.91,32.7 184.91,35.14 185.14,35.37 187.22,35.37 v1(188.57,36.73) 188.79,36.95 188.79,37.46 188.6,37.65 RG556.2 188.22,37.68 DG9.1
SUSACK#: length 115
  TOP w0.114: v2(299.03,20.06) 298.82,19.85 298.82,18.15 299.37,17.6 299.37,17 299.63,16.74 299.63,16.17 299.78,16.03 299.78,14.87 302.78,11.87 302.97,11.87 303.22,11.61 UE5.97 ; v2(224.35,21.35) 224.21,21.2 222.35,21.2 221.85,21.7 221.85,23.26 221.95,23.37 v1(221.95,23.59) 221.95,24.28 221.19,25.04 221.17,25.04 221.14,25.07 220.67,25.07 220.48,25.26 218.8,25.26 v2(217.99,24.45)
  IN6 w0.081: v2(299.03,20.06) 298.32,20.77 293.7,20.77 293.34,21.13 276.52,21.13 276.13,21.53 273.04,21.53 271.42,23.15 270.71,23.15 270.5,23.15 270.47,23.12 270.43,23.12 269.82,22.5 267.73,22.5 267.15,23.09 265.16,23.09 264.62,22.54 261.56,22.54 260.15,23.96 260.15,26.87 259.65,27.37 256.92,27.37 255.91,28.38 252.74,28.38 251.95,27.59 249.87,27.59 244.55,22.27 244.55,21.62 242.52,19.58 237,19.58 235.7,20.88 235.7,21.68 234.85,22.53 230.04,22.53 229.44,21.93 224.93,21.93 v2(224.35,21.35)
  BOTTOM w0.089: 215.72,24.06 215.38,24.06 UH1.BE35
  BOTTOM w0.122: 215.72,24.06 216.49,24.83 217.61,24.83 v2(217.99,24.45)
SUSCLK: length 187.6
  IN6 w0.081: v2(299.41,18.41) 298.97,17.96 297.32,17.96 296.6,18.67 293.19,18.67 292.7,18.18 280.76,18.18 280.03,18.91 277.95,18.91 277.19,18.15 276.87,18.15 v2(276.74,18.28) 276.77,18.31 276.77,19.01 275.55,20.24 272.45,20.24 272.33,20.36 267.14,20.36 266.45,21.05 260.74,21.05 255.99,25.8 250.3,25.8 247.98,23.48 247.98,19.27 247.46,18.75 247.46,18.32 247.19,18.05 246.76,18.05 246.02,17.31 242.4,17.31 241.42,18.29 236.46,18.29 234.98,19.78 233.54,19.78 232.8,19.04 v2(232.8,19) 232.25,19.55 227.28,19.55 226.75,20.08 223.82,20.08 222.64,21.26 221.61,21.26 221.27,20.92 219.18,20.92
  IN6 w0.089: 219.18,20.92 218.55,20.92 218.4,20.77 218.4,20.08 217.9,19.58 217.27,19.58 216.92,19.94 v2(215.03,19.94)
  BOTTOM w0.114: JSSD2.68 278.67,9.31 276.81,11.16 276.81,18.21 v2(276.74,18.28) ; JSSD1.68 328.48,33.16 327.61,34.03 v1(323.85,34.03) 322.25,34.03 321.22,35.05 321.22,37.93 320.82,38.33 320.82,39.61 321.34,40.13 321.34,41.22 320.56,42 320.56,42.09 318.7,43.95 317.43,43.95 316.56,44.82 313.64,44.82 312.57,43.76 JWLAN.42 312.57,41.6 311.86,40.88 310.78,40.88 307.51,37.61 307.51,35.09 304.21,31.79 304.21,30.11 299,24.91 299,21.36 299.54,20.82 299.54,18.53 v2(299.41,18.41) ; JSSD3.68 237.27,9.3 237.05,9.52 237.05,9.96 236.36,10.66 233.67,10.66 233.18,11.15 233.18,18.62 v2(232.8,19)
  BOTTOM w0.122: UH1.BE45 215.29,19.49 v2(215.03,19.94)
SUSP#: length 704.5
  TOP w0.114: Q8.3 321.24,43.57 v2(321.06,43.74) ; v2(53.54,8.75) 53.54,12.44 56.71,15.61 60.27,15.61 61.22,16.56 61.22,18.91 62.05,19.74 62.05,20.5 62.68,21.14 63.64,21.14 63.95,20.82 63.95,20.31 64.08,20.18 64.91,20.18 v2(64.91,20.19) ; v2(182.95,77.52) 184.13,77.52 184.4,77.79 184.4,79.87 184,80.28 U20.4 ; v2(304.49,16.11) 304.49,18.85 304.84,19.2 306.01,19.2 306.02,19.21 UE5.116
  IN3 w0.127: v2(126.11,118.6) 126.11,118.56 124.6,117.04 124.6,114.8 123.34,113.54 123.34,102.44 120.91,100.01 v2(120.91,98.29) 120.91,97.14 118.31,94.54 118.31,91.57 117.01,90.27 117.01,75.02 105.69,63.69 105.69,61.96 105.18,61.46 104.78,61.46 102.62,59.3 102.62,56.9 101.89,56.17 101.89,54.04 99.37,51.52 v2(99.37,49.22) ; v2(304.49,16.11) 305.25,15.36 306.4,15.36 307.49,16.45 309.77,16.45 310.08,16.75 310.59,16.75 312.05,18.22 312.05,18.98 313.19,20.12 313.19,21.9 312.24,22.85 312.24,23.68 313.49,24.92 313.49,27.59 314.02,28.12 314.02,30.41 315.88,32.27 315.88,36.91 316.33,37.36 316.33,39.4 316.18,39.78 316.18,40.76 315.76,41.17 315.76,42.69 316.75,43.68 321,43.68 v2(321.06,43.74)
  IN4 w0.127: v2(99.37,49.22) 99.37,48.55 95.64,44.82 95.64,41.77 95.96,41.46 97.87,41.46 99.2,40.13 99.2,37.18 100.92,35.46 100.92,32.25 97.54,28.88 97.54,26.69 93.96,23.1 85.48,23.1 84.97,23.61 78.81,23.61 75.75,20.55 75.75,20.15 75.55,19.94 74.79,19.94 74.21,20.51 65.24,20.51 v2(64.91,20.19)
  IN6 w0.081: v2(53.54,8.75) 53.54,8.56 52.46,7.48 42.81,7.48 42.3,7.99 34.49,7.99 30.15,12.34 v2(26.93,12.34) ; v2(126.11,118.6) 126.63,119.12 126.63,122.94 124.62,124.95 124.62,126.52 119.62,131.52 119.62,133.65 119.76,133.79 119.76,137.27 119.2,137.84 119.2,144.01 119.5,144.32 119.5,146.29 119.86,146.66 119.86,148.34 119.17,149.03 119.17,149.65 125.05,155.53 125.05,155.57 137.55,155.57 142.85,160.86 152.63,160.86 153.12,161.36 157.65,161.36 159.42,163.12 160.07,163.12 161.83,161.36 166.11,161.36 169.19,164.43 169.19,168.57 v2(168.92,168.84) ; v2(321.06,43.74) 318.76,43.74 317.69,44.81 317.69,46.41 316.94,47.17 315.48,47.17 314.82,46.52 310.19,46.52 307.35,43.68 306.59,43.68 306.37,43.46 291.19,43.46 289.81,42.08 274.74,42.08 269.56,47.27 257.75,47.27 257.05,47.97 250.42,47.97 249.04,49.35 243.94,49.35 243.46,49.82 238.19,49.82 237.86,49.5 232.6,49.5 231.92,50.17 228.07,50.17 226.97,51.27 224.38,51.27 224.13,51.02 216.85,51.02 216.24,51.63 213.89,51.63 211.09,54.43 211.09,56.3 208.82,58.57 206.83,58.57 206.29,59.11 203.62,59.11 203.52,59.02 201.45,59.02 199.38,61.08 196.97,61.08 196.8,61.08 196.43,60.71 196.37,60.68 196.35,60.68 196.34,60.67 196.16,60.6 195.82,60.37 195.57,60.2 195.07,59.7 194.67,59.11 194.64,59.03 194.57,58.96 194.57,58.95 192.55,56.93 189.95,56.93 189.71,57.17 188.13,57.17 187.98,57.32 187.16,57.32 187.01,57.17 186.58,57.17 184.14,54.73 184.14,44.15 v2(182.24,42.25) 181.39,41.39 174.37,41.39 171.91,38.93 169,38.93 168.05,37.98 122.84,37.98 119.98,40.84 112.97,40.84 111.75,42.06 107.48,42.06 105.67,43.87 105.67,44.44 100.9,49.22 v2(99.37,49.22) ; v2(266.65,19.36) 266.82,19.36 267.23,18.95 274.1,18.95 274.72,18.33 274.84,18.33 275.74,17.42 295.1,17.42 295.17,17.49 300.14,17.49 300.14,17.49 300.81,16.82 303.21,16.82 303.92,16.11 v2(304.49,16.11)
  BOTTOM w0.114: v2(26.93,12.34) 27.21,12.34 27.76,12.88 PR9000.2 ; v2(120.91,98.29) 120.92,98.29 127.66,98.29 128.1,98.72 UZ21.3 ; RT15.2 172.37,168.21 171.19,169.4 169.48,169.4 v2(168.92,168.84) ; v2(64.91,20.19) 64.91,20.11 R174.1 R182.1 ; v2(266.65,19.36) 266.65,19.54 265.88,20.3 U16.4 ; v2(99.37,49.22) 99.37,48.68 98.88,48.19 PR209.2 ; v2(182.95,77.52) 182.95,77.02 182.06,76.12 182.06,74.6 180.81,73.35 180.81,66.86 180.34,66.39 180.34,61.71 182.15,59.9 182.15,52.6 181.68,52.13 181.68,42.81 v2(182.24,42.25) ; v2(126.11,118.6) 126.11,118.61 PR5007.1
SUSP#_R: length 7
  TOP w0.089: UT1.D2 176.16,170.04 175.47,170.04
  TOP w0.102: 175.47,170.04 175.19,170.04 174.88,169.73 173.24,169.73 172.54,169.03 v2(172.35,169.03) RT30.2
  BOTTOM w0.102: RT15.1 172.96,168.42 v1(172.76,168.61) v2(172.35,169.03)
SW1_2PH: length 29.1
  TOP w0.254: PR605.2 v2(141.46,139.55)
  IN6 w0.254: v2(141.46,139.55) 140.88,138.97 137.58,138.97 136.56,139.99 136.56,142.17 133.94,144.78 133.94,146.19 132.83,147.3 131.66,147.3 127.87,151.08 124.42,151.08 123.73,150.4 v2(123.73,150.32)
  BOTTOM w0.102: v2(123.73,150.32) v1(124.34,150.32)
  BOTTOM w0.254: PR549.2 123.16,150.32 v2(123.73,150.32) 123.73,149.79 123.07,149.13 PR595.2
SW1_4PH: length 25.1
  TOP w0.254: PR601.2 149.21,139.42 v2(149.08,139.3) ; PR557.1 130.75,145.49 132.09,144.15 132.09,144.17 v2(132.11,144.17)
  IN1 w0.203: v2(132.11,144.17) 133.23,143.06 139.05,143.06 141.64,140.47 144.46,140.47 145.64,139.28 149.07,139.28 v2(149.08,139.3)
  BOTTOM w0.102: v1(132.88,143.89) 132.6,144.17 v2(132.11,144.17)
  BOTTOM w0.254: v2(132.11,144.17) 132.07,144.17 131.72,144.53 PR546.1
SW2_4PH: length 37.9
  TOP w0.254: PR602.2 156.96,136.07 156.96,135.74 157.21,135.49 v2(158.02,135.49) ; v2(132.39,145.34) 131.61,145.34 130.56,146.38 PR587.1
  IN1 w0.203: v2(132.39,145.34) 134.22,143.51 139.12,143.51 141.66,140.97 144.56,140.97 145.65,139.88 155.69,139.88 157.53,138.04 157.53,135.98 v2(158.02,135.49)
  BOTTOM w0.102: v2(132.39,145.34) 132.8,145.34 v1(132.93,145.22)
  BOTTOM w0.254: PR550.1 131.72,146.37 132.39,145.7 v2(132.39,145.34)
SW3_4PH: length 46.5
  TOP w0.254: PR581.1 130.21,147.6 131.45,146.37 v2(132.41,146.37) ; PR603.2 v2(168,135.46)
  IN1 w0.203: v2(168,135.46) 167.55,135.46 165.85,137.16 160.51,137.16 157.36,140.31 145.8,140.31 144.61,141.51 141.87,141.51 139.4,143.97 134.8,143.97 v2(132.41,146.37)
  BOTTOM w0.102: v1(132.98,146.55) 132.8,146.37 v2(132.41,146.37)
  BOTTOM w0.254: v2(132.41,146.37) 132.41,146.37 132.41,146.88 131.71,147.57 PR551.1
SW4_4PH: length 52
  TOP w0.254: PR604.2 v2(173.31,135.99) ; v2(132.42,147.78) 131.33,148.87 PR582.1
  IN1 w0.203: v2(173.31,135.99) 171.71,137.6 160.64,137.6 157.44,140.8 146.08,140.8 144.97,141.91 142.17,141.91 139.58,144.5 135.7,144.5 v2(132.42,147.78)
  BOTTOM w0.102: v1(133.08,147.91) 132.95,147.78 v2(132.42,147.78)
  BOTTOM w0.254: v2(132.42,147.78) 132.42,148.12 PR572.1
SW_1.2V: length 1.3
  IN4 w1.016: 89.73,41.9 89.73,43.23
  vias: v1(87.03,42.78) v2(87.38,41.61) v2(87.38,41.01) v2(87.38,40.38) v2(87.38,39.74) v2(87.38,39.11) v2(87.7,38.6) v2(88.02,41.01) v2(88.02,40.38) v2(88.02,39.74) v2(88.02,39.11) v2(88.34,38.6) v2(88.65,40.38) v2(88.65,39.74) v2(88.65,39.11) v2(88.97,38.6) v2(89.16,39.42) v2(89.9,41.51) v2(90.28,44.16) v2(90.31,41.06) v2(90.76,44.52)
SW_1PH: length 4.9
  TOP w0.102: PR502.2 181.95,135.5 v1(182.18,135.27)
  TOP w0.254: v2(181.31,136.25) 180.91,135.84 PR502.2
  BOTTOM w0.254: PL508.2 183.21,136.5 182.96,136.25 v2(181.31,136.25)
SW_+1VALWP:
  vias: v1(251.56,19.5) v2(251.67,21.45) v2(251.67,20.87) v2(251.91,23.19) v2(251.91,22.61) v2(251.91,22.03) v2(252.31,21.45) v2(252.31,20.87) v2(252.55,23.19) v2(252.55,22.61) v2(252.55,22.03) v2(253.18,23.19) v2(253.18,22.61) v2(253.18,22.03)
SYNC_OUT: length 1.8
  TOP w0.107: UA4.38 30.01,10.61 29.72,10.9 29.57,10.9 v2(29.53,10.86)
  BOTTOM w0.102: v2(29.53,10.86) 29.23,10.86 TC24.1
SYS_PEX_RST_MON#: length 27.1
  IN1 w0.081: v2(197.42,118.68) 197.79,119.06 200.64,119.06 203.73,115.97 208.96,115.97 209.99,114.94 213.13,114.94 214.34,116.15 215.63,116.15 216.48,115.3 216.48,115.12 217.17,114.43 v2(217.32,114.43)
  BOTTOM w0.1: UG9.BE2 219.52,113.35 219.1,113.77 218.31,113.77 217.65,114.43 v2(217.32,114.43)
  BOTTOM w0.114: v2(197.42,118.68) 197.42,118.71 196.67,119.46 RG21.1
SYS_PWROK: length 127.1
  TOP w0.114: CE46.1 296.74,8.77 UE5.74 296.74,10.85 296.49,11.1 v2(296.49,12.68)
  IN1 w0.089: v2(211.8,42.35) 211.8,39.85 212.42,39.23 212.42,36.63 213.05,36 216.73,36 v2(217.31,35.42)
  IN3 w0.127: v2(293.76,31.11) 293.76,31.13 289.68,35.21 284.11,35.21 283.34,35.97 278.1,35.97 277.41,36.66 273.6,36.66 266.82,43.45 251.4,43.45 249.86,41.9 249.86,40.23 246.03,36.4 243.32,36.4 242.63,35.7 238.91,35.7 237.52,34.31 235.81,34.31 235.42,34.7 234.07,34.7 233.19,33.82 230.88,33.82 229.95,34.76 227.24,34.76 v2(227.08,34.6)
  IN6 w0.081: v2(227.08,34.6) 225.99,35.69 224.69,35.69 223.72,34.73 221.8,34.73 221.61,34.92 221.28,34.92 221.28,34.92 221.26,34.92 220.9,35.28 219.99,35.28 219.47,35.79 219.18,35.79
  IN6 w0.089: 219.18,35.79 217.93,35.79 217.67,35.79 v2(217.31,35.42)
  BOTTOM w0.114: v2(293.76,31.11) 293.76,30.28 294.17,29.87 294.17,23.01 293.58,22.42 293.58,20.33 295.02,18.89 295.02,15.68 296.49,14.21 v2(296.49,12.68)
  BOTTOM w0.122: v2(211.8,42.35) 211.8,41.05 211.56,40.81 211.56,40.55 211.46,40.44 211.46,40.43 211.36,40.34 UH1.AU3
SYS_RESET#: length 6.4
  BOTTOM w0.114: 212.02,43.63 v1(211.86,43.79) 211.83,43.82 211.83,44.66 RH571.1 CH175.1 212.94,44.87 RH5.2
  BOTTOM w0.122: 212.02,43.63 212.02,43.18 212.04,43.17 211.42,42.55 211.42,41.02 211.33,40.94 UH1.AU2
SYS_SWCLK: length 197.4
  TOP w0.102: v2(178.18,16.34) v1(178.18,15.1) ; v2(311.6,18.79) 311.6,18.18 311.7,18.08 UE1.37
  IN1 w0.102: v2(302.4,17.33) 302.52,17.33 304.24,19.04 305.92,19.04 306.81,19.93 308.49,19.93 309.29,19.13 311.26,19.13 v2(311.6,18.79)
  IN4 w0.102: v2(178.18,16.34) 178.16,16.34 178.16,16.2 178.93,15.43 180.54,15.43 182.78,15.43 187.35,10.86 190.95,10.86 191.09,11 192.69,12.6 202.62,12.6 202.89,12.87 206.83,12.87 207.1,12.6 207.22,12.47 209.5,12.47 210.3,11.67 215.34,11.67 218.32,14.66 219.51,14.66 220.98,16.12 220.98,16.31 220.98,17.31 221.45,17.78 222.59,17.78 223.15,18.34 225.94,18.34 226.32,17.96 232.74,17.96 233.47,17.22 235.96,17.22 236.23,16.96 239.77,16.96 241.74,14.99 245.96,14.99 246.44,15.47 246.44,15.48 247.06,16.11 248.21,16.11 248.93,16.82 255.15,16.82 255.83,17.5 259.36,17.5 260.52,18.66 265.06,18.66 265.76,17.96 266.08,17.96 266.14,18.03 267.15,18.03 267.86,18.73 271.22,18.73 271.41,18.73 272.57,19.89 278.13,19.89 279.87,18.15 281.31,18.15 283.51,20.35 290.1,20.35 295.45,15 299.91,15 300.82,15.91 300.82,16.51 301.19,16.88 301.95,16.88 v2(302.4,17.33)
  BOTTOM w0.102: v2(178.18,16.34) 178.16,16.34 178.16,16.34 170.6,23.9 JELC1.6 170.6,31.33 167.59,34.34 151.6,34.34 150.41,33.16 150.41,31.27 150.58,31.11 JELC2.4
SYS_SWDIO: length 201.2
  TOP w0.102: UE1.34 314.79,18.84 315.04,18.6 316.05,18.6 316.62,18.02 316.62,16.63 316.11,16.12 316.11,13.96 317.03,13.05 v2(317.06,13.05)
  IN4 w0.102: v2(236.61,9.64) 236.61,12.62 237.58,13.59 251.17,13.59 251.69,14.11 260.96,14.11 261.17,14.33 264.42,14.33 265.38,15.29 276.49,15.29 277.25,14.53 281.82,14.53 284.81,11.55 292.24,11.55 293.44,10.34 300.55,10.34 302.21,11.99 304.62,11.99 308.02,15.4 308.57,15.4 308.8,15.63 308.8,15.97 308.87,16.03 308.87,16.03 309.27,16.42 312,16.42 313.18,15.24 313.52,15.24 315.72,13.05 v2(317.06,13.05)
  IN6 w0.102: v2(177.59,16.31) 177.59,16.15 179.02,14.72 182,14.72 185.82,10.9 186.45,10.28 187.37,10.28 188.54,9.1 189.03,9.1 189.28,9.1 189.53,9.1 190.07,8.56 192.95,8.56 194.13,7.39 203.56,7.39 203.83,7.12 229.83,7.12 230.39,7.67 234.9,7.67 236.61,9.39 v2(236.61,9.64)
  BOTTOM w0.102: v2(177.59,16.31) 169.8,24.11 JELC1.5 169.8,31.49 167.39,33.9 154.77,33.9 153.25,32.38 JELC2.2
SYSON: length 384.3
  TOP w0.114: v2(322.79,28.96) 322.79,33.08 325.67,35.96 325.67,41.74 326.45,42.52 Q9.3 ; v2(178.49,78.89) 178.72,78.89 179.28,79.45 U19.4 ; UE5.95 305.14,9.05 305.47,8.72 305.47,8.36 CE42.1 306.05,7.88 v2(306.56,7.37)
  IN3 w0.127: v2(306.56,7.37) 306.56,8.16 307.95,9.55 312.28,9.55 316.11,13.38 316.11,15 316.65,15.53 316.65,15.54 317.51,16.4 317.51,16.81 319.9,19.2 319.9,19.27 322.2,21.57 322.2,22.86 322.87,23.53 322.87,26.32 322.42,26.76 322.42,28.6 v2(322.79,28.96) ; v2(128.34,27.55) 129.68,28.88 168.28,28.88 172.73,33.33 172.73,37.55 174.57,39.39 174.57,41.14 176.41,42.99 176.41,47.43 176.84,47.85 176.84,55.15 177.77,56.09 177.77,76.86 177.81,76.9 177.81,78.22 v2(178.49,78.89)
  IN6 w0.081: v2(178.49,78.89) 177.24,77.65 177.24,66.8 180.52,63.52 187.85,63.52 188.09,63.77 188.74,63.77 190.77,61.74 193.72,61.74 193.96,61.9 194.84,62.49 196.3,63.95 196.74,63.95 196.85,64.06 197.68,64.06 198.08,64.46 199.63,64.46 201.02,63.07 201.02,62.7 201.76,61.97 202.64,61.97 202.91,61.7 205.43,61.7 205.69,61.44 206.56,61.44 211.55,56.45 211.55,55.54 211.55,54.58 214.07,52.06 216.42,52.06 217.01,51.48 223.71,51.48 224.03,51.8 227.32,51.8 228.1,51.02 231.36,51.02 231.77,50.62 249.05,50.62 250.27,49.39 259.86,49.39 261.46,47.79 271.01,47.79 272.36,49.13 277.57,49.13 279.79,46.92 279.79,44.38 281.12,43.04 290.15,43.04 291.23,44.12 302.46,44.12 305.06,46.73 314.71,46.73 315.41,47.43 317,47.43 317.9,46.52 317.9,44.89 318.6,44.19 319.73,44.19 319.73,44.19 321.32,44.19 321.69,43.81 321.69,39.9 320.9,39.1 320.9,30.85 v2(322.79,28.96) ; v2(128.34,27.55) 127.31,26.52 116.84,26.52 114.76,28.6 108.24,28.6 101.65,35.18 101.65,37.85 101.55,37.96 101.55,41.01 97.77,44.78 v2(97.72,44.78)
  BOTTOM w0.114: PR208.1 97.41,44.78 v2(97.72,44.78)
TB_STAT#_CHG: length 8.5
  TOP w0.203: PR718.1 v2(56.14,21.07) 56.64,21.57 PU700.16
  TOP w0.254: PQ705.2 60.83,21.21 60.52,21.52 v2(60.52,21.71)
  IN3 w0.254: v2(60.52,21.71) 60.52,21.48 60.27,21.23 58.66,21.23 57.86,22.03 56.78,22.03 56.14,21.39 v2(56.14,21.07)
TBT_A_AUX_N: length 2.6
  TOP w0.089: v2(182.61,163.67) 182.28,163.33 UT1.W15
  BOTTOM w0.089: v2(182.61,163.67) 182.61,163.61 182.44,163.44 182.23,163.44 181.91,163.12 181.91,162.76 182.05,162.61 CT44.2
TBT_A_AUX_N_C: length 33.3
  IN3 w0.109: v2(196.77,168.08) 196.77,168.81 196.54,169.04 195.25,169.04 193.99,167.78 193.99,166.85 194.12,166.72 194.12,166 193.79,165.67 193.79,164.21 193.47,163.88 192.54,163.88 191.91,163.25 191.91,162.64 191,161.73 185.22,161.73 184.41,160.93 184.41,158.68 183.94,158.21 183.33,158.21 183.33,158.2 182.97,158.2 182.63,157.87 182.63,157.44 v2(182.52,157.33)
  BOTTOM w0.076: UT4.J2 198.51,165.87 198.26,166.12 197.95,166.12 197.48,166.59 197.48,166.67 196.77,167.38 v2(196.77,168.08)
  BOTTOM w0.089: RT70.2 197.39,168.96 196.77,168.34 v2(196.77,168.08) ; v2(182.52,157.33) 182.75,157.33 182.84,157.42 182.84,157.9 182.56,158.18 182.56,159.19 182.26,159.49 182.26,161.27 CT44.1
TBT_A_AUX_P: length 2.5
  TOP w0.089: v2(182.61,163) 182.29,162.68 UT1.Y15
  BOTTOM w0.089: CT43.2 182.62,162.46 182.53,162.55 182.37,162.55 182.08,162.83 182.08,163.04 182.3,163.26 182.43,163.26 182.61,163.08 v2(182.61,163)
TBT_A_AUX_P_C: length 33.4
  IN3 w0.109: v2(183.33,157.3) 183.05,157.3 182.93,157.42 182.93,157.5 182.83,157.59 182.83,157.78 183.05,158.01 184.02,158.01 184.61,158.59 184.61,160.84 185.3,161.53 191.08,161.53 192.1,162.56 192.1,163.17 192.62,163.69 193.55,163.69 193.99,164.13 193.99,165.59 194.32,165.92 194.32,166.81 194.19,166.93 194.19,167.69 195.33,168.84 196.46,168.84 196.57,168.73 196.57,168.46 196.36,168.25 196.36,168.15 196.29,168.08 v2(196.1,168.08)
  BOTTOM w0.076: 196.22,168.08 196.27,168.08 196.6,167.74 196.6,167.31 197.32,166.6 197.32,166.52 197.89,165.95 198.07,165.95 UT4.J1
  BOTTOM w0.089: 196.22,168.08 v2(196.1,168.08) 196.1,168.48 196.68,169.07 196.68,169.08 RT73.1 ; v2(183.33,157.3) 183.12,157.3 183.02,157.41 183.02,157.98 182.73,158.26 182.73,159.26 182.51,159.49 182.51,159.5 182.44,159.57 182.44,161.29 CT43.1
TBT_A_CC1: length 31.8
  TOP w0.127: DT11.1 190.76,175.57 v1(190.31,176.03)
  TOP w0.508: 191.27,176.14 192.29,177.16 v2(192.29,177.98)
  IN6 w0.508: v2(192.29,177.98) 192.29,178.73 192.87,179.31 194.33,179.31 197.11,176.53 198.09,176.53 199.31,175.31 205.72,175.31 206.23,174.81 206.23,174.74 206.29,174.68 206.29,174.17 206.23,174.11 206.23,174.06 203.78,171.61 203.78,170.2 203.4,169.82 202.99,169.82 202.71,169.53 202.71,169.03
  BOTTOM w0.203: v2(203.22,168.57) 203.22,168.3 202.44,167.52 202.44,167.46 202.16,167.17 UT4.L9
  BOTTOM w0.279: JUSBC1.A5 192.09,179.79 192.09,179.32 192.29,179.12 v2(192.29,177.98)
TBT_A_CC2: length 29.7
  TOP w0.102: CT113.1 203.75,168.77 v1(204.03,169.05)
  TOP w0.254: DT12.1 196.9,177.64 197.26,177.28 v2(197.43,177.28)
  IN6 w0.508: 193.49,179.95 194.59,179.95 197.26,177.28 v2(197.43,177.28) 198.57,177.28 199.35,178.06 205.23,178.06 206.74,176.55 206.74,175.22 206.87,175.09 206.87,175 206.93,174.94 206.93,173.91 206.87,173.85 206.87,173.79 204.54,171.47 204.54,168.39 v2(204.33,168.18)
  BOTTOM w0.203: 203.78,167.95 203.72,167.95 203.53,167.77 203.32,167.77 202.89,167.33 202.89,167.27 202.66,167.04 UT4.L10
  BOTTOM w0.279: JUSBC1.B5 193.35,180.95 193.52,180.77 v2(193.52,180.61)
  BOTTOM w0.381: 203.78,167.95 204.1,167.95 v2(204.33,168.18)
TBT_A_SBU1: length 28.9
  TOP w0.089: v2(194.51,176.52) 194.51,177.47 194.69,177.66 DT13.1 194.83,177.63 194.83,177.28 v2(194.95,177.16)
  IN6 w0.089: v2(194.51,176.52) 194.44,176.59 192.23,176.59 192.1,176.46 192.1,175.6 192.38,175.31 197.79,175.31 199.38,173.73 201.46,173.73 202.95,172.23 202.95,170.97 201.67,169.68 201.67,168.3 201.81,168.16 201.93,168.16 202.07,168.29 v2(202.07,168.3)
  BOTTOM w0.076: v2(202.07,168.3) 202.19,168.17 202.19,167.54 201.91,167.25 201.91,166.57 201.7,166.37 UT4.K8
  BOTTOM w0.089: v2(194.95,177.16) 194.95,177.28 194.57,177.66 193.49,177.66 193.24,177.91 193.24,178.87 193.6,179.23 JUSBC1.A8
TBT_A_SBU2: length 28.9
  TOP w0.089: v2(189.65,178.24) 188.81,178.24 188.56,177.99 DT14.1 188.55,177.91 188.55,177.63 189.07,177.11 189.27,177.11 v2(189.3,177.08)
  IN4 w0.109: v2(191.75,180.65) 191.75,179.92 190.06,178.24 v2(189.65,178.24)
  IN6 w0.089: v2(201.8,167.7) 201.8,167.88 201.47,168.22 201.47,169.76 202.76,171.05 202.76,172.15 201.38,173.53 199.3,173.53 197.71,175.12 192.3,175.12 191.9,175.51 191.9,176.26 190.99,177.17 189.38,177.17 v2(189.3,177.08)
  BOTTOM w0.076: v2(201.8,167.7) 201.66,167.56 UT4.L8
  BOTTOM w0.089: v2(191.75,180.65) 191.85,180.75 JUSBC1.B8
TBT_A_TRX_DTX_N0: length 22.4
  TOP w0.089: v2(186.72,174.3) 186.51,174.08 arc(186.48,174.03) 186.48,173.96 arc(186.49,173.93) 186.51,173.9 186.7,173.71 186.71,173.7 arc(186.73,173.68) 186.76,173.65 arc(186.97,173.54) 187.21,173.51 187.41,173.51 arc(187.67,173.39) 187.77,173.13 187.77,172.82 arc(187.66,172.56) 187.39,172.46 186.74,172.46 arc(186.64,172.49) 186.55,172.55 186.35,172.74 186.34,172.76 arc(186.31,172.8) 186.27,172.84 arc(186.11,172.9) 185.94,172.92 arc(185.75,172.88) 185.59,172.76 185.59,172.75 185.5,172.53 arc(185.49,172.51) 185.49,172.5 arc(185.46,172.3) 185.38,172.12 arc(185.38,172.11) 185.37,172.1 185.35,172.08 185.35,171.46 185.31,171.42 185.22,171.42 185.12,171.52 UT1.A21
  BOTTOM w0.089: v2(186.72,174.3) 186.71,174.31 arc(186.5,174.62) 186.43,174.98 arc(186.5,175.14) 186.65,175.2 187.37,175.2 arc(187.56,175.28) 187.64,175.47 187.64,175.82 arc(187.68,176.04) 187.81,176.23 DT5.1 arc(187.76,176.56) 187.7,176.83 187.7,176.84 arc(187.68,176.95) 187.61,177.05 arc(187.43,177.18) 187.21,177.22 184.83,177.22 arc(184.76,177.25) 184.73,177.32 184.73,177.57 arc(184.77,177.68) 184.88,177.73 186.96,177.73 arc(187.43,177.82) 187.83,178.09 188.3,178.55 arc(188.44,178.65) 188.6,178.68 188.73,178.68 arc(188.95,178.72) 189.14,178.84 189.36,179.05 arc(189.5,179.26) 189.55,179.51 189.55,180.08 arc(189.57,180.2) 189.64,180.3 189.73,180.39 arc(189.85,180.47) 189.98,180.49 190.29,180.49 arc(190.35,180.5) 190.41,180.52 arc(190.46,180.55) 190.51,180.6 190.54,180.63 arc(190.58,180.69) 190.61,180.75 190.64,180.86 arc(190.69,180.93) 190.77,180.95 arc(190.83,181.04) 190.85,181.14 JUSBC1.B10
TBT_A_TRX_DTX_N1: length 31.2
  TOP w0.089: UT1.B15 182.5,171.32 arc(182.56,171.42) 182.59,171.54 182.59,171.74 arc(182.57,171.82) 182.52,171.89 182.22,172.2 arc(182.2,172.23) 182.19,172.26 182.19,172.62 arc(182.12,172.99) 181.91,173.31 181.45,173.77 181.45,173.78 arc(181.43,173.8) 181.41,173.83 181.39,173.86 arc(181.37,173.9) 181.35,173.93 arc(181.31,174.04) 181.3,174.15 181.3,175.38 arc(181.32,175.48) v2(181.38,175.57)
  BOTTOM w0.089: v2(181.38,175.57) 181.38,175.21 arc(181.35,175.15) 181.29,175.12 181.14,175.12 arc(181.07,175.1) 181.05,175.03 181.05,174.97 arc(181.08,174.78) 181.19,174.63 181.19,174.63 arc(181.63,174.39) 182.13,174.3 183.96,174.3 arc(184.24,174.25) 184.48,174.09 185.09,173.48 arc(185.24,173.38) 185.41,173.34 186.16,173.34 arc(186.44,173.29) 186.67,173.13 188.21,171.59 arc(188.38,171.48) 188.58,171.44 190.07,171.44 arc(190.36,171.38) 190.6,171.22 190.8,171.02 arc(190.83,171) 190.86,171 194.57,171 arc(194.85,171.08) 195.08,171.25 195.69,171.86 arc(195.99,172.31) 196.1,172.85 196.1,175.36 arc(196.07,175.46) 195.99,175.54 arc(195.95,175.54) 195.9,175.54 195.78,175.54 arc(195.77,175.54) 195.76,175.55 arc(195.64,175.64) 195.59,175.79 195.59,175.91 DT9.1 195.75,176.06 arc(195.82,176.17) 195.84,176.29 195.84,177.48 arc(195.81,177.67) 195.7,177.83 194.88,178.65 arc(194.79,178.77) 194.77,178.92 194.77,178.95 arc(194.77,178.96) 194.77,178.97 arc(194.76,179.03) 194.73,179.1 arc(194.73,179.1) 194.73,179.11 arc(194.73,179.12) 194.72,179.12 arc(194.7,179.17) 194.66,179.21 arc(194.61,179.28) 194.6,179.36 JUSBC1.A10
TBT_A_TRX_DTX_P0: length 22.4
  TOP w0.089: v2(186.14,174.3) 186.2,174.24 arc(186.27,174.14) 186.29,174.01 arc(186.29,174) 186.29,173.98 arc(186.29,173.98) 186.29,173.98 arc(186.32,173.88) 186.38,173.78 186.4,173.76 arc(186.4,173.76) 186.4,173.76 186.56,173.6 186.56,173.6 186.57,173.59 arc(186.61,173.55) 186.65,173.51 arc(186.91,173.38) 187.21,173.33 187.41,173.33 arc(187.54,173.26) 187.59,173.13 187.59,172.82 arc(187.53,172.69) 187.4,172.64 187.4,172.64 186.74,172.64 arc(186.71,172.65) 186.68,172.67 186.5,172.85 arc(186.44,172.93) 186.36,172.99 arc(186.15,173.07) 185.94,173.1 arc(185.65,173.03) 185.43,172.84 185.39,172.77 185.4,172.75 185.33,172.6 arc(185.32,172.55) 185.31,172.5 arc(185.29,172.35) 185.23,172.21 184.95,171.93 arc(184.91,171.87) 184.9,171.8 184.9,171.52 arc(184.91,171.45) 184.95,171.38 185.09,171.24 arc(185.11,171.21) UT1.B21
  BOTTOM w0.089: JUSBC1.B11 190.35,181.08 arc(190.36,181) 190.41,180.93 arc(190.43,180.9) 190.44,180.86 arc(190.44,180.83) 190.44,180.8 arc(190.43,180.77) 190.41,180.75 190.38,180.71 arc(190.36,180.7) 190.34,180.68 arc(190.31,180.68) 190.29,180.67 189.98,180.67 arc(189.78,180.63) 189.61,180.52 189.51,180.42 arc(189.41,180.26) 189.37,180.08 189.37,179.51 arc(189.33,179.33) 189.23,179.18 189.01,178.97 arc(188.88,178.89) 188.73,178.86 188.6,178.86 arc(188.37,178.81) 188.17,178.68 187.71,178.21 arc(187.37,177.99) 186.96,177.9 184.88,177.9 arc(184.65,177.81) 184.55,177.57 184.55,177.32 arc(184.63,177.12) 184.83,177.04 187.21,177.04 arc(187.36,177.01) 187.49,176.93 arc(187.51,176.88) 187.52,176.84 187.52,176.83 arc(187.52,176.8) 187.53,176.77 arc(187.51,176.66) 187.46,176.57 DT4.1 187.28,176.26 arc(187.41,176.06) 187.46,175.82 187.46,175.47 arc(187.43,175.4) 187.37,175.38 186.65,175.38 arc(186.37,175.26) 186.25,174.98 arc(186.27,174.8) 186.32,174.61 arc(186.32,174.52) 186.28,174.43 v2(186.14,174.3)
TBT_A_TRX_DTX_P1: length 31.2
  TOP w0.089: UT1.A15 182.37,171.63 182.37,171.59 arc(182.33,171.49) 182.23,171.45 arc(182.16,171.49) 182.13,171.56 182.13,171.99 arc(182.12,172.02) 182.1,172.05 182.04,172.11 arc(182.01,172.15) 182,172.2 182,172.26 182,172.26 arc(182,172.26) 182,172.26 182,172.62 arc(181.95,172.92) 181.77,173.18 181.37,173.59 arc(181.36,173.59) 181.35,173.6 arc(181.26,173.72) 181.19,173.85 arc(181.14,174) 181.12,174.15 181.12,175.15 arc(181,175.4) v2(180.78,175.57)
  BOTTOM w0.089: v2(180.78,175.57) 180.78,175.11 arc(180.84,174.81) 181.01,174.55 arc(181.03,174.54) 181.04,174.52 arc(181.05,174.51) 181.06,174.5 181.07,174.49 arc(181.57,174.22) 182.13,174.13 183.96,174.13 arc(184.17,174.08) 184.35,173.96 184.96,173.35 arc(185.17,173.21) 185.41,173.17 186.16,173.17 arc(186.37,173.12) 186.55,173 188.08,171.47 arc(188.31,171.32) 188.58,171.26 190.07,171.26 arc(190.29,171.22) 190.48,171.1 190.67,170.9 arc(190.76,170.84) 190.86,170.82 194.59,170.82 arc(194.92,170.92) 195.21,171.12 195.81,171.73 arc(196.16,172.24) 196.28,172.85 196.28,175.85 arc(196.28,175.89) DT8.1 arc(196.1,176.24) 196.02,176.62 196.02,177.48 arc(195.97,177.74) 195.82,177.95 195,178.77 arc(194.96,178.84) 194.94,178.92 arc(194.96,179) 195,179.06 arc(195.07,179.16) 195.1,179.28 JUSBC1.A11
TBT_A_TTX_C_DRX_N0: length 17.8
  TOP w0.089: CT42.1 arc(184.46,174.7) 184.41,174.96 184.41,175.43 arc(184.39,175.58) 184.34,175.73 arc(184.19,175.9) 183.97,175.96 arc(183.92,175.97) 183.87,175.98 183.81,176.01 arc(183.78,176.03) 183.75,176.06 arc(183.73,176.07) 183.71,176.09 arc(183.68,176.12) 183.66,176.15 183.62,176.2 arc(183.6,176.24) 183.59,176.28 183.58,176.41 arc(183.58,176.41) 183.58,176.42 183.58,176.46 arc(183.58,176.49) 183.57,176.53 183.57,176.64 183.57,176.64 arc(183.58,176.69) 183.59,176.74 arc(183.71,176.91) 183.9,176.97 184.86,176.97 arc(185.18,176.84) 185.31,176.52 185.31,176.33 arc(185.34,176.12) 185.41,175.91 arc(185.48,175.8) 185.56,175.7 arc(185.62,175.64) 185.68,175.59 arc(185.7,175.58) 185.72,175.56 arc(186.19,175.34) 186.7,175.26 187.34,175.26 arc(187.5,175.23) 187.63,175.14 188.67,174.1 arc(188.72,174.04) 188.75,173.98 arc(188.77,173.87) 188.83,173.78 189.18,173.44 arc(189.2,173.42) v2(189.24,173.41)
  BOTTOM w0.089: JUSBC1.A3 191.1,179.44 arc(191.05,179.24) 190.94,179.07 arc(190.94,179.02) 190.93,178.98 arc(190.88,178.82) 190.78,178.68 190.69,178.59 arc(190.67,178.56) 190.64,178.54 arc(190.61,178.49) 190.59,178.44 arc(190.56,178.37) 190.55,178.28 arc(190.54,178.26) 190.54,178.24 190.54,178.17 arc(190.54,178.13) 190.54,178.08 arc(190.53,178.04) 190.53,178 arc(190.55,177.9) 190.61,177.81 DT3.1 arc(190.67,177.48) 190.63,177.29 190.63,177.29 190.61,177.11 arc(190.61,177.1) 190.61,177.1 arc(190.58,177.01) 190.55,176.92 arc(190.51,176.71) 190.5,176.5 190.5,176.5 190.5,174.81 arc(190.37,174.15) 190,173.6 arc(189.87,173.52) 189.72,173.49 189.42,173.49 arc(189.32,173.47) v2(189.24,173.41)
TBT_A_TTX_C_DRX_N1: length 26
  TOP w0.089: CT40.1 182.74,174.73 arc(182.75,174.75) 182.75,174.77 182.76,174.96 182.78,175.14 arc(182.77,175.23) 182.75,175.32 arc(182.73,175.36) 182.72,175.39 arc(182.68,175.42) 182.66,175.46 arc(182.57,175.63) 182.54,175.82 182.54,176.35 arc(182.55,176.57) 182.57,176.79 182.58,176.83 arc(183.01,177.62) 183.85,177.94 185.87,177.94 arc(186.22,177.87) 186.51,177.67 188.29,175.9 arc(188.64,175.66) 189.06,175.57 189.3,175.57 189.3,175.58 arc(189.32,175.58) 189.33,175.57 arc(189.57,175.54) 189.79,175.46 arc(189.93,175.38) 190.06,175.27 190.19,175.13 arc(190.33,174.92) 190.38,174.68 190.38,174.57 arc(190.42,174.38) 190.53,174.21 190.76,173.98 arc(191.26,173.65) 191.84,173.54 193.15,173.54 arc(193.28,173.56) 193.38,173.63 193.88,174.13 arc(194.11,174.31) 194.38,174.43 arc(194.95,174.56) 195.53,174.61 195.69,174.61 arc(195.72,174.61) 195.75,174.63 arc(195.82,174.73) 195.84,174.85 195.84,175.5 arc(195.78,175.74) DT7.1 195.63,175.95 arc(195.75,176.12) 195.79,176.33 195.79,178.13 arc(195.75,178.33) 195.64,178.5 195.12,179.03 arc(194.97,179.24) 194.92,179.5 194.92,180.08 arc(194.86,180.37) v2(194.69,180.62)
  BOTTOM w0.089: v2(194.69,180.62) 194.69,180.75 arc(194.68,180.81) 194.65,180.86 194.63,180.88 arc(194.58,180.91) 194.52,180.92 arc(194.46,180.93) 194.41,180.97 194.4,180.97 arc(194.36,181.04) 194.35,181.11 JUSBC1.B3
TBT_A_TTX_C_DRX_P0: length 17.8
  TOP w0.089: CT41.1 184.1,174.54 arc(184.2,174.69) 184.24,174.87 184.24,175.43 184.23,175.43 arc(184.22,175.53) 184.19,175.63 184.18,175.64 arc(184.16,175.68) 184.12,175.72 arc(184.05,175.77) 183.97,175.78 arc(183.88,175.79) 183.8,175.82 183.74,175.85 arc(183.68,175.88) 183.64,175.92 arc(183.61,175.94) 183.59,175.96 arc(183.55,176) 183.51,176.05 183.47,176.1 arc(183.44,176.17) 183.41,176.25 183.4,176.4 arc(183.4,176.4) 183.4,176.41 arc(183.4,176.47) 183.4,176.53 183.4,176.64 arc(183.4,176.72) 183.42,176.79 arc(183.6,177.05) 183.9,177.15 184.86,177.15 arc(185.31,176.97) 185.49,176.52 185.49,176.33 arc(185.51,176.16) 185.57,175.99 arc(185.63,175.9) 185.69,175.82 arc(185.75,175.76) 185.82,175.71 arc(186.24,175.51) 186.7,175.44 187.34,175.44 arc(187.57,175.39) 187.76,175.26 188.88,174.15 arc(188.88,174.14) 188.89,174.13 arc(189.05,174.03) v2(189.24,174)
  BOTTOM w0.089: v2(189.24,174) 189.47,173.77 189.5,173.74 arc(189.6,173.68) 189.72,173.66 189.72,173.66 arc(189.8,173.68) 189.87,173.73 arc(190.2,174.22) 190.32,174.81 190.32,176.72 arc(190.35,176.88) 190.4,177.02 arc(190.41,177.06) 190.42,177.1 arc(190.43,177.13) 190.44,177.15 190.46,177.3 190.46,177.32 arc(190.45,177.36) 190.44,177.41 arc(190.32,177.58) DT2.1 190.17,177.69 arc(190.3,177.87) 190.36,178.09 190.36,178.18 arc(190.37,178.27) 190.38,178.35 arc(190.4,178.43) 190.43,178.52 arc(190.46,178.58) 190.5,178.64 arc(190.53,178.68) 190.56,178.71 190.65,178.8 arc(190.72,178.9) 190.76,179.01 arc(190.76,179.04) 190.76,179.07 arc(190.76,179.1) 190.74,179.13 190.7,179.17 arc(190.62,179.28) 190.6,179.42 JUSBC1.A2
TBT_A_TTX_C_DRX_P1: length 26
  TOP w0.089: CT39.1 183.01,174.62 arc(182.97,174.68) 182.96,174.76 182.96,175.13 arc(182.95,175.26) 182.91,175.39 arc(182.89,175.44) 182.86,175.5 arc(182.85,175.51) 182.84,175.51 arc(182.82,175.54) 182.8,175.56 arc(182.74,175.68) 182.72,175.82 182.72,176.35 arc(182.73,176.56) 182.75,176.76 182.76,176.8 arc(183.13,177.49) 183.85,177.76 185.87,177.76 arc(186.15,177.7) 186.39,177.54 188.16,175.77 arc(188.58,175.49) 189.07,175.4 189.32,175.4 arc(189.52,175.37) 189.71,175.3 arc(189.83,175.23) 189.93,175.14 190.07,175.01 arc(190.17,174.86) 190.2,174.68 190.2,174.57 arc(190.26,174.31) 190.4,174.09 190.63,173.86 arc(191.19,173.49) 191.84,173.36 193.15,173.36 arc(193.34,173.4) 193.51,173.51 193.99,173.99 arc(193.99,173.99) 194,174 arc(194.2,174.16) 194.43,174.26 arc(194.98,174.39) 195.53,174.43 195.69,174.43 arc(195.79,174.45) 195.88,174.51 arc(195.98,174.67) 196.02,174.85 196.02,175.32 arc(196.09,175.65) DT6.1 196.09,176.1 arc(196,176.24) 195.97,176.39 195.97,178.13 arc(195.92,178.4) 195.76,178.63 195.24,179.15 arc(195.13,179.31) 195.1,179.5 195.1,180.16 arc(195.14,180.39) v2(195.28,180.6)
  BOTTOM w0.089: v2(195.28,180.6) 195.28,180.61 194.91,180.98 arc(194.86,181.05) 194.85,181.13 JUSBC1.B2
TBT_A_TTX_DRX_N0: length 2.9
  TOP w0.089: UT1.B19 184.3,171.28 arc(184.4,171.42) 184.43,171.59 184.43,171.84 arc(184.42,171.88) 184.4,171.92 arc(184.37,171.96) 184.35,172.02 184.35,172.09 arc(184.37,172.18) 184.38,172.27 184.38,172.73 arc(184.38,172.73) 184.38,172.74 arc(184.42,173.01) 184.44,173.28 184.44,173.29 arc(184.44,173.31) 184.44,173.34 arc(184.49,173.63) CT42.2
TBT_A_TTX_DRX_N1: length 3
  TOP w0.089: UT1.B17 183.26,171.18 183.18,171.26 arc(183.09,171.39) 183.06,171.55 183.06,172.7 arc(183.03,172.81) 182.97,172.91 182.87,173.01 arc(182.81,173.1) 182.79,173.21 182.79,173.54 arc(182.73,173.74) CT40.2
TBT_A_TTX_DRX_P0: length 2.9
  TOP w0.089: UT1.A19 184.2,171.6 arc(184.19,171.55) 184.16,171.5 184.03,171.5 184,171.53 arc(183.98,171.57) 183.96,171.62 183.96,171.8 arc(183.98,171.86) 184.01,171.91 184.09,171.99 184.12,172.03 arc(184.13,172.05) 184.14,172.06 arc(184.16,172.1) 184.17,172.14 arc(184.19,172.21) 184.19,172.27 184.19,172.46 184.19,172.46 184.19,172.71 arc(184.19,172.75) 184.19,172.78 arc(184.24,173.03) 184.25,173.28 184.25,173.56 arc(184.2,173.76) CT41.2
TBT_A_TTX_DRX_P1: length 3
  TOP w0.089: UT1.A17 183.28,171.55 arc(183.31,171.49) 183.37,171.46 183.42,171.46 183.46,171.5 arc(183.5,171.56) 183.51,171.62 183.51,171.77 arc(183.5,171.84) 183.46,171.89 183.33,172.03 arc(183.27,172.12) 183.25,172.22 183.25,172.7 arc(183.21,172.89) 183.1,173.05 183,173.15 arc(182.98,173.17) 182.98,173.21 182.98,173.54 arc(183.02,173.74) CT39.2
TBT_A_USB20_L_NB: length 8.3
  IN4 w0.127: v2(193.28,176.99) 193.47,177.17 193.47,177.38 192.77,178.08 192.77,179.03 192.54,179.26 192.54,180.38 192.38,180.54 v2(192.36,180.54)
  BOTTOM w0.107: LT3.3 193.35,174.28 193.48,174.41 193.48,174.82 193.32,174.98 DT10.7 DT10.4 193.32,176.41 193.48,176.57 193.48,176.79 v2(193.28,176.99) ; JUSBC1.B7 192.35,180.6 192.36,180.58 v2(192.36,180.54)
TBT_A_USB20_L_NT: length 6.4
  BOTTOM w0.107: LT2.2 192.27,174.32 192.16,174.42 192.16,174.81 192.32,174.96 DT10.8 DT10.2 192.32,176.43 192.16,176.58 192.16,176.77 192.69,177.3 192.69,177.34 192.92,177.57 v4(192.92,178.44) 192.92,179.2 193.1,179.37 JUSBC1.A7
TBT_A_USB20_L_PB: length 8.3
  IN4 w0.127: v2(192.94,180.63) 192.94,180.58 192.76,180.41 192.76,179.35 192.99,179.12 192.99,178.17 193.68,177.47 193.68,177.17 v2(193.87,176.99)
  BOTTOM w0.107: LT3.2 193.85,174.26 193.68,174.43 193.68,174.87 193.81,175 DT10.6 DT10.5 193.81,176.45 193.68,176.58 193.68,176.8 v2(193.87,176.99) ; v2(192.94,180.63) 192.85,180.73 JUSBC1.B6
TBT_A_USB20_L_PT: length 6.4
  BOTTOM w0.107: JUSBC1.A6 192.6,179.41 192.72,179.29 192.72,178.75 192.69,178.72 192.69,178.15 192.72,178.12 192.72,177.66 v4(192.32,177.26) 191.96,176.9 191.96,176.57 191.81,176.43 DT10.1 DT10.9 191.81,174.91 191.96,174.77 191.96,174.41 191.76,174.22 LT2.3
TBT_A_USB20_N: length 18.4
  TOP w0.089: UT1.D20 v2(184.55,170.16)
  TOP w0.107: RT112.1 198.69,170.24 198.55,170.39 v2(198.35,170.39)
  IN6 w0.089: v2(184.55,170.16) 184.55,170.07 184.93,169.7 187.07,169.7 187.16,169.79 188.16,169.79 189.15,170.77 189.58,170.77 189.71,170.9 196.26,170.9 197.37,169.79 198.95,169.79 199.14,169.98 199.14,170.18 198.94,170.39 v2(198.35,170.39)
TBT_A_USB20_NB: length 19.5
  IN6 w0.089: v2(195.27,173.35) 195.04,173.35 194.95,173.43 194.95,173.83 195.04,173.92 196.17,173.92 196.72,173.37 198.56,173.37 199.03,172.89 201.12,172.89 201.93,172.08 201.93,171.77 201.9,171.74 201.9,171.64 201.7,171.43 201.7,171.17 201.68,171.16 201.68,170.82 201.44,170.58 v2(201.28,170.58)
  BOTTOM w0.076: 201.24,167.04 201.27,167.06 201.27,168.2 201.54,168.47 201.54,168.47 201.55,168.48 201.55,168.5
  BOTTOM w0.089: 201.24,167.04 201.16,166.95 UT4.L7
  BOTTOM w0.107: v2(195.27,173.35) 195.03,173.1 195.03,172.15 194.51,171.63 193.58,171.63 193.35,171.86 LT3.4 ; v2(201.28,170.58) 201.28,170.72 201.47,170.9 201.62,170.9 201.9,170.62 201.9,170.44 201.73,170.27 201.73,169.05 201.55,168.86 201.55,168.58 201.55,168.58 201.55,168.5
TBT_A_USB20_NT: length 17
  IN6 w0.089: v2(192.54,171.89) 192.27,171.89 192.18,171.98 192.18,172.2 192.31,172.33 198.7,172.33 198.77,172.26 198.79,172.26 199.47,171.58 199.73,171.58 199.91,171.76 v2(200.27,171.76)
  BOTTOM w0.076: 200.66,166.75 200.73,166.68 200.85,166.68 200.91,166.74 200.91,166.98 200.71,167.18 200.71,167.54 201.02,167.85 201.02,168.36 201.06,168.4
  BOTTOM w0.089: UT4.L6 200.66,166.75
  BOTTOM w0.107: v2(200.27,171.76) 199.89,171.76 199.78,171.66 199.78,171.36 201.25,169.9 201.25,169.25 201.06,169.06 201.06,168.4 ; LT2.1 192.27,172.24 192.21,172.19 192.21,172.04 192.36,171.89 v2(192.54,171.89)
TBT_A_USB20_P: length 18.4
  TOP w0.089: UT1.E20 v2(184.55,169.51)
  TOP w0.107: v2(198.76,170.8) 198.76,170.49 198.95,170.3 RT113.1
  IN6 w0.089: v2(184.55,169.51) 184.58,169.54 187.14,169.54 187.23,169.62 188.23,169.62 189.22,170.61 189.65,170.61 189.78,170.74 196.19,170.74 197.3,169.62 199.02,169.62 199.31,169.91 199.31,170.25 v2(198.76,170.8)
TBT_A_USB20_PB: length 19.5
  IN6 w0.089: v2(194.39,173.4) 194.7,173.4 194.79,173.49 194.79,173.9 194.97,174.08 196.24,174.08 196.78,173.54 198.62,173.54 199.1,173.06 201.18,173.06 202.1,172.15 202.1,171.7 202.07,171.67 202.07,171.57 201.86,171.36 201.86,171.24 v2(202.1,171)
  BOTTOM w0.076: 201.37,166.68 201.37,166.72 201.41,166.76 201.41,166.87 201.41,166.97 201.43,166.99 201.43,168.13 201.61,168.3 201.61,168.3 201.63,168.32 201.63,168.32 201.73,168.42 201.73,168.48 201.75,168.5
  BOTTOM w0.089: 201.37,166.68 201.37,166.58 UT4.K7
  BOTTOM w0.107: v2(202.1,171) 202.1,170.36 201.94,170.19 201.94,168.96 201.75,168.77 201.75,168.5 ; v2(194.39,173.4) 194.52,173.52 194.67,173.52 194.83,173.37 194.83,172.24 194.42,171.83 193.66,171.83 193.56,171.94 193.56,172.05 193.64,172.14 193.77,172.14 193.85,172.22 LT3.1
TBT_A_USB20_PT: length 17
  IN6 w0.089: v2(191.78,171.89) 192.01,172.12 192.01,172.27 192.24,172.49 198.77,172.49 198.84,172.42 198.86,172.42 199.54,171.75 199.66,171.75 199.86,171.94 v2(199.86,172.18)
  BOTTOM w0.076: 200.57,166.53 200.41,166.69 200.41,166.97 200.54,167.11 200.54,167.6 200.85,167.91 200.85,168.58
  BOTTOM w0.089: UT4.K6 200.66,166.44 200.57,166.53
  BOTTOM w0.107: v2(191.78,171.89) 191.88,171.89 192.01,172.01 192.01,172.17 191.76,172.41 LT2.4 ; 200.85,168.58 200.85,168.59 200.85,169.14 201.04,169.33 201.04,169.81 199.58,171.28 199.58,171.74 199.86,172.02 v2(199.86,172.18)
TBT_CIO_PLUG_EVENT#: length 179.4
  TOP w0.089: UT1.W2 176.38,163.37 176.15,163.6 175.52,163.6 174.72,162.8 174.39,162.8
  TOP w0.102: 174.39,162.8 v2(174.37,162.79)
  TOP w0.127: v2(174.37,162.79) 174.3,162.71 RT29.2
  IN1 w0.089: 195.41,45.7 196.99,44.12 196.99,43.23 201.27,38.95 201.78,38.95 205.37,35.36 206.32,35.36 207.01,34.66 207.01,34.16 207.37,33.8 207.51,33.8 207.81,33.8 209.11,32.5 211.21,32.5 v2(211.75,31.96)
  IN1 w0.102: 195.41,45.7 195.33,45.77 192.13,45.77 191.47,46.43 191.47,48.71 192.12,49.35 192.12,49.35 192.99,50.23 192.99,53.31 191.97,54.33 191.97,58.48 191.53,58.91 191.53,59.82 191.72,60.01 192.06,60.34 192.06,60.85 192.16,60.95 v2(192.16,61.35)
  IN2 w0.102: v2(174.37,162.79) 172.23,160.64 172.23,158.61 172.84,157.99 172.84,155.88 174.03,154.69 177.36,154.69 177.38,154.71 177.39,154.71 177.82,155.15 183.34,155.15 190.44,148.04 190.44,129.58 182.61,121.75 182.61,107.29 180.37,105.05 180.37,97.81 184.79,93.39 184.79,92.41 184.79,92.41 184.79,91.79 184.79,91.79 184.79,88.54 181.17,84.92 181.17,83.65 178.92,81.39 178.92,71.25 179.03,71.13 179.03,71.13 182.41,67.76 185.1,67.76 190.89,61.97 191.65,61.97 192.16,61.46 v2(192.16,61.35)
  BOTTOM w0.122: UH1.AV21 v2(211.75,31.96)
TBT_EE_CLK: length 22.2
  BOTTOM w0.114: RT101.1 197.56,158.32 197.3,158.2 196.68,157.79 RT122.1 196.25,157.43 195.67,156.85 v1(195.6,156.85) 195.39,156.85 194.29,157.94 194.28,157.94 194.15,158.07 193.8,158.07 193.66,158.2 190.41,158.2 190.31,158.09 190.31,157.8 190.42,157.69 190.69,157.69 190.81,157.57 190.81,156.45 190.92,156.34 191.15,156.34 191.26,156.45 191.26,157.57 191.38,157.69 191.61,157.69 191.72,157.57 191.72,156.45 191.83,156.34 192.06,156.34 192.18,156.45 192.18,157.57 192.29,157.69 193.01,157.69 193.2,157.5 193.2,156.35 193.21,156.34 193.21,155.93 193.2,155.93 193.2,155.55 192.72,155.07 UT2.6 192.72,153.51 193.09,153.14 RT52.2
TBT_EE_CLK_R: length 28.5
  TOP w0.089: 175.53,159.51 175.71,159.69 175.71,159.78 177.07,161.14 177.07,161.75 UT1.AB4
  TOP w0.114: 175.53,159.51 175.45,159.43 v2(174.74,159.43)
  IN3 w0.127: v2(192.72,156.14) 192.47,155.88 182.49,155.88 182.17,156.2 182.17,156.2 181.39,156.98 181.39,158.7 180.9,159.19 174.95,159.19 174.74,159.4 174.74,159.43 v2(174.74,159.43)
  BOTTOM w0.102: v2(192.72,156.14) 192.21,155.63 192.21,155.48 192.13,155.4 192.13,153.32 192.5,152.95 RT52.1
