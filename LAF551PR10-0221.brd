# Allegro board LAF551PR10-0221.brd (continued)
## Nets (continued)
PD100_PIN1: PD100.1 PR113.1
PD_EE_CLK: RT101.2 RT123.2 UT4.A3
PD_EE_CS_N: RT100.2 UT4.B3
PD_EE_DI: RT98.2 UT4.B4
PD_EE_DO: RT99.2 UT4.A4
PD_IRQ#: RT107.2 UE5.89 UT4.B6
PD_RESET: RT109.1 UE10.8
PD_UART: RT62.1 UT4.E2 UT4.F2
PECI_KB9012: RE76.1 UE5.118
PEG_CRX_C_GTX_N0: CG9.2 UG9.BH26
PEG_CRX_C_GTX_N1: CG16.2 UG9.BE26
PEG_CRX_C_GTX_N2: CG25.2 UG9.BG27
PEG_CRX_C_GTX_N3: CG27.2 UG9.BH29
PEG_CRX_C_GTX_N4: CG29.2 UG9.BE29
PEG_CRX_C_GTX_N5: CG31.2 UG9.BG30
PEG_CRX_C_GTX_N6: CG33.2 UG9.BH32
PEG_CRX_C_GTX_N7: CG36.2 UG9.BE32
PEG_CRX_C_GTX_P0: CG8.2 UG9.BG26
PEG_CRX_C_GTX_P1: CG10.2 UG9.BF26
PEG_CRX_C_GTX_P2: CG22.2 UG9.BF27
PEG_CRX_C_GTX_P3: CG26.2 UG9.BG29
PEG_CRX_C_GTX_P4: CG28.2 UG9.BF29
PEG_CRX_C_GTX_P5: CG30.2 UG9.BF30
PEG_CRX_C_GTX_P6: CG32.2 UG9.BG32
PEG_CRX_C_GTX_P7: CG35.2 UG9.BF32
PEG_CRX_C_RD_GTX_N8: CM69.2 UM8.4
PEG_CRX_C_RD_GTX_N9: CM66.2 UM8.8
PEG_CRX_C_RD_GTX_N10: CM62.2 UM8.6
PEG_CRX_C_RD_GTX_N11: CM65.2 UM8.2
PEG_CRX_C_RD_GTX_P8: CM67.2 UM8.3
PEG_CRX_C_RD_GTX_P9: CM63.2 UM8.7
PEG_CRX_C_RD_GTX_P10: CM68.2 UM8.5
PEG_CRX_C_RD_GTX_P11: CM64.2 UM8.1
PEG_CRX_C_TTX_N12: CT16.2 UT1.V22
PEG_CRX_C_TTX_N13: CT2.2 UT1.P22
PEG_CRX_C_TTX_N14: CT108.2 UT1.K22
PEG_CRX_C_TTX_N15: CT110.2 UT1.F22
PEG_CRX_C_TTX_P12: CT14.2 UT1.V23
PEG_CRX_C_TTX_P13: CT12.2 UT1.P23
PEG_CRX_C_TTX_P14: CT109.2 UT1.K23
PEG_CRX_C_TTX_P15: CT111.2 UT1.F23
PEG_CRX_GTX_N0: CG9.1 UC1.E10
PEG_CRX_GTX_N1: CG16.1 UC1.E11
PEG_CRX_GTX_N2: CG25.1 UC1.E12
PEG_CRX_GTX_N3: CG27.1 UC1.E13
PEG_CRX_GTX_N4: CG29.1 UC1.E14
PEG_CRX_GTX_N5: CG31.1 UC1.E15
PEG_CRX_GTX_N6: CG33.1 UC1.E16
PEG_CRX_GTX_N7: CG36.1 UC1.E17
PEG_CRX_GTX_N8: CM69.1 UC1.F18
PEG_CRX_GTX_N9: CM66.1 UC1.D19
PEG_CRX_GTX_N10: CM62.1 UC1.F20
PEG_CRX_GTX_N11: CM65.1 UC1.D21
PEG_CRX_GTX_P0: CG8.1 UC1.F10
PEG_CRX_GTX_P1: CG10.1 UC1.D11
PEG_CRX_GTX_P2: CG22.1 UC1.F12
PEG_CRX_GTX_P3: CG26.1 UC1.D13
PEG_CRX_GTX_P4: CG28.1 UC1.F14
PEG_CRX_GTX_P5: CG30.1 UC1.D15
PEG_CRX_GTX_P6: CG32.1 UC1.F16
PEG_CRX_GTX_P7: CG35.1 UC1.D17
PEG_CRX_GTX_P8: CM67.1 UC1.E18
PEG_CRX_GTX_P9: CM63.1 UC1.E19
PEG_CRX_GTX_P10: CM68.1 UC1.E20
PEG_CRX_GTX_P11: CM64.1 UC1.E21
PEG_CRX_RD_GTX_N8: JCDRA.16 UM8.42
PEG_CRX_RD_GTX_N9: JCDRA.19 UM8.37
PEG_CRX_RD_GTX_N10: JCDRA.25 UM8.39
PEG_CRX_RD_GTX_N11: JCDRA.31 UM8.44
PEG_CRX_RD_GTX_P8: JCDRA.15 UM8.43
PEG_CRX_RD_GTX_P9: JCDRA.18 UM8.38
PEG_CRX_RD_GTX_P10: JCDRA.24 UM8.40
PEG_CRX_RD_GTX_P11: JCDRA.30 UM8.45
PEG_CRX_TTX_N12: CT16.1 UC1.F22
PEG_CRX_TTX_N13: CT2.1 UC1.D23
PEG_CRX_TTX_N14: CT108.1 UC1.F24
PEG_CRX_TTX_N15: CT110.1 UC1.D25
PEG_CRX_TTX_P12: CT14.1 UC1.E22
PEG_CRX_TTX_P13: CT12.1 UC1.E23
PEG_CRX_TTX_P14: CT109.1 UC1.E24
PEG_CRX_TTX_P15: CT111.1 UC1.E25
PEG_CTX_C_GRX_N0: CC1.2 UG9.BK27
PEG_CTX_C_GRX_N1: CC2.2 UG9.BL29
PEG_CTX_C_GRX_N2: CC3.2 UG9.BM30
PEG_CTX_C_GRX_N3: CC4.2 UG9.BK30
PEG_CTX_C_GRX_N4: CC5.2 UG9.BL32
PEG_CTX_C_GRX_N5: CC6.2 UG9.BM33
PEG_CTX_C_GRX_N6: CC7.2 UG9.BK33
PEG_CTX_C_GRX_N7: CC8.2 UG9.BL35
PEG_CTX_C_GRX_N8: CC9.2 JCDRA.4
PEG_CTX_C_GRX_N9: CC10.2 JCDRA.7
PEG_CTX_C_GRX_N10: CC11.2 JCDRA.10
PEG_CTX_C_GRX_N11: CC12.2 JCDRA.13
PEG_CTX_C_GRX_P0: CC13.2 UG9.BL27
PEG_CTX_C_GRX_P1: CC14.2 UG9.BK29
PEG_CTX_C_GRX_P2: CC15.2 UG9.BM29
PEG_CTX_C_GRX_P3: CC16.2 UG9.BL30
PEG_CTX_C_GRX_P4: CC17.2 UG9.BK32
PEG_CTX_C_GRX_P5: CC18.2 UG9.BM32
PEG_CTX_C_GRX_P6: CC19.2 UG9.BL33
PEG_CTX_C_GRX_P7: CC20.2 UG9.BK35
PEG_CTX_C_GRX_P8: CC21.2 JCDRA.3
PEG_CTX_C_GRX_P9: CC22.2 JCDRA.6
PEG_CTX_C_GRX_P10: CC23.2 JCDRA.9
PEG_CTX_C_GRX_P11: CC24.2 JCDRA.12
PEG_CTX_C_TRX_N12: CT15.2 UT1.Y22
PEG_CTX_C_TRX_N13: CT13.2 UT1.T22
PEG_CTX_C_TRX_N14: CT18.2 UT1.M22
PEG_CTX_C_TRX_N15: CT21.2 UT1.H22
PEG_CTX_C_TRX_P12: CT3.2 UT1.Y23
PEG_CTX_C_TRX_P13: CT1.2 UT1.T23
PEG_CTX_C_TRX_P14: CT4.2 UT1.M23
PEG_CTX_C_TRX_P15: CT5.2 UT1.H23
PEG_CTX_GRX_N0: CC1.1 UC1.B10
PEG_CTX_GRX_N1: CC2.1 UC1.B11
PEG_CTX_GRX_N2: CC3.1 UC1.B12
PEG_CTX_GRX_N3: CC4.1 UC1.B13
PEG_CTX_GRX_N4: CC5.1 UC1.B14
PEG_CTX_GRX_N5: CC6.1 UC1.B15
PEG_CTX_GRX_N6: CC7.1 UC1.B16
PEG_CTX_GRX_N7: CC8.1 UC1.B17
PEG_CTX_GRX_N8: CC9.1 UC1.C18
PEG_CTX_GRX_N9: CC10.1 UC1.A19
PEG_CTX_GRX_N10: CC11.1 UC1.C20
PEG_CTX_GRX_N11: CC12.1 UC1.A21
PEG_CTX_GRX_P0: CC13.1 UC1.C10
PEG_CTX_GRX_P1: CC14.1 UC1.A11
PEG_CTX_GRX_P2: CC15.1 UC1.C12
PEG_CTX_GRX_P3: CC16.1 UC1.A13
PEG_CTX_GRX_P4: CC17.1 UC1.C14
PEG_CTX_GRX_P5: CC18.1 UC1.A15
PEG_CTX_GRX_P6: CC19.1 UC1.C16
PEG_CTX_GRX_P7: CC20.1 UC1.A17
PEG_CTX_GRX_P8: CC21.1 UC1.B18
PEG_CTX_GRX_P9: CC22.1 UC1.B19
PEG_CTX_GRX_P10: CC23.1 UC1.B20
PEG_CTX_GRX_P11: CC24.1 UC1.B21
PEG_CTX_TRX_N12: CT15.1 UC1.C22
PEG_CTX_TRX_N13: CT13.1 UC1.A23
PEG_CTX_TRX_N14: CT18.1 UC1.C24
PEG_CTX_TRX_N15: CT21.1 UC1.A25
PEG_CTX_TRX_P12: CT3.1 UC1.B22
PEG_CTX_TRX_P13: CT1.1 UC1.B23
PEG_CTX_TRX_P14: CT4.1 UC1.B24
PEG_CTX_TRX_P15: CT5.1 UC1.B25
PEG_RCOMP: RC2.2 UC1.G2
PEX_TERMP: RG23.2 UG9.BL44
PEX_VDD_ENP: PC801.1 PR801.1 PR802.1 PR8217.2 PU800.11 UG31.20
PGOOD_1.2V: PR210.2 PU201.10
PLTRST_CPU#: CH195.1 UC1.BP35 UH1.AG5
PM_SLP_S3#: CE41.1 Q8.2 QE1.5 UE5.6 UH1.BF42
PM_SLP_S3_H: Q7.2 Q7.5 Q8.5 Q8.6 R307.2
PM_SLP_S4#: PR1301.2 Q9.2 UE5.73 UH1.BE42
PM_SLP_S4_H: Q9.5 Q9.6 R325.2
PM_SLP_S5#: CE45.1 QE4.5 UE5.14 UH1.BC42
POK: DE2.1 DE3.1 DE4.1 PR14.1 PR17.2 PU100.7
POWER_LED: QE4.6 QE8.2 RE28.2
PQ700_D: PC701.2 PC722.2 PC723.2 PQ700.1 PQ702.4 PQ708.4 PR705.1 PR725.2 PR726.2
PQ700_G: PQ700.2 PR700.2 PR701.1
PQ701_G: PQ701.4 PR725.1
PQ703_S: PC725.2 PL700.2 PQ703.1 PQ703.2 PQ703.3 PR712.1 PR734.1
PQ705_D: PQ705.1 PR710.2
PQ707_G: PQ707.4 PR726.1
PROC_DETECT#: RH519.1 UH1.AP41
PROCHOT#_CHG: PR724.2 PU700.10
PS_ID: PR3.1 PR4.2 UE5.16
PSID: PJPDC1.1 PL2.2
PSID-1: PQ2.2 PR6.1 PR9.2
PSID-2: PQ2.1 PQ7.2 PR8.2
PSID-3: PQ7.3 PR4.1
PSID-4: PD1.2 PL2.1 PQ7.1 PR6.2
PTP_KBBL#: JTP.9 RE663.2 UE10.16
PTP_LID_CLOSE#: JTP.10 RE33.2 UE10.17
PWM1: PR6043.2 PR6067.2 PU6000.11
PWM1_1PH/ICCMAX1: PR522.1 PR5001.1 PU500.44
PWM1_2PH/ICCMAX2: PR589.1 PR590.1 PU500.23
PWM1_4PH/ICCMAX4: PR552.1 PR558.1 PU500.18
PWM2: PR6049.2 PR6066.2 PU6000.10
PWM2_2PH/ROSC1: PR562.1 PU500.22
PWM2_4PH/ADDR: PR563.1 PR580.1 PU500.19
PWM3: PR6054.2 PR6065.2 PU6000.9
PWM3_4PH/VBOOT: PR560.1 PR573.1 PU500.20
PWM4: PR6055.2 PR6064.2 PU6000.8
PWM4_4PH/ROSCM: PR561.1 PR591.1 PU500.21
PWR_B#: JPWR.4 QE13.3 RE154.2 RE160.1
PWR_B_7313#: QE13.4 UE3.17
PWR_B_EC: QE13.2 UE6.22
PWR_G#: JPWR.3 QE21.3 RE155.1 RE156.2
PWR_G_7313#: QE21.4 UE3.16
PWR_G_EC: QE21.2 UE6.10
PWR_LED#: QE4.2 UE5.92
PWR_R#: JPWR.2 QE22.3 RE157.1 RE158.2
PWR_R_7313#: QE22.4 UE3.15
PWR_R_EC: QE22.2 UE6.6
PWR_SRC_ON: CV15.2 QV1.3 RV9.2 RV12.1
PWR_VGA_CORE_BOOT1: PR8205.2 PU8200.1
PWR_VGA_CORE_BOOT1_1: PC8206.2 PR8205.1
PWR_VGA_CORE_BOOT2: PR8207.2 PU8200.15
PWR_VGA_CORE_BOOT2_1: PC8213.2 PR8207.1
PWR_VGA_CORE_LGATE1: PQ8200.6 PR8206.2 PU8200.19
PWR_VGA_CORE_LGATE2: PQ8201.6 PU8200.17
PWR_VGA_CORE_PHASE1: PC8206.1 PL8200.1 PQ8200.7 PR8204.1 PU8200.20
PWR_VGA_CORE_PHASE2: PC8213.1 PL8201.1 PQ8201.7 PR8210.1 PU8200.16
PWR_VGA_CORE_REFIN: PC8217.1 PR8208.2 PR8211.1 PR8215.2 PR8218.2 PU8200.7
PWR_VGA_CORE_SS: PC8216.1 PU8200.11
PWR_VGA_CORE_TON: PR8202.1 PU8200.9
PWR_VGA_CORE_TON_1: PC8205.1 PR8201.1 PR8202.2
PWR_VGA_CORE_UGATE1: PQ8200.1 PU8200.2
PWR_VGA_CORE_UGATE2: PQ8201.1 PU8200.14
PWR_VGA_CORE_VREF: PC8215.1 PR8208.1 PU8200.8
PWRSHARE_EN_EC#: UE5.119 UU1.5
REFADJ: PR6040.1 PU6000.40
REFIN: PR6045.1 PR6053.1 PU6000.1
REGN_CHG: PC710.1 PR714.1 PU700.24
REMOTE1+: C2500.1 C2502.1 Q2407.1 Q2407.2 U2407.2
REMOTE1-: C2500.2 C2502.2 Q2407.3 R184.1
REMOTE2+: C2504.1 C2505.1 Q2408.1 Q2408.2 U2407.4
REMOTE2-: C2504.2 C2505.2 Q2408.3 R184.2 U2407.3
REMOTE3+: C2510.1 C2511.1 Q2411.1 Q2411.2 U2407.5
REMOTE3-: C2510.2 C2511.2 Q2411.3 R185.2
RESET_N: RT102.1 UT4.F11
RF_+1VALWP: PR306.1 PU300.5
RING2: LA8.2 RA28.2 UA1.36
RING2_R: CA46.1 CA92.1 DA5.2 JACK1.4 LA8.1
RJ45_CT: CL30.2 RL9.2 RL10.2 RL11.2 RL12.2
RJ45_CT0: RL12.1 TL1.15
RJ45_CT1: RL11.1 TL1.16
RJ45_CT2: RL10.1 TL1.21
RJ45_CT3: RL9.1 TL1.22
RJ45_MDIN0: JLAN.2 TL1.14
RJ45_MDIN1: JLAN.6 TL1.18
RJ45_MDIN2: JLAN.5 TL1.20
RJ45_MDIN3: JLAN.8 TL1.24
RJ45_MDIP0: JLAN.1 TL1.13
RJ45_MDIP1: JLAN.3 TL1.17
RJ45_MDIP2: JLAN.4 TL1.19
RJ45_MDIP3: JLAN.7 TL1.23
ROM_CS#: RG579.2 UG9.BJ4 UG16.1
ROM_SCLK: RG75.2 RG86.1 RG89.2 RG148.2 UG9.BK3
ROM_SI: RG77.2 RG84.1 RG87.2 RG149.2 UG9.BK2
ROM_SO: RG85.1 RG88.2 RG580.2 UG9.BK4 UG16.4
RPD_G1: RT64.1 UT4.K9
RPD_G2: RT65.1 UT4.K10
RST#: CE55.2 RE91.2 UE6.3
RT8812_PVCC: PC8200.1 PR8200.1 PU8200.18
RTC_CELL: QE58.2 RE662.1 UE10.22
RTD3_CIO_PWR_EN: RT16.2 UH1.BF21
RTD3_CIO_PWR_EN_R: RT16.1 RT36.2 UT1.F1
RTD3_USB_PWR_EN: RT12.2 UH1.BE21
RTD3_USB_PWR_EN_R: RT12.1 RT37.1 UT1.D4
SA_SW: PL508.1 PR5002.1 PU511.11 PU511.12
SATA_DET#: JHDD.19 RS8.2
SATA_GP0: JHDD.16 RS2.1 RS3.1 UH1.AH41
SATA_GP1: JSSD3.69 R364.1 UH1.AJ43
SATA_GP3: JSSD2.69 R365.1 UH1.AN47
SATA_GP4: JSSD1.69 R363.1 UH1.AM46
SATA_PRX_C_DTX_N0: CH229.1 JHDD.1
SATA_PRX_C_DTX_P0: CH230.1 JHDD.2
SATA_PRX_DTX_N0: CH229.2 UH1.C45
SATA_PRX_DTX_P0: CH230.2 UH1.C46
SATA_PTX_C_DRX_N0: CH227.1 JHDD.4
SATA_PTX_C_DRX_P0: CH228.1 JHDD.5
SATA_PTX_DRX_N0: CH227.2 UH1.B38
SATA_PTX_DRX_P0: CH228.2 UH1.C38
SCL_CHG: PR721.2 PU700.12
SD_RCOMP_1P8: RH214.1 UH1.BE5
SD_RCOMP_3P3: RH215.1 UH1.BE4
SDA_CHG: PR720.2 PU700.11
SENSE_VCCIO: PR5012.1 PR5014.2 PR5017.1
SERIRQ: RH111.1 UE5.3 UH1.AW35
SLEEVE: LA7.2 RA26.2 UA1.37
SLEEVE_R: CA45.1 CA91.1 DA5.3 JACK1.3 LA7.1
SLP_S3: QE1.3 RE15.2 UE1.12
SLP_S5: QE4.3 RE16.2 UE1.11
SM_PG_CTRL: PR211.2 RH525.2 UC2.4
SMBALERT#: RH95.2 UH1.BE25
SML0CLK: RH501.2 UH1.BF25 UM4.11
SML0DATA: RH502.2 UH1.BE24 UM4.10
SML1CLK: QH5.6 RH460.2 UH1.BF27
SML1DATA: QH5.3 RH461.2 UH1.BE27
SNB_1.0VS_VGAP: PC802.1 PR803.2
SNB_1.2V: PC211.1 PR202.2
SNB_3V: PC109.1 PR110.2
SNB_5V: PC110.1 PR111.2
SNB_+1.8VGS: PC806.1 PR809.2
SNB_+1VALWP: PC309.1 PR305.2
SNB_VCCIO: PC591.1 PR5009.2
SNUB_CHG: PC715.1 PR713.2
SPEAKER_SEL: JSPK.5 UE10.2
SPI_CLK: RE11.2 RE22.1 UE1.15
SPI_CS#: RE12.2 UE1.14 UE2.1
SPI_MISO: RE10.2 UE1.16
SPI_MOSI: RE9.2 UE1.17
SPK_L+_CONN: CA255.1 DA7.2 JSPK.4 LA51.2 RA61.1
SPK_L-_CONN: DA7.3 JSPK.3 RA57.2 RA59.1
SPK_R+_CONN: CA257.1 DA8.2 JSPK.2 LA53.2 RA65.1
SPK_R-_CONN: DA8.3 JSPK.1 RA60.2 RA64.1
SRN_CHG: PR723.1 PU700.19
SRP_CHG: PR722.1 PU700.20
SS: PC6002.2 PC6017.1 PR6015.2 PU6000.28
STRAP0: RG78.1 RG90.2 UG9.BL3
STRAP1: RG79.1 RG91.2 UG9.BL4
STRAP2: RG80.1 RG92.2 UG9.BM4
STRAP3: DG8.2 RG81.1 RG93.2 UG9.BM5
STRAP3_PCH: DG8.1 RG555.2 UH1.M45
STRAP4: RG82.1 RG94.2 UG9.BK5
STRAP5: DG9.2 RG83.1 RG95.2 RG575.2 UG9.BJ5
STRAP5_PCH: DG9.1 RG556.2 UH1.L48
SUSACK#: UE5.97 UH1.BE35
SUSCLK: JSSD1.68 JSSD2.68 JSSD3.68 JWLAN.42 UH1.BE45
SUSP#: PR209.2 PR5007.1 PR9000.2 Q8.3 R174.1 R182.1 RT15.2 U16.4 U20.4 UE5.116 UZ21.3
SUSP#_R: RT15.1 RT30.2 UT1.D2
SW1_2PH: PR549.2 PR595.2 PR605.2
SW1_4PH: PR546.1 PR557.1 PR601.2
SW2_4PH: PR550.1 PR587.1 PR602.2
SW3_4PH: PR551.1 PR581.1 PR603.2
SW4_4PH: PR572.1 PR582.1 PR604.2
SW_1.2V: PC204.2 PL201.2 PQ200.1 PQ200.2 PQ200.3 PQ201.5 PR202.1 PU201.16
SW_1PH: PL508.2 PR502.2
SW_+1VALWP: PC305.2 PL300.1 PQ300.1 PQ300.2 PQ300.3 PQ301.5 PR305.1 PU300.8
SYNC_OUT: TC24.1(TP-1) UA4.38
SYS_PEX_RST_MON#: RG21.1 UG9.BE2
SYS_PWROK: CE46.1 UE5.74 UH1.AU3
SYS_RESET#: CH175.1 RH5.2 RH571.1 UH1.AU2
SYS_SWCLK: JELC1.6 JELC2.4 UE1.37
SYS_SWDIO: JELC1.5 JELC2.2 UE1.34
SYSON: CE42.1 PR208.1 Q9.3 U19.4 UE5.95
TB_STAT#_CHG: PQ705.2 PR718.1 PU700.16
TBT_A_AUX_N: CT44.2 UT1.W15
TBT_A_AUX_N_C: CT44.1 RT70.2 UT4.J2
TBT_A_AUX_P: CT43.2 UT1.Y15
TBT_A_AUX_P_C: CT43.1 RT73.1 UT4.J1
TBT_A_CC1: CT112.1 DT11.1 JUSBC1.A5 UT4.L9
TBT_A_CC2: CT113.1 DT12.1 JUSBC1.B5 UT4.L10
TBT_A_SBU1: DT13.1 JUSBC1.A8 UT4.K8
TBT_A_SBU2: DT14.1 JUSBC1.B8 UT4.L8
TBT_A_TRX_DTX_N0: DT5.1 JUSBC1.B10 UT1.A21
TBT_A_TRX_DTX_N1: DT9.1 JUSBC1.A10 UT1.B15
TBT_A_TRX_DTX_P0: DT4.1 JUSBC1.B11 UT1.B21
TBT_A_TRX_DTX_P1: DT8.1 JUSBC1.A11 UT1.A15
TBT_A_TTX_C_DRX_N0: CT42.1 DT3.1 JUSBC1.A3
TBT_A_TTX_C_DRX_N1: CT40.1 DT7.1 JUSBC1.B3
TBT_A_TTX_C_DRX_P0: CT41.1 DT2.1 JUSBC1.A2
TBT_A_TTX_C_DRX_P1: CT39.1 DT6.1 JUSBC1.B2
TBT_A_TTX_DRX_N0: CT42.2 UT1.B19
TBT_A_TTX_DRX_N1: CT40.2 UT1.B17
TBT_A_TTX_DRX_P0: CT41.2 UT1.A19
TBT_A_TTX_DRX_P1: CT39.2 UT1.A17
TBT_A_USB20_L_NB: DT10.4 DT10.7 JUSBC1.B7 LT3.3
TBT_A_USB20_L_NT: DT10.2 DT10.8 JUSBC1.A7 LT2.2
TBT_A_USB20_L_PB: DT10.5 DT10.6 JUSBC1.B6 LT3.2
TBT_A_USB20_L_PT: DT10.1 DT10.9 JUSBC1.A6 LT2.3
TBT_A_USB20_N: RT112.1 UT1.D20
TBT_A_USB20_NB: LT3.4 UT4.L7
TBT_A_USB20_NT: LT2.1 UT4.L6
TBT_A_USB20_P: RT113.1 UT1.E20
TBT_A_USB20_PB: LT3.1 UT4.K7
TBT_A_USB20_PT: LT2.4 UT4.K6
TBT_CIO_PLUG_EVENT#: RT29.2 UH1.AV21 UT1.W2
TBT_EE_CLK: RT52.2 RT101.1 RT122.1 UT2.6
TBT_EE_CLK_R: RT52.1 UT1.AB4
TBT_EE_CS_N: RT50.2 RT100.1 UT1.AC3 UT2.1
TBT_EE_DI: RT98.1 UT1.AB3 UT2.5
TBT_EE_DO: RT49.2 RT99.1 UT1.AC4 UT2.2
TBT_EE_WP_N: RT48.2 UT1.V1 UT2.3
TBT_FORCE_PWR: RT13.2 UH1.Y47
TBT_FORCE_PWR_R: RT13.1 RT35.1 RT94.2 UT1.H4
TBT_HDMI_DDC_CLK: T9.1(TP-1) UT1.Y2
TBT_HDMI_DDC_DATA: T7.1(TP-1) UT1.Y1
TBT_HOLD_N: RT51.2 UT2.7
TBT_I2C_SCL: RT27.2 UT1.U2 UT4.D2
TBT_I2C_SDA: RT26.2 UT1.U1 UT4.D1
TBT_PCIE_WAKE#: RT10.2 UE5.70
TBT_PCIE_WAKE_N: RT10.1 RT28.2 UT1.W1
TBT_RBIAS: RT25.1 UT1.H6
TBT_RESET_N: RT23.1 RT80.1 RT102.2 UT1.F4
TBT_RESET_N_EC: RT23.2 UE5.15
TBT_RSENSE: RT25.2 UT1.J6
TBT_RST#_R: RT1.2 UT1.L4
TBT_SRC_CFG1: RT11.1 UT1.AA1
TBT_SRC_HPD: RT4.1 UT1.G1
TBT_SVR_IND: LT1.1 UT1.C1 UT1.C2 UT1.D1
TBT_TCK: RT7.2 UT1.T4
TBT_TDI: RT9.2 UT1.Y4
TBT_TDO: RT6.2 UT1.W4
TBT_TEST_EN: RT17.1 UT1.E1
TBT_TEST_PWG: RT18.1 UT1.AB5
TBT_TMS: RT8.2 UT1.V4
TBT_TMU_CLK_OUT: RT34.1 T2.1(TP-1) UT1.V2
TBT_XTAL_25_IN: RT116.1 UT1.D22
TBT_XTAL_25_OUT: RT117.1 UT1.D23
TBTA_DEBUG1: RT71.1 UT4.L2
TBTA_DEBUG2: RT72.1 UT4.K2
TBTA_DIG_AUD_N: RT69.1 UT4.K3
TBTA_DIG_AUD_P: RT68.1 UT4.L3
TBTA_HPD: RT41.1 UT1.M4 UT4.C10
TBTA_I2C_INT: RT32.2 UT1.J4 UT4.C1
TBTA_I2C_SCL1_R: RT57.2 RT60.2 UT4.B5
TBTA_I2C_SDA1_R: RT58.2 RT59.2 UT4.A5
TBTA_LDO_BMC: CT98.1 UT4.E1
TBTA_LSRX: RT42.1 UT1.A4 UT4.K4
TBTA_LSTX: RT21.2 RT40.1 UT1.A5 UT4.L4
TBTA_MRESET: RT63.1 UT4.E11
TBTA_ROSC: RT75.1 UT4.G2
TBTB_I2C_INT: RT33.2 UT1.E2
THERMDA: UT1.AB23 UT1.AC23
TOBII_INT#: JTOBII.6 RE300.1 RE651.2
TOBII_PWR_EN#: CE79.1 RE652.2 UE6.17 UE12.4
TON_1.2V: PR206.2 PU201.9
TP_CLK: RE100.2 RE654.1 UE5.87
TP_CLK_R: JTP.12 RE654.2
TP_DATA: RE101.2 RE655.1 UE5.88
TP_DATA_R: JTP.13 RE655.2
TP_EN: CT114.1 QT2.2 UE10.21 UT5.3
TP_INT#: JTP.8 RE661.2 UE5.38 UH1.BE15
TP_LED_B#: Q28.5 R146.2 R153.2 UE3.14
TP_LED_B#_DRV: Q28.2 Q28.3 R144.2
TP_LED_B#_DRV#: JTP.3 Q28.6 R153.1
TP_LED_EN: Q2410.2 UE5.25
TP_LED_G#: Q29.5 R152.2 R154.2 UE3.11
TP_LED_G#_DRV: Q29.2 Q29.3 R150.2
TP_LED_G#_DRV#: JTP.4 Q29.6 R152.1
TP_LED_R#: Q34.5 R147.2 R151.2 UE3.10
TP_LED_R#_DRV: Q34.2 Q34.3 R145.2
TP_LED_R#_DRV#: JTP.5 Q34.6 R151.1
TRIP_+1VALWP: PR303.2 PU300.2
TRONL_LED_B_DRV#: JTRONL.5 JTRONL.10 UE8.5
TRONL_LED_G_DRV#: JTRONL.4 JTRONL.9 UE8.4
TRONL_LED_R_DRV#: JTRONL.3 JTRONL.8 UE8.3
TRONR_LED_B_DRV#: JTRONR.5 JTRONR.10 UE8.9
TRONR_LED_G_DRV#: JTRONR.4 JTRONR.9 UE8.8
TRONR_LED_R_DRV#: JTRONR.3 JTRONR.8 UE8.6
TS_EN: JEDP.34 UE6.14
TSENSE_2PH: PC531.1 PR568.1 PU500.25
TSENSE_4PH: PC529.1 PR567.1 PU500.14
TYPEC_DET#: QU1.1 RU26.2 UE10.18
UART_2_PRXD_DTXD: JWDB.3 JWLAN.22 RC62.1 UH1.BD20
UART_2_PTXD_DRXD: JWDB.2 JWLAN.24 RC63.1 UH1.BE20
UG_3V: PQ100.4 PU100.10
UG_5V: PQ102.4 PU100.16
UG_+1VALWP: PQ300.4 PU300.9
USART_RX: JELC1.2 RE6.1 UE1.31
USART_TX: JELC1.3 RE7.1 UE1.30
USB1.8_EN: CU91.1 RU31.2 UE10.9 UU8.3
USB2_COMP: RH109.1 UH1.F4
USB3_A_PRX_L_DTX_N2: DU28.1 JUSBC2.A10 LU10.3
USB3_A_PRX_L_DTX_P2: DU29.1 JUSBC2.A11 LU10.2
USB3_A_PRX_RD_DTX_N2: LU10.4 UU2.22
USB3_A_PRX_RD_DTX_P2: LU10.1 UU2.23
USB3_A_PTX_C_DRX_N1: CU80.1 LU8.1
USB3_A_PTX_C_DRX_P1: CU79.1 LU8.4
USB3_A_PTX_L_DRX_N1: DU25.1 JUSBC2.A3 LU8.2
USB3_A_PTX_L_DRX_P1: DU24.1 JUSBC2.A2 LU8.3
USB3_A_PTX_RD_DRX_N1: CU80.2 UU2.17
USB3_A_PTX_RD_DRX_P1: CU79.2 UU2.16
USB3_B_PRX_L_DTX_N1: DU22.1 JUSBC2.B10 LU7.2
USB3_B_PRX_L_DTX_P1: DU23.1 JUSBC2.B11 LU7.3
USB3_B_PRX_RD_DTX_N1: LU7.1 UU2.13
USB3_B_PRX_RD_DTX_P1: LU7.4 UU2.14
USB3_B_PTX_C_DRX_N2: CU82.1 LU11.4
USB3_B_PTX_C_DRX_P2: CU81.1 LU11.1
USB3_B_PTX_L_DRX_N2: DU26.1 JUSBC2.B3 LU11.3
USB3_B_PTX_L_DRX_P2: DU27.1 JUSBC2.B2 LU11.2
USB3_B_PTX_RD_DRX_N2: CU82.2 UU2.19
USB3_B_PTX_RD_DRX_P2: CU81.2 UU2.20
USB3_CC1: DU20.1 DU20.9 JUSBC2.A5 UU7.11
USB3_CC2: DU20.2 DU20.8 JUSBC2.B5 UU7.13
USB3_PRX_C_DTX_N8: CI38.2 JCDRA.36
USB3_PRX_C_DTX_P8: CI39.2 JCDRA.37
USB3_PRX_C_RD_DTX_N1: CU84.1 UU2.44
USB3_PRX_C_RD_DTX_P1: CU83.1 UU2.45
USB3_PRX_DTX_N1: CU84.2 UH1.D11
USB3_PRX_DTX_N6: LU5.1 UH1.G14
USB3_PRX_DTX_N7: JIO.26 UH1.G17
USB3_PRX_DTX_N8: CI38.1 UH1.R21
USB3_PRX_DTX_P1: CU83.2 UH1.C11
USB3_PRX_DTX_P6: LU5.4 UH1.F14
USB3_PRX_DTX_P7: JIO.27 UH1.F16
USB3_PRX_DTX_P8: CI39.1 UH1.P21
USB3_PRX_L_DTX_N6: DU2.1 DU2.9 JUSB1.5 LU5.2
USB3_PRX_L_DTX_P6: DU2.2 DU2.8 JUSB1.6 LU5.3
USB3_PTX_C_DRX_N6: CU13.1 LU4.1
USB3_PTX_C_DRX_P6: CU12.1 LU4.4
USB3_PTX_C_RD_DRX_N1: CU49.1 UU2.40
USB3_PTX_C_RD_DRX_P1: CU50.1 UU2.41
USB3_PTX_DRX_N1: CU49.2 UH1.F9
USB3_PTX_DRX_N6: CU13.2 UH1.C17
USB3_PTX_DRX_N7: JIO.29 UH1.A17
USB3_PTX_DRX_N8: JCDRA.42 UH1.B18
USB3_PTX_DRX_P1: CU50.2 UH1.F7
USB3_PTX_DRX_P6: CU12.2 UH1.C16
USB3_PTX_DRX_P7: JIO.30 UH1.B17
USB3_PTX_DRX_P8: JCDRA.43 UH1.C18
USB3_PTX_L_DRX_N6: DU2.4 DU2.7 JUSB1.8 LU4.2
USB3_PTX_L_DRX_P6: DU2.5 DU2.6 JUSB1.9 LU4.3
USB3_RUF1: DU20.4 DU20.7 JUSBC2.A8
USB3_RUF2: DU20.5 DU20.6 JUSBC2.B8
USB20_N1: UH1.J3 UU1.2
USB20_N2: JIO.23 UH1.N13
USB20_N3: LM1.1 UH1.K4
USB20_N3_R: JCDRA.40 LM1.2
USB20_N4: UE1.32 UH1.M10
USB20_N6: DV2.3 JEDP.17 UH1.K7
USB20_N7: LV2.1 UH1.L4
USB20_N7_R: DV4.3 JEDP.19 LV2.2
USB20_N8: LU9.4 UH1.G4
USB20_N8_R: DU11.3 JUSBC2.A7 JUSBC2.B7 LU9.3
USB20_N9: LE3.1 RE647.1 UH1.M6
USB20_N9_R: JTOBII.3 LE3.2 RE647.2
USB20_N10: DK1.2 JPK.10 UH1.H3
USB20_N11: RT114.1 UH1.R10
USB20_N11_R: RT112.2 RT114.2 UT4.K5
USB20_N14: JWLAN.5 UH1.E5
USB20_P1: UH1.J2 UU1.3
USB20_P2: JIO.24 UH1.N15
USB20_P3: LM1.4 UH1.K3
USB20_P3_R: JCDRA.39 LM1.3
USB20_P4: UE1.33 UH1.L9
USB20_P6: DV2.2 JEDP.18 UH1.K6
USB20_P7: LV2.4 UH1.L3
USB20_P7_R: DV4.2 JEDP.20 LV2.3
USB20_P8: LU9.1 UH1.G5
USB20_P8_R: DU11.2 JUSBC2.A6 JUSBC2.B6 LU9.2
USB20_P9: LE3.4 RE648.1 UH1.N8
USB20_P9_R: JTOBII.4 LE3.3 RE648.2
USB20_P10: DK1.3 JPK.11 UH1.H2
USB20_P11: RT115.1 UH1.P9
USB20_P11_R: RT113.2 RT115.2 UT4.L5
USB20_P14: JWLAN.3 UH1.F6
USB31_PWR_EN: UE10.19 UU2.3
USB_FLIP: QU2.2 RU19.1 UU7.18
USB_MODE: RU20.1 UU7.19
USB_OC0#: RPH6.4 UH1.AH36 UU1.13
USB_OC1#: CU17.1 RPH6.3 UH1.AL40 UU3.3
USB_OC2#: RPH6.1 UH1.AJ44
USB_OC3#: RPH6.2 UH1.AL41
USB_PWR_EN: CU16.1 RE645.2 UE5.117 UU3.4
USB_SEL0: RU30.1 UU2.28
USB_SEL1: RU29.2 UU2.27
USB_XTAL24_IN: RU34.2 UU2.25
USB_XTAL24_IN_R: CU51.1 RU28.1 RU34.1 YU1.1
USB_XTAL24_OUT: RU35.2 UU2.26
USB_XTAL24_OUT_R: CU52.1 RU28.2 RU35.1 YU1.3
USBC_PWR_EN: CU35.1 RE649.2 UE10.5 UU7.6
USBCHG_DET#: CU27.2 CU28.1 DU6.2 JUSB1.10 RU4.2
USBCHG_DET_D: PD100.3 RU6.1 UU5.4
USBCHG_DET_EC#: CU29.1 DU6.1 RU6.2 UE5.75
VCIN0_PH1: PH1.1 PR24.1 PR25.1 UE5.109
VCIN1_AC_IN: CE40.2 DH1.1 PR714.2 PR715.1 PU700.5 QE3.5 UE5.110
VCIN1_ADP_PROCHOT: PC13.2 PR23.1 PR26.2 UE5.102
VCIN_ BATT_TEMP: CE35.2 PC14.1 PD3.2 PR16.1 PR22.2 PR727.1 UE5.63
VCLK_5V: PR107.1 PU100.19
VCOUT0_MAIN_PWR_ON#: PR114.1 UE5.104
VCOUT1_PROCHOT#: RE84.2 RE85.2 UE5.103
VD33STB: RA25.2 UA1.10
VGA_EN: RM14.2 RM87.1 UM8.26
VGA_SMB_CK2: QG6.4 RG17.1 UG9.BJ8
VGA_SMB_DA2: QG6.1 RG18.1 UG9.BH8
VGND: CU53.2 CU54.2 CU55.2 CU56.2 CU90.2 RU33.1 UU2.6 UU2.7
VL: PC111.1 PU100.13
VR_PWRGD: PR516.2 PU500.45 UE5.101
VR_SVID_ALERT#: PR506.2 PR517.1 RH152.2 RH153.1
VR_SVID_CLK: PR507.2 PR515.2 UC1.BH32
VR_SVID_DATA: PR505.1 PR519.2 RH151.2 UC1.BH29
VROM_SEL: RH588.2 RH589.2 UG16.7 UG16.10 UH1.AW26
VSB_N_001: PC10.2 PQ3.3 PR12.2 PR13.2
VSB_N_002: PC12.1 PQ4.2 PR17.1
VSB_N_003: PQ4.1 PR13.1
VSENSEN_L: RA61.2 RA79.1 UA4.27
VSENSEN_R: RA65.2 RA82.1 UA4.30
VSN_1PH: PC500.2 PR509.2 PU500.51
VSN_2PH: PC514.1 PR530.1 PU500.37
VSN_4PH: PC512.2 PR527.2 PU500.2
VSP_1PH: PC508.2 PR511.2 PU500.52
VSP_2PH: PC513.1 PR529.1 PU500.38
VSP_4PH: PC511.2 PR523.2 PU500.1
VTTREF_1.2V: PC210.1 PU201.4
WAKE#: RH4.2 RH453.1 UH1.BB47
WAKE_PCH#: RH545.1 UH1.BG44
WL_OFF#: RH520.2 RN15.2 UH1.AP24
WL_OFF#_R: CN9.1 JWLAN.48 RN5.2 RN15.1
WOOFER_SEL: JIO.21 UE10.7
XCLK_BIASREF: RH71.2 RH590.2 UH1.T3
XDP_HOOK0: JPCMC.27 RC355.1
XDP_ITP_PMODE: JPCMC.26 RC353.2 UH1.AL3
XDP_PRDY#: JPCMC.34 UC1.BP27 UH1.AM5
XDP_PREQ#: JPCMC.33 RH156.2 UC1.BL30 UH1.AL2
XDP_SPI_IO2: JPCMC.24 RC354.1
XDP_SPI_SI: JPCMC.25 RC9.2 RH1.1
XDP_TCK: JPCMC.31 RC348.1 UH1.AJ3
XDP_TDI: JPCMC.29 RH495.2 UC1.BL32 UH1.AH2
XDP_TDO: JPCMC.35 RH496.2 UC1.BT28 UH1.AH3
XDP_TMS: JPCMC.30 RH494.2 UC1.BP28 UH1.AJ4
XMP1: PR212.1 UH1.BE34
XMP1-1: PC217.1 PQ202.2 PR212.2 PR216.1
XMP1-2: PQ202.6 PR213.2
XMP2: PR214.1 UH1.BA33
XMP2-1: PC218.1 PQ202.5 PR214.2 PR217.1
XMP2-2: PQ202.3 PR215.2
XTAL24_IN: RH91.2 UH1.U10
XTAL24_IN_R: CH47.1 RH72.1 RH91.1 YH2.1
XTAL24_OUT: RH92.2 UH1.U9
XTAL24_OUT_R: CH48.1 RH72.2 RH92.1 YH2.3
XTALIN: CG75.2 RG99.1 UG9.BL6 YG1.1
XTALOUT: CG76.2 RG99.2 UG9.BM6 YG1.3
XTALOUTBUFF_R: RG98.1 UG9.BK6
XTLI: RL16.2 UL1.8
XTLI_R: CL8.1 RL16.1 YL1.1
XTLO: RL17.2 UL1.7
XTLO_R: CL9.1 RL17.1 YL1.3
N04520: CU53.1 CU54.1 CU90.1 LU14.1 UU2.10 UU2.11
N102521: RU17.1 UU7.16
N102523: RU16.1 UU7.20
N102525: RU15.1 UU7.1
N102559: RU18.1 UU7.17
N102569: RU23.2 UU7.8
N102573: RU14.1 UU7.9
N102595: RU14.2 UU7.10
N102623: RU21.2 UU7.7
N102677: QU1.2 RU24.2 RU25.1
N102751: T142.1(TP-1) UU2.38
N102753: T143.1(TP-1) UU2.37
N102771: RU32.2 UU2.36
N102835: LU13.1 UU2.8 UU2.9
N16758539: PC6416.1 PR6400.2 PU6400.18
N16760382: PR6414.2 PR6415.2 PU6400.11
N16761462: PC6437.1 PR6417.1 PR6418.1 PU6400.7
N16857461: DS1.1 QS3.1
N16910514: PC6439.1 PR6416.2 PR6417.2 PR6426.2
N16935748: RG570.1 UG31.12
N16935754: CG488.1 RG200.2 UG31.1
N17186119: PR6421.2 PU6400.10
N17230071: PC6423.2 PR6405.2
N17230179: PC6415.2 PR6407.2
N17235867: PR6412.2 PU6400.5
N17244796: PR6418.2 PR6423.1
N17249165: PC6434.1 PR6415.1 PR6422.2
N17249236: PC6434.2 PR6414.1
N17431129: CE36.1 RE89.1
N17434554: RE74.2 UE5.107
N17956500: RX9.1 UX3.3
N17957050: RX3.2 UX3.4
N18370426: RT110.2 RT111.2 UT5.1 UT5.2 UT5.4
N19111564: RPT1.5 RPT1.6 RPT1.7 RPT1.8 RT130.1 RT131.2
N19518338: CA51.2 UA2.B3
N19518342: RA46.2 UA2.A1
N19518343: RA47.2 UA2.A3
N19518406: RA39.2 UA3.A3
N19518407: RA38.2 UA3.A1
N19518412: CA44.2 UA3.B3
N19518451: CA11.1 RA2.2
N19518500: CA21.1 UA1.27
N19518501: CA21.2 UA1.28
N19518503: CA20.1 UA1.25
N19518504: CA20.2 UA1.26
N19518526: CA23.1 CA85.1 UA1.18
N19518594: CA3.1 CA4.1 RA68.1 UA1.46
N19518614: CA7.1 CA8.1 RA69.1 UA1.51
N19518635: CA26.1 CA27.1 UA1.43
N19518638: CA33.1 UA1.41
N19518639: CA30.1 CA31.1 UA1.21
N19518650: CA32.1 UA1.44
N19518666: CA25.1 UA1.29
N19518674: CA24.1 UA1.31
N19518681: CA19.2 UA1.23
N19518684: CA19.1 RA15.2 RA16.1
N19529476: CA74.1 UA4.23
N19529515: CA66.2 UA4.40
N19529521: CA71.2 RA51.2 UA4.3
N19529522: RA51.1 RA52.1 UA4.6
N19529526: CA67.2 UA4.2
N19529527: CA68.2 UA4.50
N19529528: CA69.2 UA4.49
N19529529: CA70.2 UA4.41
N19529531: RA62.2 UA4.5
N19616464: CG230.1 CG231.1 CG232.1 LG4.2 UG9.BC12
N19616930: CG233.1 CG234.1 CG235.1 CG236.1 CG237.1 CG238.1 CG239.1 LG3.2 UG9.AF11 UG9.BB24 UG9.BD12 UG9.U42
N19618056: RG101.1 UG9.BJ6
N19842722: RG130.1 UG5.J13
N19842724: RG126.1 UG5.J1
N19842731: RG128.1 UG5.J10
N19847413: RG120.1 UG4.J13
N19847417: RG116.1 UG4.J1
N19847426: RG118.1 UG4.J10
N19849394: RG119.1 UG3.J13
N19849396: RG115.1 UG3.J1
N19849403: RG117.1 UG3.J10
N19854250: RG109.1 UG2.J13
N19854254: RG105.1 UG2.J1
N19854263: RG107.1 UG2.J10
N19855299: QG2.1 RG111.1
N19856231: RG108.1 UG1.J13
N19856233: RG104.1 UG1.J1
N19856240: RG106.1 UG1.J10
N19942790: CU27.1 DU8.2 RU5.2 UU5.2
N19967780: RU3.2 UU1.16
N19967783: RU2.2 UU1.15
N19967793: RU7.2 UU1.8
N19967795: RU1.2 UU1.4
N20019079: RG582.2 UG31.2
N20112847: CT37.1 RT116.2 YT1.1
N20112857: CT38.1 RT117.2 YT1.3
N20124859: CT153.1 CT154.1 CT155.1 LT4.1 UT1.R13
N20496102: CA90.2 RA76.1
N20496103: CA89.2 RA75.1
N20496104: CA88.2 RA74.1
N20496105: CA87.2 RA73.1
N20647992: CH232.1 RH591.2
N20649294: CE20.1 RE22.2
N20653356: CT157.2 RT123.1
N20764785: RH580.1 UH1.F3
N20764786: RH581.1 UH1.G3
N20764806: RH89.2 UH1.BB36
N20904379: RT22.1 UT4.A6 UT4.A7 UT4.A8 UT4.B7
N20905578: CT104.1 UT4.H7
N20905857: RT83.2 UT4.F1
N20968008: QE53.5 RE527.1 RE528.2
N20968033: QE54.2 RE449.2 RE511.1
N20968035: QE39.5 RE455.2 RE456.1
N20968040: QE29.5 RE396.2 RE397.1
N20968043: QE29.2 RE399.2 RE401.1
N20968050: QE39.2 RE453.1 RE454.2
N20968053: QE49.5 RE512.1 RE513.2
N20968066: QE49.2 QE49.3 RE511.2
N20968067: QE40.2 RE458.1 RE460.2
N20968070: QE40.5 RE461.2 RE462.1
N20968081: QE41.2 RE465.1 RE467.2
N20968083: QE41.5 RE466.2 RE468.1
N20968085: QE54.5 RE514.1 RE517.2
N20968092: QE50.5 RE515.1 RE516.2
N20968099: QE50.2 QE50.3 RE514.2
N20968108: QE42.2 RE472.1 RE474.2
N20968112: QE42.5 RE471.2 RE473.1
N20968116: QE43.2 RE479.1 RE480.2
N20968120: QE43.5 RE476.2 RE478.1
N20968122: QE55.2 RE518.1 RE521.2
N20968127: QE51.5 RE519.1 RE520.2
N20968134: QE51.2 QE51.3 RE518.2
N20968141: QE55.5 RE522.1 RE525.2
N20968146: QE52.5 RE523.1 RE524.2
N20968153: QE52.2 QE52.3 RE522.2
N20968157: QE44.2 RE485.1 RE486.2
N20968166: QE44.5 RE482.2 RE484.1
N20968170: QE45.2 RE491.1 RE492.2
N20968174: QE45.5 RE488.2 RE490.1
N20968178: QE46.2 RE496.1 RE498.2
N20968182: QE46.5 RE495.2 RE497.1
N20968184: QE56.2 RE526.1 RE529.2
N20968195: QE53.2 QE53.3 RE526.2
N20968204: QE47.2 RE501.1 RE503.2
N20968208: QE47.5 RE502.2 RE504.1
N20968214: QE48.2 RE508.1 RE510.2
N20968218: QE48.5 RE507.2 RE509.1
N20972959: JLAN.9 RL8.1
N20972981: RL5.1 UL2.3
N20972982: CL31.1 JLAN.12 LL1.2
N20973042: RL2.2 UL1.5
N20973177: QL3.1 RL13.2 RL14.2
N20986399: RE161.1 UE12.3
N20995131: RE25.2 UE3.24
N20995135: RE31.1 UE3.30
N20999302: RM72.1 UM8.27
N20999314: RM61.2 UM8.52
N20999316: RM64.1 RM66.1 UM8.48
N21000707: RM21.2 RM96.2 UM4.1
N21000709: CM99.1 RM28.1 RM29.1
N21000711: CM98.1 RM27.1 RM38.1
N21000719: CM16.1 CM17.1 RM18.2 UM4.20
N21000750: RM25.2 UM4.18
N21000786: RM28.2 UM4.13
N21000788: RM27.2 UM4.14
N21000830: QM1.2 QM2.6 RM92.2
N21000850: QM2.3 QM3.2 RM94.2
N21000877: RM20.2 UM4.4
N21002214: RE14.2 UE2.3
N21002223: RE11.1 UE2.6
N21002224: RE9.1 UE2.5
N21002246: RE13.2 UE2.7
N21002352: RE10.1 UE2.2
N21002397: RE20.1 UE9.3
N21003330: R181.2 U2407.7
N21003701: DF1.1 JFAN1.3 RF3.1
N21003743: DF2.1 JFAN2.3 RF6.1
N21024703: C3.1 UZ21.6
N21194807: CV374.1 RV13.2
N21200526: RH153.2 UC1.BH31
N21200532: RH158.2 UC1.BR30
N21238299: RE166.2 UE8.24
N21238303: RE167.1 UE8.30
N21643800: PQ6400.1 PQ6401.1 PR6429.2 PR6430.2
N21646778: PQ6402.1 PQ6403.1 PR6431.2 PR6433.2
N21748624: PC725.1 PQ703.4 PR733.1
N21874242: PQ9.6 PR27.2
N21874255: PQ9.5 PR29.1 PR31.2
N21874275: PC15.2 PQ9.2 PR33.2
N21874281: PC15.1 PQ9.3 PR32.2
N21995444: CT156.1 RT122.2
N22226841: QV97.5 UX1.4
N22301470: RG157.1 UG7.J13
N22301471: RG158.1 UG7.J1
N22301473: RG159.1 UG7.J10
N22301475: RG162.1 UG8.J13
N22301476: RG161.1 UG8.J1
N22301478: RG163.1 UG8.J10
N23042187: RG564.1 UG9.BE5
N23258859: T144.1(TP-1) UC1.BP13
N23259058: RH592.2 UC1.A36
N23259061: RH593.2 UC1.A37
N24138892: RH6.1 RH7.1 UH1.BE48 UH1.BE49
N24314166: QV3.1 RX39.2 UV3.15
N24365027: CE63.2 RE530.2 UE10.3
N24371838: JHDMI.13 RV655.2
N24377091: QV97.2 UX2.4
N24377100: QX3.2 RX6.1
N24654525: C2522.1 J6.2 U18.1
N24654698: R367.1 U18.3
N25145265: QV2.1 RV12.2
N25301591: RG7.1 RG562.1 UG10.4
N25301635: RG26.1 UG9.BK23
N25301647: QG501.1 RG572.2
N25301655: QG500.5 RG508.1 RG519.1
N25585283: DV13.1 RV653.2
N25585284: DV12.1 RV649.2
N25732286: CG64.1 UG12.12
N25732288: CG65.1 UG12.10
N25785396: QG502.6 RG516.2 UG22.2
N25788545: QE57.5 RE637.2 RE638.1
N25788553: QE57.3 RE636.2
N25788554: QE57.6 RE639.2
N25788555: QE57.2 RE640.2 RE641.1
N25802636: RG65.2 UG11.5
N25805684: RG19.1 UG9.BG8
N25805686: RG20.1 UG9.BF8
N25867602: QE13.6 RE160.2
N25867965: QE21.6 RE155.2
N25868866: QE22.6 RE157.2
N26209034: RE646.2 UE5.2
N26229867: RH598.1 UH1.AF19 UH1.AF20
N26231028: CH36.1 T146.1(TP-1) UH1.BG5
N26232649: T145.1(TP-1) UH1.AJ22 UH1.AJ23 UH1.AK22 UH1.AK23
N26795549: QG512.1 RG575.1
N26956296: PC9001.1 PR9000.1 PR9001.1 PU9000.3
N26956300: PC9000.1 PJP9000.2 PU9000.1
N26956432: PC9002.1 PU9000.4
N27252307: RV671.1 UV3.9
N27252308: RV672.1 UV3.12
N27420614: T147.1(TP-1) UH1.R6
N27472757: QG510.2 RG1.1
N28080092: CG313.1 RG102.2 RG523.2
N28084182: CG314.1 RG103.2 RG524.2
N28087019: CG315.1 RG113.2 RG525.2
N28087890: CG316.1 RG114.2 RG526.2
N28090623: CG317.1 RG124.2 RG527.2
N28092415: CG318.1 RG125.2 RG528.2
N28094238: CG387.1 RG160.2 RG531.2
N28096445: CG388.1 RG164.2 RG532.2
N28329347: QG8.1 RG156.1
N28330529: QG4.1 RG133.1
N28331699: QG3.1 RG122.1
N28597766: PC532.1 PR577.2 PU500.16
N28597770: PC530.2 PR571.2 PU500.15
N28597795: PC522.1 PR538.1 PU500.36
N28597846: PH503.1 PR567.2 PR586.1
N28597859: PC521.1 PR540.2
N28597868: PH504.1 PR568.2 PR570.1
N28597881: PC520.1 PR534.1 PU500.3
N28597896: PR524.1 PU500.43
N28598015: PC517.1 PR535.2
N28598023: PC511.1 PC512.1 PR525.2 PR527.1
N28598065: PC509.2 PR520.1
N28598080: PH501.2 PR543.2 PR547.1
N28598124: PC513.2 PC514.2 PR530.2 PR531.1
N28598150: PC500.1 PC503.2 PR508.2 PR509.1
N28598222: PC518.1 PR537.2
N28598224: PC516.1 PR533.2
N28598271: PC503.1 PC508.1 PR510.2 PR511.1
N28598352: PR545.2 PU500.27
N28598562: PH502.2 PR544.2 PR548.1
N28598616: PH500.2 PR501.1
N28601001: PR563.2 PU503.1
N28601008: PR566.2 PU503.16
N28601054: PR556.2 PU502.16
N28601064: PR552.2 PU502.1
N28601066: PR554.2 PU502.7
N28601068: PC541.1 PU502.5
N28601070: PC541.2 PR554.1
N28601086: PC548.1 PR555.2
N28601170: PC550.2 PR564.1
N28601172: PR564.2 PU503.7
N28601174: PC550.1 PU503.5
N28601188: PC556.1 PR565.2
N28601213: PC540.2 PR553.2 PU502.3
N28601267: PC549.2 PR5004.2 PU503.3
N28602138: PR576.2 PU504.16
N28602178: PR573.2 PU504.1
N28602204: PC558.1 PU504.5
N28602206: PC558.2 PR574.1
N28602208: PR574.2 PU504.7
N28602236: PC557.2 PR5020.2 PU504.3
N28602391: PC564.1 PR575.2
N28602475: PR592.2 PU510.7
N28602479: PC574.1 PU510.5
N28602493: PC573.2 PR5024.2 PU510.3
N28602593: PC580.1 PR593.2
N28602604: PC574.2 PR592.1
N28602621: PR591.2 PU510.1
N28602627: PR594.2 PU510.16
N28603914: PR585.2 PU507.16
N28603920: PR590.2 PU507.1
N28603944: PC567.1 PU507.5
N28603948: PR583.2 PU507.7
N28603964: PC566.2 PR5022.2 PU507.3
N28604013: PC586.1 PU511.5
N28604017: PR5005.2 PU511.7
N28604029: PC588.2 PR5025.2 PU511.3
N28604096: PR5006.2 PU511.16
N28604102: PR5001.2 PU511.1
N28604619: PC567.2 PR583.1
N28604630: PC570.1 PR584.2
N28604700: PC586.2 PR5005.1
N28604706: PC587.1 PR5002.2
N29076894: QG500.6 RG530.2 RG540.2
N29125650: RG529.1 UG11.9
N29401212: RE32.2 UE4.24
N29401214: RE37.1 UE4.30
N29700600: RG535.2 UG24.2 UG24.3
N29702846: LX8.1 RX38.2
N29702855: LX7.1 RX37.2
N29702861: LX6.1 RX36.2
N29702867: LX5.1 RX35.2
N29702873: LX4.1 RX34.2
N29702889: LX3.1 RX33.2
N29702919: LX2.1 RX32.2
N29702925: LX1.1 RX31.2
N30070819: RG131.1 UG6.J13
N30070822: RG127.1 UG6.J1
N30070830: RG129.1 UG6.J10
N30816588: RA84.1 RA85.1 UA2.B2
N30963031: QG503.5 QG503.6 RG509.2
N30963037: QG503.3 RG510.2
N30963062: QG504.5 QG504.6 RG511.2
N30963079: QG504.3 RG512.2
N30963101: QG505.5 QG505.6 RG513.2
N30963122: QG505.3 RG514.2
N30964064: QG507.5 QG507.6 RG541.2
N30964087: QG507.3 RG542.2
N31201664: RG545.1 UG26.4
N31204217: RG533.2 RG568.2 UG23.2 UG23.3
N31214366: QG502.2 RG553.2
N31214429: RG554.1 UG22.4
N31214439: QG502.5 RG554.2
N31227786: QG508.5 QG508.6 RG543.2
N31227804: QG508.3 RG544.2
N31483113: PC8222.1 PQ8202.2 PR8214.2
N31483116: PQ8202.3 PR8215.1
N31483118: PQ8202.5 PQ8202.6 PR8220.2
N31787119: PC6102.1 PR6107.1
N32274706: PL6401.1 PQ6402.7 PQ6403.7 PR6424.1 PR6432.2 PR6433.1
N32295361: PL6400.1 PQ6400.7 PQ6401.7 PR6409.1 PR6428.2 PR6430.1
N32548345: RG1.2 UG29.4
N32794300: PR6202.1 PU6200.2
N32795713: PC6203.1 PR6204.2 PU6200.24
N32805176: PC6015.1 PR6040.2 PR6045.2 PR6063.2
N32805666: PC6001.1 PR6007.2 PU6000.25
N32805668: PR6005.2 PR6007.1
N32805796: PC6005.1 PC6007.1 PR6019.1 PR6022.2
N32805986: PC6017.2 PR6016.1 PR6018.1
N32806265: PC6011.2 PR6022.1 PR6024.1 PU6000.31
N32806285: PC6009.1 PC6010.2 PR6021.1 PR6023.1 PR6024.2 PR6068.1
N32806326: PC6005.2 PR6017.2
N32806527: PR6031.2 PR6038.2
N32806709: PR6015.1 PR6016.2
N32856423: PR6205.2 PU6200.5
N32856454: PC6202.2 PU6200.7
N32856474: PC6202.1 PR6205.1
N32858912: PR6201.1 PU6200.26
N32868428: PR6212.2 PU6201.5
N32868434: PC6215.2 PU6201.7
N32868438: PC6215.1 PR6212.1
N32868572: PC6216.1 PR6211.2 PU6201.24
N32868706: PR6208.1 PU6201.26
N32868738: PR6209.1 PU6201.2
N32872459: PR6114.2 PU6101.5
N32872467: PC6115.2 PU6101.7
N32872469: PC6115.1 PR6114.1
N32872562: PC6116.1 PR6113.2 PU6101.24
N32872704: PR6110.1 PU6101.26
N32872742: PR6111.1 PU6101.2
N32872879: PR6107.2 PU6100.5
N32872885: PC6102.2 PU6100.7
N32873027: PC6103.1 PR6106.2 PU6100.24
N32873161: PR6103.1 PU6100.26
N32873197: PR6104.1 PU6100.2
N32889750: PR6053.2 PR6061.1
N32890192: PC6016.2 PR6063.1 PU6000.2
N32892915: PC6426.2 PR6411.1
N32894520: PR6419.2 PR6420.1 PU6400.9
N33144860: PC6011.1 PR6068.2
N33334796: PQ8203.5 PQ8203.6 PR6069.2
N37205985: RH519.2 UC1.BR33
N37206101: RH154.2 UC1.H13
N37206112: RH155.2 UC1.BP31
N37239953: RH192.2 UC1.J23
N37239957: RH167.2 UC1.H23
N37345395: T135.1(TP-1) UH1.AL35
N37890445: CT115.1 QT2.5 RT90.1
N37890455: QT2.3 RT89.2
N37890462: QT2.6 RT88.2 RT90.2
N37890499: CT117.1 UT5.6
N38701284: DE1.2 RE8.2 UE1.25
N38702841: RE651.1 UE1.20
N38755071: JEDP.28 RV675.2
N38961275: RG567.2 UG30.2 UG30.3
N39960403: CU92.1 UU8.6
N40259586: RT108.1 RT109.2 UT4.D6
N41521526: CE51.1 QE2.2 RE85.1
N46084233: QX2.2 RX2.1
N123247790: C2507.1 U17.10
N123252636: C2506.1 U17.12
N124009550: T63.1(TP-1) UT4.G4
N124752685: CH101.2 RH211.1
N124753277: CH100.2 RH212.1
N203830181: PD5.3 PR11.1
N210597020: PC8219.1 PR8210.2
N212152397: JRTC1.1 PR2.2
N213961754: PC14.2 PQ8.2 PR28.2
N1240135923: T64.1(TP-1) UT4.B2
N1240135924: T65.1(TP-1) UT4.C2
N1240135925: T114.1(TP-1) UT4.D10
N1240135926: T120.1(TP-1) UT4.G11
N1240135928: T121.1(TP-1) UT4.E10
N1240135929: T122.1(TP-1) UT4.G10
N1240135930: T70.1(TP-1) UT4.D7
N1240135963: T62.1(TP-1) UT4.F4

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; JDIMM1 87 88 91 92 95 97 100 101 104 105 134 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 134 162 165; JELC2 6 7 8; JHDD 7 8 10 11 14 17; JHDMI 14; JIO 2 9; JKB2 1 2; JKBBL 17 18 19 20; JPK 6 19 20; JSSD1 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JSSD2 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JSSD3 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JWLAN 6 8 9 10 11 12 13 14 15 16 17 19 20 21 23 26 28 34 36 38 40 47 50 51 52 53 54 56 57 58 59 60 62 63 65; PD1 3; PD3 3; PU502 6 13 17 19; PU503 6 13 17 19; PU504 6 13 17 19; PU507 6 13 17 19; PU509 10 12; PU510 6 13 17 19; PU511 6 13 17 19; PU700 13 14; PU800 10 12; PU802 10 12; PU1300 5; PU6000 4 5 6 7 13 14 15; PU6100 6 22 25 27; PU6101 6 22 25 27; PU6200 6 22 25 27; PU6201 6 22 25 27; PU8200 6; QE56 3 4 5; RE664 2; RE665 2; RE666 2; RE667 2; RPC7 3 4; U2407 8 11; UA1 4 8 47 48 49 50; UA4 13 31 32 35 36; UC1 A27 A29 A33 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AJ8 AJ10 AJ11 AK3 AL1 AL2 AL3 AM10 AM11 AP14 AP29 AT3 AT5 AT7 AT11 AT13 AU13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B2 B26 B27 B28 B29 B30 B33 B34 B36 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ28 BK28 BL31 BL34 BM30 BM31 BN1 BN33 BN35 BP1 BR1 BR2 BR27 BR31 BR35 BT2 BT27 BT30 C1 C26 C28 C30 C33 C34 C38 D1 D29 D34 E1 E2 E3 E28 E29 E30 E33 F28 F30 F33 G3 G13 H24 J3 J24 N29 R14; UC2 1; UE1 2 3 4 10 26 29 38 39 40 41 45 46; UE3 12 13 19 20 21 22 28 29; UE4 12 13 19 20 21 22 28 29; UE5 37; UE6 13 23; UE8 12 13 22 28 29; UE10 13; UG1 A5 A10 U5 U10; UG2 A5 A10 U5 U10; UG3 A5 A10 U5 U10; UG4 A5 A10 U5 U10; UG5 A5 A10 U5 U10; UG6 A5 A10 U5 U10; UG7 A5 A10 U5 U10; UG8 A5 A10 U5 U10; UG9 A9 A17 A42 AA44 AC7 AC8 AC9 AD3 AD45 AD46 AF49 AG8 AG9 AG52 AM1 AM2 AM3 AM5 AM6 AM7 AM8 AN1 AN2 AN3 AN6 AN7 AN9 AN44 AR1 AR2 AR3 AR5 AR6 AR7 AR8 AR50 AT1 AT2 AT3 AT6 AT7 AT9 AT44 AT45 AV1 AV2 AV3 AV5 AV6 AV7 AV8 AW1 AW2 AW3 AW6 AW7 AW9 AW47 AW48 B50 BA1 BA2 BA3 BA5 BA6 BA7 BA8 BA9 BB2 BB3 BB6 BB7 BB8 BD4 BD14 BE7 BE12 BE23 BE35 BE38 BF12 BF21 BF23 BF24 BF33 BF35 BF36 BF38 BF39 BG1 BG4 BG6 BG11 BG12 BG21 BG23 BG24 BG33 BG35 BG36 BG38 BG39 BG41 BH6 BH11 BH12 BH23 BH35 BH38 BH41 BJ1 BJ2 BJ9 BJ11 BK11 BK12 BK14 BK18 BK20 BK21 BK36 BK38 BK39 BK41 BK42 BK44 BL11 BL12 BL14 BL18 BL20 BL21 BL36 BL38 BL39 BL41 BL42 BM8 BM9 BM11 BM12 BM20 BM21 BM35 BM36 BM38 BM39 BM41 BM42 C24 C35 D17 D41 E29 F9 F29 F41 G9 G14 G35 G41 H6 H7 H14 H24 H35 J3 J14 J23 J24 J35 J41 J46 J47 M7 M8 M44 M45 P9 P45 U1 V4 V44 V45 Y50; UG11 10 13 16 17; UH1 A22 A25 AA1 AA45 AB48 AC6 AC7 AC9 AC11 AC14 AC15 AC39 AC41 AC43 AC44 AD47 AD48 AE9 AE11 AE39 AE41 AE43 AE44 AE48 AF47 AF48 AG45 AH14 AH15 AH40 AH46 AH47 AH48 AJ46 AJ47 AK47 AL9 AL15 AL37 AL47 AM7 AM43 AM45 AM47 AM48 AN4 AN35 AN37 AN46 AP2 AP3 AP9 AP21 AP29 AP47 AR2 AR13 AR35 AR37 AR42 AR48 AT5 AT10 AT40 AT49 AU4 AU24 AU46 AU47 AU48 AV6 AV7 AV13 AV16 AV18 AV34 AV43 AV44 AV46 AV47 AW2 AW3 AW13 AW15 AW18 AW21 AW32 AW48 B9 B10 B14 B15 B19 B21 B23 B24 B25 B26 B27 BA2 BA3 BA17 BA36 BB3 BB4 BB6 BB16 BB24 BB34 BC1 BC5 BC17 BC28 BC33 BD4 BD7 BD8 BD12 BD16 BD17 BD34 BD39 BD42 BE3 BE6 BE8 BE9 BE12 BE16 BE19 BE23 BE29 BE32 BE33 BE36 BE40 BF6 BF8 BF9 BF10 BF15 BF17 BF19 BF24 BF32 BF33 BF36 BF38 BF40 BF41 BG6 BG8 C3 C9 C10 C14 C15 C19 C20 C21 C23 C24 C26 C27 C39 C47 D4 D20 D21 D29 D39 D46 E28 F11 F20 F24 F26 G1 G2 G12 G20 G24 G26 J13 J15 J18 J21 J24 K13 K16 K18 K21 K29 K46 K47 L2 L24 L26 L46 L47 M1 M26 M29 N2 N3 N18 N32 N47 N48 P24 P47 P48 R13 R15 R18 R24 R32 R46 R47 T1 T2 T45 T47 T48 U2 U3 U13 U35 U37 U47 U48 V2 V3 V47 V48 W46 W47 Y2 Y14 Y15 Y35 Y36 Y46 Y48; UL1 24 25 26 28 40; UM4 7 8; UM8 10 11 12 13 15 16 17 18 21 22 23 28 29 30 31 32 33 34 35; US1 2 3; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 J1 J2 L1 L2 N1 N2 R1 R2 V18 W16 W19 Y16 Y19; UT4 A9 B9; UU1 9; UU2 24 33 35; UU5 1; UV3 11 14

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 1069 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 12835 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 148 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 87 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V_B+: length 28.1
  IN3 w0.254: v2(89.92,34.6) 89.92,33 91.4,31.52 99.55,31.52 101.1,33.07 101.1,41.52 98.5,44.12 v2(97.51,44.12)
  BOTTOM w0.254: PR206.1 97.07,44.12 v2(97.51,44.12)
  vias: v1(87.77,35.72)
1.8VS_PGOOD: length 1.9
  BOTTOM w0.254: PR820.1 228.55,39.4 229.17,40.03 PU802.9
1V8_AON_EN: length 247
  TOP w0.102: CG487.1 193.04,111.34 192.22,112.16 192.13,112.16 191.52,112.77 QG503.2 190.89,112.77 190.64,113.02 190.64,114.06 190.74,114.16 193.82,114.16 193.95,114.03 195.17,114.03 196.13,114.99 197.47,114.99 197.98,115.49 197.98,115.9 v1(197.58,116.3) 196.92,116.96 v2(196.88,116.96)
  TOP w0.254: UG25.4 278.55,150.17 278.29,150.42 v2(277.95,150.42)
  IN2 w0.102: v2(277.95,150.42) 277.93,150.42 277.19,151.17 277.19,151.47 275.59,153.06 274.49,153.06 270.88,156.67 266.65,156.67 266.18,156.2 243.47,156.2 242.88,155.6 238.76,155.6 237.31,157.05 232.39,157.05 231.76,156.43 224.3,156.43 223.6,155.73 223.51,155.73 222.38,155.73 221.98,155.73 219.26,155.73 219.25,155.75 216.29,155.75 216.11,155.92 215.49,155.92 214.55,154.98 211.56,154.98 210.81,154.24 210.81,153.88 210.82,153.27 211.41,152.68 211.41,151.97 211.95,151.43 211.95,146.71 206.7,141.47 206.7,131.63 204.99,129.91 204.99,128.01 204.54,127.56 203.21,127.56 201.75,129.02 199.38,129.02 198.55,128.19 198.55,125.76 197.68,124.9 194.27,124.9 191.14,121.77 191.14,120.99 191.44,120.69 194.66,120.69 194.85,120.5 194.85,119.97 196.86,117.95 196.86,116.98 v2(196.88,116.96)
  IN2 w0.254: v2(188.22,56.06) 193.13,56.06 194.75,57.69 194.75,58.83 196.96,61.04 196.96,61.95 197.67,62.67 198.72,62.67 202.46,58.92 204.67,58.92 205.14,58.45 v2(205.14,58.07)
  IN4 w0.102: v2(205.14,58.07) 205.14,58.88 205.49,59.24 205.49,67.91 207.91,70.32 207.91,102.55 206.43,104.03 197.79,104.03 196.06,105.75 195.96,105.75 194.81,106.9 194.81,110.73 195.42,111.34 195.42,114.04 195.99,114.61 197.24,114.61 197.99,115.36 197.99,116.07 197.1,116.96 v2(196.88,116.96)
  BOTTOM w0.102: RG576.1 197.35,117.43 v2(196.88,116.96) 196.69,116.77 196.24,116.77 RG70.2 195.92,116.07 196.11,115.88 196.11,115.19 196.26,115.04 UG12.3
  BOTTOM w0.203: v2(188.22,56.06) 188.6,55.68 UG31.14
1V8_ENP:
  vias: v1(227.06,40.53)
1V8_MAIN_EN: length 271.6
  TOP w0.102: v2(197.53,115.62) 197.13,115.22 196.04,115.22 195.08,114.26 194.05,114.26 193.85,114.45 189.93,114.45 189.31,113.83 187.76,113.83 186.93,113 v1(186.93,109.78) 186.93,107.27 188.03,106.16 189.24,106.16 189.54,106.47 QG504.2
  TOP w0.254: v2(281.04,172.88) 281.3,172.63 DG3.2 DG7.2 ; RG549.1 280.07,164.58 280.07,163.88 v2(280.24,163.71) ; RG550.1 277.4,166.69 DG6.1 277.59,167.1 v2(277.06,167.63) ; UG26.2 v2(277.72,154.54)
  IN1 w0.254: v2(277.06,167.63) 277.06,168.9 281.03,172.87 ; v2(280.24,163.71) 280.24,164.56 280.49,164.81 282.63,164.81 282.98,165.15 282.98,169.26 281.24,171 281.24,172.67 281.03,172.87 ; 281.03,172.87 v2(281.04,172.88)
  IN2 w0.254: v2(280.24,163.71) 280.24,163.22 280.27,163.19 280.27,155.53 280.02,155.27 278.45,155.27 v2(277.72,154.54) 276.84,153.66 274.52,153.66 271.03,157.15 266.52,157.15 266.07,156.71 243.55,156.71 242.75,155.91 239.86,155.91 238.29,157.48 229.26,157.48 229.23,157.51 227.9,157.51 227.29,156.9 224.25,156.9 223.39,156.03 222.39,156.03 221.98,156.04 219.39,156.04 219.37,156.05 216.41,156.05 216.24,156.23 215.36,156.23 214.48,155.34 211.53,155.34 211.48,155.29 211.43,155.29 210.26,154.11 210.26,153.05 211.1,152.21 211.1,151.85 211.64,151.31 211.64,146.84 206.4,141.6 206.4,131.83 203.55,128.98 202.73,128.98 202.37,129.34 198.77,129.34 198.23,128.8 198.23,126.01 197.57,125.35 194.08,125.35 190.84,122.11 190.84,121.89 190.84,120.87 191.32,120.39 193.02,120.39 193.71,119.7 194.69,119.7 196.39,118 196.39,116.77 v2(197.53,115.62) 197.53,115.54 196.16,114.16 193.11,114.16 192.35,113.4 192.35,110.47 193.13,109.69 193.13,107.36 194.83,105.65 194.83,104.96 194.58,104.7 191.46,104.7 190.57,105.59 188.9,105.59 186.28,102.97 186.28,99.46 187.58,98.16 187.58,72.34 191.33,68.58 191.33,66.73 192.22,65.84 v2(192.22,65.76)
  IN4 w0.254: v2(192.22,65.76) 192.16,65.82 191.8,65.82 189.67,63.7 189.67,62.77 188.1,61.19 188.1,58.97 188.5,58.57 v2(188.62,58.57)
  BOTTOM w0.102: RG71.2 198.48,115.51 198.38,115.61 197.54,115.61 v2(197.53,115.62) 197.06,115.15 UG12.5
  BOTTOM w0.203: UG31.16 188.92,56.48 188.29,57.11 188.16,57.11 ; 188.16,57.11 188.16,58.21 188.52,58.57 v2(188.62,58.57) ; 188.16,57.11 187.24,57.11 186.76,56.63 186.76,55.15 RG571.2
1V8_MAIN_NVVDD2_EN: length 9.4
  TOP w0.102: UG28.2 v1(280.94,158.57)
  TOP w0.254: v2(279.68,162.98) 278.99,163.67 278.79,163.67 CG482.1 277.59,164.86 DG6.2 277,165.78 RG550.2 ; v2(280.94,160.99) UG28.2
  IN1 w0.254: v2(279.68,162.98) 280.94,161.72 v2(280.94,160.99)
3/5V_B+: length 3.5
  IN1 w0.508: v2(54.38,42.54) 54.49,42.65 v2(54.49,45.02)
  BOTTOM w0.203: PU100.12 54.26,45.43 54.49,45.21 v2(54.49,45.02)
  vias: v1(54.4,40.24) v2(50.85,41.37) v2(51.43,41.95) v2(51.43,41.37) v2(52.02,42.54) v2(52.02,41.95) v2(52.02,41.37) v2(52.6,43.12) v2(52.6,42.54) v2(52.6,41.95) v2(52.6,41.37) v2(53.18,43.12) v2(53.18,42.54) v2(53.18,41.95) v2(53.18,41.37) v2(53.77,43.12) v2(53.77,42.54) v2(53.77,41.95)
3V3_SYS_EN: length 313.8
  TOP w0.102: v2(279.62,157.69) 279.32,157.38 RG545.2
  TOP w0.406: QG505.2 193.23,106.47 193.54,106.16 RG515.2 193.54,105.77 193.18,105.4 v2(193.18,105.34)
  IN2 w0.508: v2(195.18,67.84) 196.73,66.28 197.81,66.28 198.83,65.26 198.83,64.54 198.33,64.04 196.45,62.16 196.45,61.25 194.24,59.04 194.24,57.9 193.02,56.67 187.91,56.67 v2(187.57,56.33)
  IN3 w0.102: v2(279.62,157.69) 278.8,157.69 275.45,154.33 275.45,150.91 277.87,148.49 277.87,146.53 278.96,145.43 278.96,144.25 280.46,142.75 283.82,142.75 286.97,139.6 286.97,99.93 286.98,99.89 287.08,99.5 287.08,99.48 287.12,99.32 287.13,99.32 287.19,99.06 287.29,98.7 287.35,98.49 287.38,98.37 287.41,98.26 287.42,98.25 287.9,96.62 287.93,96.53 287.93,96.53 288.39,95.12 288.67,94.16 289.31,92.77 291.58,88.11 291.58,81.5 292.41,80.66 292.41,78.98 299.47,71.92 299.47,61.54 299.88,61.14 v2(299.91,61.14)
  IN6 w0.254: v2(299.91,61.14) 299.35,61.14 296.32,58.11 296.32,53.33 292.71,49.72 278.7,49.72 277.85,50.57 273.56,50.57 271.45,52.68 261.3,52.68 259.22,50.6 250.85,50.6 249.62,51.83 232.64,51.83 232.22,52.25 229.86,52.25 v2(229.65,52.47)
  BOTTOM w0.203: v2(187.57,56.33) 187.94,56.71 188.23,56.71 188.86,56.08 UG31.15
  BOTTOM w0.254: v2(229.65,52.47) 229.65,52.39 228.62,51.36 222.54,51.36 v1(221.75,52.15) 220.76,53.14 214.15,53.14 213.44,53.85 213.44,58.38 212.81,59.01 211.82,59.01 211.54,59.29 211.54,60.33 210.57,61.29 210.57,67.88 209.57,68.89 205.91,68.89 204.87,67.84 v2(195.18,67.84) 194.51,67.17 191.91,67.17 190.76,68.32 190.76,69.42 189.77,70.41 189.77,83.96 190.19,84.38 190.19,102.99 192.35,105.15 192.92,105.15 193.11,105.34 v2(193.18,105.34) 193.18,105.85 193.34,106.01 UG14.4 193.21,106.24 192.96,106.24 CG240.1
3V_5V_EN: length 7.9
  TOP w0.127: v1(62.04,50.64) 61.65,50.25 PC112.1
  TOP w0.254: PR114.2 59.65,48.77 PR100.2 PR112.2 60.9,48.77 61.22,49.08 PC112.1 61.65,48.44 PR116.1 62.15,47.31 PR113.2 PR115.2
3V_5V_EN2: length 82.5
  TOP w0.508: PR115.1 v2(64.33,46.15)
  IN3 w0.508: v2(47.76,17.22) 47.76,17.27 48.32,17.83 48.37,17.83 48.4,17.86 52.98,17.86 53.62,17.22 54.35,17.22 56.45,15.13 78.52,15.13 82.75,19.36 82.75,21 82.85,21.1 82.85,23.66 80.74,25.77 80.74,28.64 78.33,31.05 76.81,31.05 76.18,31.68 76.18,35.68 67.92,43.95 66.54,43.95 v2(64.33,46.15)
  BOTTOM w0.254: v2(47.76,17.22) 48.48,17.94 v1(52.26,17.94) PD101.1
3V_ELC_ON: length 233.3
  TOP w0.203: RE83.1 308.39,25.04 v2(308.39,24.43) 308.39,24.18 308.23,24.01 UE5.128
  IN2 w0.254: v2(101.18,30.98) 101.69,31.49 113.81,31.49 116.26,33.94 180.27,33.94 183.91,37.58 185.75,37.58 186.08,37.91 189.61,37.91 189.7,37.82 193.24,37.82 194.62,39.19 194.62,39.82 195.58,40.78 197.06,40.78 197.33,41.05 200.08,41.05 200.17,41.14 204.44,41.14 204.72,40.86 206.72,40.86 206.89,41.03 209.61,41.03 209.64,41 213.52,41 214.87,42.35 222.72,42.35 225.02,40.05 229.3,40.05 230.2,40.95 234.39,40.95 234.83,40.5 234.83,40.5 234.94,40.4 235.77,40.4 236.19,39.98 238.77,39.98 239.16,39.6 239.23,39.6 239.41,39.42 240.36,38.47 246.96,38.47 248.57,36.86 248.57,34.07 250.18,32.46 251.81,32.46 252.38,32.7 260.89,32.7 261.31,32.28 268.12,32.28 268.78,31.63 272.31,31.63 272.68,31.26 274.93,31.26 276.2,29.99 277.75,29.99 278.58,29.16 280.69,29.16 282.67,27.18 284.71,27.18 285.21,26.68 285.21,25.39 285.94,24.67 286.57,24.67 286.85,24.95 287.38,24.95 287.59,24.74 288.4,24.74 289.2,23.94 289.2,22.62 290,21.82 290.16,21.82 290.98,21.82 290.98,21.82 293.11,21.82 293.67,21.26 293.84,21.1 297.13,21.1 297.2,21.03 298.31,21.03 299.02,21.74 301.23,21.74 301.34,21.86 301.39,21.86 302.73,23.19 302.79,23.19 307.21,23.19 308.39,24.38 v2(308.39,24.43)
  BOTTOM w0.102: v1(99.47,32.43) UE9.4
  BOTTOM w0.254: UE9.4 100.81,31.35 v2(101.18,30.98)
3V_EN: length 8.3
  TOP w0.254: v2(56.95,48.29) 56.97,48.32 56.97,50.03 58.11,51.17 v1(58.48,51.17) 59.4,51.17 59.65,50.92 PR100.1
  BOTTOM w0.203: PU100.6 55.72,48.28 55.87,48.43 55.87,48.51 56.14,48.78 56.52,48.78 56.95,48.35 v2(56.95,48.29)
3VS: length 1.2
  BOTTOM w0.102: 69.96,12.88 69.96,12.5 v1(70.53,11.93)
3VS_GATE: length 2.9
  BOTTOM w0.203: R174.2 C258.1 65.39,17.96 v2(65.25,17.82) 65.09,17.66 U17.5
5V_EN: length 13
  TOP w0.254: v2(51.53,48.52) 52.92,49.9 55,49.9 56.77,51.67 60.16,51.67 v1(60.27,51.55) 60.57,51.26 PR112.1
  BOTTOM w0.203: v2(51.53,48.52) 51.72,48.52 51.96,48.28 PU100.20
5VCC: length 9.3
  TOP w0.254: v2(275.34,133.91) 276.23,134.8 v1(276.23,135.46) PC6014.1
  BOTTOM w0.203: PU6000.12 276.81,135.88 PR6035.2 276.48,134.53 PR6032.1 PR6070.1 v2(275.34,133.91)
5VS:
  vias: v1(61.82,15.69)
5VS_GATE: length 2.2
  BOTTOM w0.203: U17.3 64.29,17.47 63.48,18.28 R182.2
+0.6VS: length 102.6
  IN2 w1.524: 93.54,54.23 93.56,54.21 94.16,54.21 104.68,64.74 106.78,64.74 109.63,61.89 179.1,61.89 181.43,59.56 181.43,55.11 179.78,53.46 178.38,53.46
  vias: v2(91.7,53.9) v2(91.7,53.27) v2(92.4,53.9) v2(178.32,52.2) v2(178.32,51.55) v2(179.33,43.38) v2(179.28,42.8) v3(181.35,39.84)
+0.6VSP: length 0.7
  BOTTOM w0.203: 90.53,47.65 v1(89.8,47.65)
+0.9V_CIO:
  vias: v2(179.35,164.96) v2(180.65,165.61)
+0.9V_DP:
  vias: v1(174.06,155.9) v2(174.57,155.97) v2(175.21,155.97) v2(176.03,155.97) v2(178.7,166.91) v2(178.7,166.26) v2(180.65,166.91) v2(180.65,164.31) v2(181.3,164.31)
+0.9V_LVR_OUT: length 1.8
  BOTTOM w0.203: v1(184.51,171.83) 184.24,171.55 184.24,171.09 183.75,170.6 CT81.1
  vias: v2(180.65,168.21) v2(180.65,167.56) v2(183.24,168.21)
+0.9V_PCIE:
  vias: v1(187.83,160.71) v2(181.96,166.9) v2(182.6,166.9) v2(183.27,166.9) v2(183.9,166.9) v2(187.83,159.15) v2(187.83,158.57)
+0.9V_SVR:
  vias: v1(170,172.76) v2(170.44,174.23) v2(170.44,173.65) v2(170.44,173.07) v2(170.44,172.48) v2(180,167.56) v2(180.65,170.16) v2(181.3,170.16) v2(181.3,169.5) v2(181.96,169.5)
+0.9V_USB: length 0.8
  BOTTOM w0.203: v2(182.6,164.96) 183.17,164.39 CT77.1
  vias: v2(187.18,159.15) v2(187.18,158.57)
+1.0VS_VGA_PGOOD: length 89.7
  TOP w0.254: UG27.2 312.15,61.73 v2(312.35,61.53) ; v2(240.92,40.16) 240.92,40.55 PR821.1 241.26,41.2 241.51,41.46 244.91,41.46 248.01,44.55 v2(248.01,48.62)
  IN3 w0.254: v2(248.01,48.62) 248.01,48.85 248.88,49.72 258.35,49.72 260.75,47.32 272.47,47.32 274.13,48.98 293.52,48.98 298.78,54.24 298.78,56.64 301.39,59.26 308.24,59.26 308.53,59.55 310.32,59.55 310.87,60.1 310.87,60.26 312.13,61.53 v2(312.35,61.53)
  BOTTOM w0.102: v1(241.05,39.59) 240.92,39.72 v2(240.92,40.16)
  BOTTOM w0.254: v2(240.92,40.16) 240.92,40.43 241.37,40.88 PU800.9
+1.0VS_VGAP:
  vias: v1(237.31,46.32)
+1.2V_DDR: length 109.8
  BOTTOM w0.203: UC1.AL11 151.21,101.9 v2(151.58,102.26) 151.87,102.55 UC1.AJ12 ; v2(159.81,102.26) 159.52,102.55 UC1.Y12 ; UC1.L6 166.56,98.64 166.76,98.83 167.2,98.83 UC1.K6 ; v2(154.32,101.05) UC1.AG9
  BOTTOM w0.254: UC1.AF6 154.49,98.3 v2(154.38,98.3) ; UC1.W6 159.85,98.62 v2(159.42,98.18) 159.02,98.59 UC1.AA6 ; UC1.AR12 147.33,102.55 v2(147.01,102.22) 146.68,102.55 UC1.AT12 ; v2(154.38,98.3) 154.07,97.99 UC1.AG5 ; v2(154.38,98.3) 154.69,97.99 UC1.AF5 ; v2(167.91,102.24) 167.81,102.24 UC1.K12 167.3,102.75 166.87,102.75 UC1.L12 ; UC1.AE12 155.58,102.55 v2(155.29,102.84) ; UC1.K6 UC1.J6 168.3,98.64 v2(168.64,98.3) 168.32,97.99 UC1.J5 ; v2(161.93,98.31) 162.25,98.64 UC1.T6 ; UC1.AP7 148.38,98.9 UC1.AP6 UC1.AR6 146.92,98.27 v2(146.84,98.27) ; UC1.AY6 143.99,98.64 v2(144.33,98.3) 144.67,98.64 UC1.AW6
  BOTTOM w0.305: JDIMM2.12 114.44,42 v2(114.38,42.06) ; v2(130.34,50.23) 130.19,50.08 JDIMM2.75 ; v2(125.1,42.15) 124.94,42 JDIMM2.54 ; JDIMM1.241 173.69,62.87 173.31,63.26 v2(173.07,63.26) ; JDIMM2.123 142.19,50.22 v2(142.13,50.29) ; JDIMM2.135 145.2,50.16 145.41,50.38 v2(145.62,50.38) ; v2(145.75,39.51) 145.75,39.62 145.44,39.93 JDIMM2.136 ; v2(140.32,50.26) 140.69,49.89 JDIMM2.117 ; JDIMM2.147 150.2,50.36 v2(150.17,50.38) 151.26,50.38 151.69,49.94 JDIMM2.153 ; v2(142.25,39.49) 142.44,39.69 JDIMM2.124 ; JDIMM1.75 130.19,62.96 v2(130.04,63.11) ; v2(135.26,42.09) 135.44,41.91 JDIMM2.96 ; UC1.R6 UC1.T6 ; JDIMM2.159 153.2,50.03 153.51,50.35 v2(153.77,50.35) 154.2,49.92 JDIMM2.163 ; v2(167.53,51.59) 167.97,51.59 168.44,52.06 JDIMM1.220 ; v2(142.14,63.16) 142.19,63.1 JDIMM1.123 ; JDIMM1.124 142.44,52.55 v2(142.13,52.24) ; v2(152.21,51.71) 152.39,51.71 153.44,52.76 JDIMM1.160 ; v2(140.32,51.52) 140.02,51.52 139.44,52.1 JDIMM1.112 ; v2(152.22,52.31) 151.94,52.58 JDIMM1.154 ; v2(135.96,51.64) 135.77,51.64 135.44,51.97 JDIMM1.96 ; JDIMM1.199 163.19,63.32 163.81,63.94 v2(164.54,63.94) ; JDIMM2.129 143.69,50.08 142.86,50.92 v2(142.12,50.92) ; JDIMM1.118 140.94,52.38 140.76,52.19 v2(140.32,52.19) ; JDIMM2.199 163.19,50.17 v2(164,50.97) ; v2(150.19,52.25) 150.44,52.51 JDIMM1.148 ; JDIMM2.241 173.69,49.94 v2(173.31,50.33) ; JDIMM1.142 146.94,52.6 v2(146.63,52.28) ; v2(140.32,50.86) 139.73,50.86 139.2,50.33 139.2,49 JDIMM2.111 ; JDIMM2.220 168.44,39.61 v2(168.55,39.51) ; v2(139.88,63.77) 140.09,63.77 140.69,63.16 JDIMM1.117 ; JDIMM2.141 146.69,47.74 v2(146.76,47.68) ; JDIMM1.136 145.44,52.73 145.62,52.56 v2(145.62,51.71) 144.59,51.71 143.94,52.36 JDIMM1.130 ; JDIMM1.33 119.69,62.87 v2(119.53,63.04) ; v2(139.44,39.49) JDIMM2.112 ; JDIMM1.178 157.94,55.04 v2(158.07,55.17) ; v2(147.06,39.51) 146.95,39.62 146.95,40.8 JDIMM2.142 ; v2(144.26,39.51) 143.95,39.82 143.95,40.8 JDIMM2.130 ; JDIMM1.12 114.44,52.53 v2(114.66,52.32) ; JDIMM2.148 150.44,39.85 150.1,39.51 v2(149.93,39.51) ; JDIMM1.54 124.94,52.5 v2(124.73,52.28) ; v2(144.48,64.13) 145.58,64.13 146.69,63.02 JDIMM1.141 ; JDIMM1.129 143.69,62.81 143.72,62.81 144.1,63.19 v2(144.48,63.19) 144.55,63.13 144.93,63.13 145.19,62.86 JDIMM1.135 ; JDIMM2.118 140.94,39.9 v2(140.53,39.49) ; v2(119.69,50.25) JDIMM2.33 ; JDIMM2.178 157.95,40.8 157.95,42.84 v2(157.81,42.98) ; JDIMM2.154 151.94,39.83 v2(151.64,39.53) 153.09,39.53 153.44,39.89 JDIMM2.160
  vias: v2(98.81,36) v2(98.8,35.33) v2(98.8,34.7) v2(98.8,34.06) v2(98.8,33.43) v2(99.37,35.65) v2(99.37,35.02) v2(99.37,34.38) v2(99.37,33.75) v2(99.39,33.14) v2(100.01,35.65) v2(100.01,35.02) v2(100.01,34.38) v2(100.01,33.75) v2(100.01,33.11) v2(108.71,41.11) v2(108.71,40.48) v2(108.71,39.84) v2(108.71,39.21) v2(108.71,38.57) v2(109.28,41.43) v2(109.28,40.79) v2(109.28,40.16) v2(109.28,39.52) v2(109.28,38.89) v2(109.85,41.11) v2(109.85,40.48) v2(109.85,39.84) v2(109.85,39.21) v2(109.85,38.57) v2(110.42,41.43) v2(110.42,40.79) v2(110.42,40.16) v2(110.42,39.52) v2(110.42,38.89) v2(119.79,47.5) v2(126.29,77.69) v2(127.9,39.36) v2(128.65,98.29) v2(128.85,98.86) v2(129.1,85.21) v2(132.03,42.31) v2(136.66,42.3) v2(139.88,64.41) v2(139.88,63.14) v2(142.14,64.43) v2(142.14,63.79) v2(148.41,39.73) v2(150.82,63.06) v2(153.29,63.15) v2(155.65,52.06) v2(167.26,39.49) v2(167.31,89) v2(171.97,47.55) v3(100.88,42.8)
