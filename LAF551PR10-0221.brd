# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 232.6
  TOP w0.127: v2(17.47,26.77) v3(17.47,27.69)
  TOP w0.203: v2(23.57,29.96) 23.5,30.03 UA2.A2 ; UA3.A2 19.9,24.5 20.41,23.99 20.41,23.17 21.46,22.11 22.31,22.11 22.54,21.89 v2(22.54,21.45) ; v2(27.96,35.41) v3(26.97,35.41)
  TOP w0.356: v2(21.48,28.07) 21.99,28.07 CA51.1 ; RA44.2 21.6,26.79 v2(21.54,26.72) ; v2(17.47,26.77) 17.79,26.46 CA44.1
  TOP w0.381: CA50.2 20.46,25.99 v2(19.57,25.99) ; RA45.2 23.5,23.17 22.81,23.17 v2(22.67,23.31) 21.6,23.31 21.18,23.72 CA48.2
  TOP w0.508: v3(26.09,37.2) 26.9,37.2 v2(26.91,37.2) 26.91,37.2 CA32.2 ; v2(30.62,25.16) 29.83,25.95 CA16.2 28.96,25.95 28.47,25.45 CA17.2 ; CA260.1 23.96,35.33 v2(24.92,34.37) ; v2(26.87,18.6) 26.74,18.72 RA4.1 ; CA24.2 28.58,29.47 CA25.2 v2(27.72,29.37) ; v2(17.55,22.51) 18.03,22.51 CA92.2 ; v2(18.32,16.98) 18.37,17.03 CA91.2 ; v2(27.96,35.41) 28.14,35.23 RA6.1 ; v2(27.01,38.3) 26.86,38.15 CA259.1 ; v2(15.78,29.68) 15.88,29.58 RA1.1 ; v2(14.3,3.6) RA7.1 ; CA30.2 31.76,25.26 CA31.2 v2(32.28,23.85) ; CA261.1 29.96,28.63 29.07,27.74 v2(27.92,27.74)
  GND1 w0.203: JACK2.4 6.75,18.8 ; JACK2.4 5.67,18.13 ; JACK2.4 4.59,18.8 ; JACK2.4 6.75,18.13 ; JACK2.4 4.59,18.13 ; 13.47,14.93 JACK1.5 ; JACK1.5 14.55,15.6 ; JACK1.5 14.55,14.93 ; JACK1.5 12.39,16.27 ; JACK1.5 13.47,16.27 ; JACK1.5 14.55,16.27 ; JACK1.5 12.39,15.6 ; JACK1.5 12.39,14.93 ; 9.64,28.3 JACK2.6 ; JACK2.6 11.8,28.3 ; JACK2.6 9.64,28.97 ; JACK2.6 9.64,27.63 ; JACK2.6 11.8,28.97 ; JACK2.6 11.8,27.63 ; JACK2.6 10.72,27.63 ; JACK2.6 10.72,28.97 ; 8.27,18.13 JACK2.3 ; JACK2.3 7.19,18.13 ; JACK2.3 9.35,18.8 ; JACK2.3 7.19,18.8 ; JACK2.3 9.35,18.13
  GND2 w0.203: JACK2.6 11.8,27.63 ; JACK2.6 10.72,27.63 ; JACK2.6 9.64,28.97 ; JACK2.6 9.64,28.3 ; JACK2.6 10.72,28.97 ; JACK2.6 9.64,27.63 ; JACK2.6 11.8,28.3 ; JACK2.6 11.8,28.97 ; 7.19,18.13 JACK2.3 ; JACK2.3 9.35,18.8 ; JACK2.3 7.19,18.8 ; JACK2.3 8.27,18.13 ; JACK2.3 9.35,18.13 ; JACK2.4 6.75,18.13 ; JACK2.4 5.67,18.13 ; JACK2.4 6.75,18.8 ; JACK2.4 4.59,18.13 ; JACK2.4 4.59,18.8 ; 12.39,15.6 JACK1.5 ; JACK1.5 13.47,16.27 ; JACK1.5 12.39,14.93 ; JACK1.5 12.39,16.27 ; JACK1.5 14.55,14.93 ; JACK1.5 13.47,14.93 ; JACK1.5 14.55,15.6 ; JACK1.5 14.55,16.27
  GND3 w0.203: 4.59,18.8 JACK2.4 ; JACK2.4 5.67,18.13 ; JACK2.4 6.75,18.13 ; JACK2.4 6.75,18.8 ; JACK2.4 4.59,18.13 ; JACK1.5 14.55,14.93 ; JACK1.5 14.55,15.6 ; JACK1.5 14.55,16.27 ; JACK1.5 12.39,15.6 ; JACK1.5 12.39,16.27 ; JACK1.5 13.47,16.27 ; JACK1.5 13.47,14.93 ; JACK1.5 12.39,14.93 ; 10.72,27.63 JACK2.6 ; JACK2.6 11.8,28.97 ; JACK2.6 11.8,28.3 ; JACK2.6 10.72,28.97 ; JACK2.6 11.8,27.63 ; JACK2.6 9.64,28.3 ; JACK2.6 9.64,28.97 ; JACK2.6 9.64,27.63 ; 7.19,18.8 JACK2.3 ; JACK2.3 8.27,18.13 ; JACK2.3 7.19,18.13 ; JACK2.3 9.35,18.13 ; JACK2.3 9.35,18.8
  IN3 w0.508: v2(27.72,29.37) 31.41,29.37 v2(32.85,27.93)
  GND4 w0.203: 10.72,27.63 JACK2.6 ; JACK2.6 11.8,27.63 ; JACK2.6 11.8,28.97 ; JACK2.6 9.64,28.97 ; JACK2.6 9.64,28.3 ; JACK2.6 9.64,27.63 ; JACK2.6 11.8,28.3 ; JACK2.6 10.72,28.97 ; JACK2.4 6.75,18.8 ; JACK2.4 4.59,18.8 ; JACK2.4 6.75,18.13 ; JACK2.4 4.59,18.13 ; JACK2.4 5.67,18.13 ; JACK1.5 13.47,16.27 ; JACK1.5 13.47,14.93 ; JACK1.5 14.55,15.6 ; JACK1.5 12.39,16.27 ; JACK1.5 14.55,14.93 ; JACK1.5 14.55,16.27 ; JACK1.5 12.39,15.6 ; JACK1.5 12.39,14.93 ; JACK2.3 9.35,18.8 ; JACK2.3 9.35,18.13 ; JACK2.3 7.19,18.13 ; JACK2.3 8.27,18.13 ; JACK2.3 7.19,18.8
  IN5 w0.203: 9.64,28.97 JACK2.6 ; JACK2.6 11.8,28.97 ; JACK2.6 10.72,28.97 ; 5.67,18.13 JACK2.4 ; JACK2.4 6.75,18.13 ; JACK2.4 4.59,18.13 ; JACK2.3 9.35,18.13 ; JACK2.3 8.27,18.13 ; JACK2.3 7.19,18.13 ; JACK1.5 14.55,16.27 ; JACK1.5 12.39,16.27 ; JACK1.5 13.47,16.27
  GND5 w0.203: JACK1.5 14.55,15.6 ; JACK1.5 12.39,16.27 ; JACK1.5 12.39,15.6 ; JACK1.5 13.47,14.93 ; JACK1.5 14.55,16.27 ; JACK1.5 14.55,14.93 ; JACK1.5 13.47,16.27 ; JACK1.5 12.39,14.93 ; 9.64,28.97 JACK2.6 ; JACK2.6 9.64,28.3 ; JACK2.6 10.72,28.97 ; JACK2.6 10.72,27.63 ; JACK2.6 11.8,28.97 ; JACK2.6 9.64,27.63 ; JACK2.6 11.8,28.3 ; JACK2.6 11.8,27.63 ; 5.67,18.13 JACK2.4 ; JACK2.4 6.75,18.13 ; JACK2.4 4.59,18.8 ; JACK2.4 4.59,18.13 ; JACK2.4 6.75,18.8 ; 8.27,18.13 JACK2.3 ; JACK2.3 7.19,18.8 ; JACK2.3 7.19,18.13 ; JACK2.3 9.35,18.8 ; JACK2.3 9.35,18.13
  GND6 w0.203: 8.27,18.13 JACK2.3 ; JACK2.3 9.35,18.13 ; JACK2.3 7.19,18.13 ; JACK2.3 9.35,18.8 ; JACK2.3 7.19,18.8 ; JACK1.5 14.55,16.27 ; JACK1.5 14.55,15.6 ; JACK1.5 12.39,15.6 ; JACK1.5 12.39,14.93 ; JACK1.5 12.39,16.27 ; JACK1.5 13.47,14.93 ; JACK1.5 13.47,16.27 ; JACK1.5 14.55,14.93 ; JACK2.4 6.75,18.13 ; JACK2.4 4.59,18.13 ; JACK2.4 5.67,18.13 ; JACK2.4 4.59,18.8 ; JACK2.4 6.75,18.8 ; JACK2.6 11.8,28.97 ; JACK2.6 11.8,28.3 ; JACK2.6 9.64,28.97 ; JACK2.6 10.72,27.63 ; JACK2.6 9.64,28.3 ; JACK2.6 11.8,27.63 ; JACK2.6 9.64,27.63 ; JACK2.6 10.72,28.97
  BOTTOM w0.203: v2(27.96,35.41) 27.96,35.23 28.28,34.91 UA1.42 ; UA1.20 32.82,27.96 v2(32.85,27.93) ; UA1.30 28.24,30.11 27.95,29.82 27.95,29.6 v2(27.72,29.37)
  BOTTOM w0.356: v2(18.32,16.98) 18.44,17.09 CA43.2
  BOTTOM w0.381: CA42.2 v2(22.54,21.45) ; v2(26.81,19.61) 27.06,19.87 27.36,19.87 27.82,20.32 CA45.2 27.91,20.45 CA46.2
  BOTTOM w0.508: CA15.2 26.97,37.26 26.91,37.2 v2(26.91,37.2) ; v2(30.62,25.16) 30.96,25.16 CA29.2 31.31,25.53 31.63,25.84 CA28.2 ; v2(25.78,35.61) 25.98,35.61 26.17,35.42 CA27.2 CA26.2 ; v2(27.01,38.3) 27.05,38.34 CA14.2 ; v2(24.92,34.37) CA33.2
VCC_1.0VS_VGAP: length 1.3
  TOP w0.102: v2(241.12,45.27) v1(241.12,45.84)
  TOP w0.254: v2(241.12,45.27) 241.31,45.08 PC803.1
VCC_+1.8VGS: length 5
  BOTTOM w0.102: v1(227.6,45.8) 227.6,45.8 227.71,45.91 228.82,45.91 229.56,45.18 PC822.1
  BOTTOM w0.254: 229.21,44.58 229.56,44.94 PC822.1 ; 229.21,44.58 229.17,44.55 PU802.17 ; 229.21,44.58 228.85,44.58 228.72,44.45 PU802.16
VCC_CHG: length 4.6
  BOTTOM w0.127: v1(61.26,26.22) 61.07,26.03 v2(60.46,26.03)
  BOTTOM w0.508: v2(60.46,26.03) 60.33,25.9 60.33,24.95 PC711.2 60.84,24.12 61.78,23.18 PR707.2
VCC_CHG2: length 3.8
  BOTTOM w0.127: PR707.1 63.1,20.51 v3(63.67,21.09)
  BOTTOM w0.508: PD700.1 60.57,20.51 PR707.1
VCC_VCCIO: length 1.3
  BOTTOM w0.102: PC807.1 v1(122.61,113.96)
VCCGT_SENSE: length 46.1
  TOP w0.381: PR526.1 120.55,136 v2(120.55,136.68) PR529.2
  IN4 w0.381: v2(120.55,136.68) 120.4,136.53 120.4,134.57 119.82,133.99 119.82,132.18 123.87,128.13 148.15,128.13 v2(150.76,125.53)
  BOTTOM w0.254: 152.14,122.77 152.64,122.27 152.8,122.27 UC1.AH38
  BOTTOM w0.381: 152.14,122.77 151.19,122.77 150.4,123.56 v1(150.4,124.4) 150.4,125.17 v2(150.76,125.53) 151.08,125.53 151.39,125.22 RH203.1
VCCIO_PGOOD: length 2.7
  BOTTOM w0.114: v1(123.73,121.22) 123.56,121.05 PR5016.2 122.77,120.66 122.06,119.96 PU509.9
VCCIO_SENSE: length 64.5
  IN6 w0.254: v2(168,103.99) 168,105.41 166.77,106.65 166.77,110.7 165.06,112.4 165.06,116.04 165.46,116.44 165.46,123.84
  IN6 w0.381: 165.46,123.84 165.46,124.44 162.53,127.37 132.73,127.37 130.11,124.74 v2(130.11,124.03)
  BOTTOM w0.254: UC1.H14 168,104.05 v2(168,103.99)
  BOTTOM w0.381: PR5017.2 127.94,123.46 128.6,124.12 130.02,124.12 v2(130.11,124.03)
VCCSA_SENSE: length 68.3
  TOP w0.381: PR514.2 127.87,133.23 128.02,133.23 v2(128.36,133.56) 128.91,133.56 PR510.1
  IN6 w0.381: v2(128.36,133.56) 128.36,133.01 130.58,130.79 131.85,130.79 133.74,128.9 153.39,128.9 155.76,131.27 158.2,131.27 160.57,128.9 167.52,128.9 168.22,128.2 172.47,128.2 v2(172.47,128.2)
  BOTTOM w0.254: 174.89,124.88 174.89,124.82 174.26,124.19 171.4,124.19 171.08,124.51 169.45,124.51 168.68,125.29 166.07,125.29 165.54,124.76 165.54,122.49 165.66,122.38 UC1.M38
  BOTTOM w0.381: v2(172.47,128.2) 172.93,128.2 173.37,127.75 RH201.1 174.06,126.11 v1(174.43,125.74) 174.89,125.28 174.89,124.88
VCCSENSE: length 39.1
  TOP w0.381: PR523.1 129.96,137.7 129.96,137.95 v2(130.11,138.1)
  IN4 w0.381: v2(130.11,138.1) 130.11,137.49 137.12,130.48 150.76,130.48 154.5,126.74 v2(154.5,125.4)
  BOTTOM w0.127: v2(130.11,138.1) v1(130.83,138.1)
  BOTTOM w0.254: UC1.AG37 153.98,121.36 154.24,121.62 154.24,122.33 154.52,122.61
  BOTTOM w0.381: v2(154.5,125.4) 154.66,125.56 155.27,125.56 155.59,125.23 RH197.2 155.53,125.22 154.94,124.63 154.94,123.42 154.52,123.01 154.52,122.61 ; PR523.1 130.11,137.85 v2(130.11,138.1)
VDD_1.2V: length 6.9
  BOTTOM w0.102: PR201.1 97.61,42.6 97.84,42.37 97.84,41.97 v1(98.31,41.49)
  BOTTOM w0.203: 93.75,43.68 93.49,43.93 PU201.11
  BOTTOM w0.254: 93.75,43.68 94.73,43.68 94.94,43.46 PC212.1 PR203.2 PR201.1
VDDP_1.2V: length 4.7
  BOTTOM w0.102: v1(91.08,41.74) 91.94,42.6 PR204.2
  BOTTOM w0.203: PC207.2 93.61,43.3 93.09,43.81 PU201.12
  BOTTOM w0.254: PR204.2 PC207.2
VIN: length 112.2
  TOP w0.254: PR716.1 54.96,28.84 54.3,28.18 v2(54.3,28.12) ; v2(112.66,75.49) 113.17,76 113.17,80.32 114.05,81.21 PR31.1
  TOP w0.381: v2(80.15,52.38) 80.15,52.25 76.72,48.82 76.72,42.6
  IN1 w0.508: v2(53.87,17.83) 54.1,17.61 57.57,17.61 59.13,19.17 59.13,20.63 59.13,21.26
  IN3 w0.457: 58.85,21.77 v2(59.13,21.77)
  IN3 w0.508: v2(54.3,28.12) 54.3,26.66 54.81,26.15 57.22,26.15 57.6,25.77 58.75,25.77 59.19,25.33 59.19,23.99 58.77,23.57 58.25,23.57 57.9,23.22 57.9,22.71 58.25,22.35 58.27,22.35 58.85,21.77
  IN4 w0.508: v2(54.3,28.12) 55.34,29.16 68.17,29.16 71.32,32.31 71.32,34.03
  IN6 w0.381: v2(112.66,75.49) 110.63,75.49 102.82,67.68 102.82,62.22 92.97,52.38 v2(80.15,52.38)
  BOTTOM w0.457: PD700.3 58.82,21.47 v2(59.13,21.77)
  BOTTOM w0.508: v2(53.87,17.83) 54.07,17.64 56.64,17.64 57,18 PD101.2
  vias: v2(71.32,35.3) v2(71.32,34.66) v2(71.95,35.3) v2(71.95,34.66) v2(71.95,34.08) v2(72.59,35.3) v2(72.59,34.66) v2(72.59,34.08) v2(73.22,35.3) v2(73.22,34.66) v2(73.22,34.08) v2(73.86,35.3) v2(73.86,34.66) v2(73.86,34.08) v3(73.48,42.5) v3(76.83,35.94) v3(76.96,38.74)
VIN1N: length 3.9
  BOTTOM w0.102: UG11.11 190.86,115.91 190.65,115.7 190.65,115.45 190.56,115.36 190.56,115.19 CG62.2 190.66,114.61 190.56,114.51 190.56,113.91 RG59.2
VIN1P: length 3.9
  BOTTOM w0.102: UG11.12 190.21,115.92 190.42,115.71 190.42,115.54 190.33,115.45 190.33,115.19 CG62.1 190.23,114.61 190.33,114.51 190.33,113.91 RG62.2
VIN2N: length 3.8
  BOTTOM w0.102: RG64.2 186.76,118.3 187.12,118.3 187.18,118.24 187.42,118.24 187.52,118.14 CG63.2 188.16,118.29 188.33,118.29 188.54,118.08 UG11.14
VIN2P: length 3.8
  BOTTOM w0.102: UG11.15 188.54,118.73 188.33,118.52 188.06,118.52 CG63.1 187.52,118.57 187.42,118.47 187.28,118.47 187.22,118.53 186.76,118.53 RG66.2
VIN3N: length 3.9
  BOTTOM w0.102: RG138.2 190.42,122.9 190.42,122.23 190.36,122.16 CG183.2 190.47,121.57 190.47,121.44 190.42,121.39 190.42,121.14 190.21,120.93 UG11.1
VIN3P: length 3.9
  BOTTOM w0.102: RG137.2 190.65,122.95 190.65,122.3 190.79,122.16 CG183.1 190.7,121.59 190.7,121.34 190.65,121.3 190.65,121.13 190.86,120.92 UG11.2
VINMON: length 8.8
  TOP w0.254: v2(267.92,143.3) v1(269.2,143.3) 270.52,143.3 271.99,141.83 271.99,141.43 271.55,140.99 v2(271.5,140.99)
  BOTTOM w0.203: v2(271.5,140.99) 271.69,140.99 272.01,140.67 PU6000.27
  BOTTOM w0.254: v2(267.92,143.3) PR6000.1 PR6006.2
VSSGT_SENSE: length 44
  TOP w0.381: PR532.1 118.83,133.73 PR531.2 118.8,133.33 v1(119.62,132.52) v2(120.56,132.52)
  IN4 w0.381: v2(120.56,132.52) 121.03,132.52 124.65,128.9 148.47,128.9 150.12,127.24 151.01,127.24 152.09,126.17 v2(152.09,125.4)
  BOTTOM w0.254: 152.96,122.76 153.48,122.24 153.48,121.67 153.17,121.36 UC1.AH37
  BOTTOM w0.381: 152.96,122.76 152.08,123.64 152.08,125.39 v2(152.09,125.4) 152.1,125.39 152.59,125.39 RH472.1
VSSIO_SENSE: length 62
  IN6 w0.254: v2(167.19,104.4) 167.19,105.74 166.42,106.51 166.42,110.56 164.72,112.26 164.72,116.18 165.12,116.58 165.12,123.43 163.71,124.84 163.71,124.86
  IN6 w0.381: v2(130.71,124.25) 133.07,126.61 161.97,126.61 163.71,124.86
  BOTTOM w0.254: UC1.J14 167.71,104.4 v2(167.19,104.4)
  BOTTOM w0.381: v2(130.71,124.25) 130.02,124.95 128.34,124.95 127.75,124.35 PR5018.2
VSSSA_SENSE: length 66.4
  TOP w0.381: PR500.2 127.44,134.24 v2(127.44,134.6)
  IN6 w0.381: v2(127.44,134.6) 127.44,132.84 130.3,129.98 131.28,129.98 133.13,128.13 153.7,128.13 156.08,130.51 157.82,130.51 160.19,128.13 167.2,128.13 167.9,127.44 v2(172.47,127.44)
  BOTTOM w0.254: UC1.M37 165.59,121.36 165.25,121.71 165.25,122.28 165.2,122.33 165.2,125.09 165.96,125.85 168.6,125.85 169.59,124.86 171.23,124.86 RH469.1
  BOTTOM w0.381: v2(127.44,134.6) 127.75,134.9 PR508.1 ; v2(172.47,127.44) 172.48,127.43 RH469.1
VSSSENSE: length 36.2
  TOP w0.381: v2(129.22,138.13) 129.14,138.13 128.81,138.46 PR525.1
  IN4 w0.381: v2(129.22,138.13) 129.22,137.01 136.57,129.66 148.79,129.66 150.37,128.07 151.35,128.07 153.29,126.14 153.29,125.73 v2(153.3,125.72)
  BOTTOM w0.254: UC1.AG38 153.84,122.96
  BOTTOM w0.381: v2(153.3,125.72) 153.73,125.29 RH466.1 153.82,125.14 154.38,124.57 154.38,123.7 153.84,123.16 153.84,122.96 ; PR525.1 128.81,138.53 v2(129.22,138.13)
81215_ALERT: length 3.7
  TOP w0.203: PR517.2 123.31,136.62 122.01,137.93 122.01,138.96 122.14,139.1 PU500.41
81215_SCLK: length 4.1
  TOP w0.203: PR515.1 123.61,137.09 123.32,137.09 122.34,138.07 122.34,138.82 122.54,139.03 PU500.42
81215_SDIO: length 3.6
  TOP w0.203: PU500.40 121.74,139.16 121.61,139.03 v1(121.61,138.47) 121.56,138.42 121.56,137.91 122.55,136.92 122.55,136.63 PR519.1
81215_VR_HOT: length 6.1
  TOP w0.102: PR513.1 121.48,136.52 121.93,136.07 v1(121.93,134.6)
  TOP w0.203: PU500.39 121.23,140.14 121.23,136.74 PR513.1
+CODEC_AVDD2: length 14.2
  TOP w0.508: CA16.1 29.41,26.85 CA17.1 27.71,26.85 27.02,26.15 v3(27.02,25.33) 27.6,24.74 v2(29.1,24.74)
  IN6 w0.508: v2(30.88,27.55) 28.95,25.61 28.95,24.9 v2(29.1,24.74)
  BOTTOM w0.203: UA1.24 31.22,27.88 v2(30.88,27.55)
  BOTTOM w0.356: RA12.1 30.83,24.06 LA4.1
  BOTTOM w0.508: LA4.1 30.29,23.56 v2(29.1,24.74)
+EC_VCCA: length 26.4
  TOP w0.203: v2(286.84,27.17) 286.84,27.87 286.27,28.44 v3(286.14,28.44)
  TOP w0.508: v2(286.84,27.17) 287.43,27.17 LE1.2 ; v2(286.84,12.88) CE33.1
  IN1 w0.508: v2(293.75,11.23) 288.49,11.23 v2(286.84,12.88)
  BOTTOM w0.508: v2(286.84,27.17) 286.94,27.17 287.45,26.66 287.45,26.03 287.3,25.88 287.3,25.16 288.1,24.36 288.1,22.08 287.73,21.71 287.73,13.77 v2(286.84,12.88)
+FBA_VREFC: length 10.7
  BOTTOM w0.305: 276.88,102.87 277.07,102.87 277.34,102.61 RG110.2 RG111.2 277.75,103.65 v1(276.89,104.5) 276.54,104.85 CG79.1 276.54,106.19 276.55,106.2 UG2.J14 ; 276.88,102.87 276.86,102.85 CG78.1 277.03,101.77 277.03,100.71 276.55,100.23 UG1.J14 ; 276.88,102.87 RG112.1
+FBB_VREFC: length 27.8
  BOTTOM w0.305: 276.35,69.8 CG113.1 276.35,72.3 276.55,72.51 UG4.J14 ; 276.35,69.8 RG122.2 ; 276.35,69.8 v1(274.16,69.8) 268.52,69.8 266.81,68.09 266.81,61.8 264.51,59.5 RG121.2 RG123.1 CG114.1 261.13,60.37 UG3.J14
+FBC_VREFC: length 11
  BOTTOM w0.305: RG132.2 RG133.2 ; RG133.2 v1(230.49,59.5) 230.89,59.5 231.57,60.18 CG149.1 233.1,60.18 233.37,60.44 234.12,60.44 UG6.J14 ; RG133.2 RG134.1 CG148.1 227.37,60.37 227.02,60.71 UG5.J14
+FBD_VREFC: length 16.5
  BOTTOM w0.305: UG7.J14 199.03,90.58 198.27,89.82 198.27,89.27 ; RG156.2 CG265.1 RG154.1 ; RG156.2 RG155.2 195.54,88.59 196.22,89.27 v1(196.6,89.27) 198.27,89.27 ; RG156.2 CG256.1 ; 198.27,89.27 198.27,84.86 199.03,84.11 UG8.J14
+FBX_PLLAVDD: length 79.4
  TOP w0.305: v2(230.01,89.96) 229.69,90.28 CG54.1 ; v2(247.32,105.2) 247.23,105.29 CG57.1 ; v2(244.62,89.9) 244.5,90.02 CG56.1 ; v2(238.32,89.9) 237.94,90.28 237.87,90.28 CG60.1 ; CG58.1 226.56,94.94 v2(226.32,94.7)
  IN2 w0.4: v2(226.32,94.7) 226.87,95.25 226.87,104.2 226.47,104.6 220.27,104.6 218.32,106.54 212.35,106.54 211.07,107.82 205.12,107.82 v2(205.11,107.81)
  IN6 w0.381: v2(247.32,105.2) 246.74,104.62 246.74,100.38 v2(247.32,99.8) 246.2,98.68 246.2,91.31 244.79,89.9 v2(244.62,89.9) 244.01,90.51 238.93,90.51 v2(238.32,89.9) 237.71,90.51 230.99,90.51 230.44,89.96 v2(230.01,89.96) 229.83,89.96 229.69,90.09 228.42,90.09 226.94,91.57 226.94,94.09 226.33,94.7 v2(226.32,94.7)
  BOTTOM w0.25: UG9.L17 230.17,89.8 v2(230.01,89.96)
  BOTTOM w0.3: v2(226.32,94.7) 226.22,94.7 UG9.V11 ; v2(238.32,89.9) 238.32,89.8 238.36,89.76 ; v2(247.32,105.2) 247.57,104.95 UG9.AN42 ; UG9.AF42 247.42,99.8 v2(247.32,99.8) ; UG9.L38 244.62,89.8 v2(244.62,89.9)
  BOTTOM w0.305: UG9.L29 238.36,89.76
  vias: v1(201.68,106.87)
+HDMI_5V_OUT: length 0.6
  TOP w0.203: v2(222.46,173.02) v3(221.85,173.02)
+IFPX_PLLVDD: length 0.8
  BOTTOM w0.25: UG9.BD18 v2(231.17,112.35) ; UG9.BD15 v2(229.07,112.35)
  vias: v1(230.45,117)
+INV_PWR_SRC:
  vias: v2(158.24,173.92) v2(158.24,173.31) v2(158.82,173.92) v2(158.82,173.28) v2(169.78,181.19) v2(170.11,180.7) v2(170.43,181.21) v2(170.81,180.7) v3(171.55,184.39)
+LAN_IO: length 19.7
  TOP w0.508: RL14.1 266.58,157.39 v2(265.71,157.39) 265.71,158.01 LL1.1 ; RL8.2 v2(242.71,174.36) ; v2(272.2,158.82) 272.54,159.16 CL16.1 ; CL17.1 274.3,159.02 v2(274.54,158.78)
  IN4 w0.508: v2(265.71,157.39) 266.26,156.84 270.53,156.84 272.2,158.5 v2(272.2,158.82)
  BOTTOM w0.203: CL11.1 275.5,165.8 275.5,165.5 275.24,165.24 UL1.1 ; UL1.16 v2(272.2,158.82)
  BOTTOM w0.508: RL1.1 RL2.1 278.16,165.14 v2(278.35,165.33) ; CL11.1 v2(275.9,166.93)
  vias: v2(270.71,170.18) v2(270.71,169.6) v2(270.71,169.01) v3(270.79,168.29)
+LCDVDD: length 2
  TOP w0.127: 163.97,183.01 163.9,183.01 v3(162.51,184.41)
  vias: v2(163.11,172.61) v2(163.19,171.96) v2(163.65,172.91) v2(163.76,172.29) v2(164.17,173.27) v2(164.27,172.69)
+NVVDD1: length 12.2
  TOP w0.254: PC6304.1 246.01,101.97 v2(246.13,101.84) ; PC6302.1 242.97,91.44 v2(243.19,91.23)
  TOP w0.3: 240.17,90.6 240.32,90.74 v2(240.32,91.29) ; v2(241.72,92.64) 241.71,92.66 240.33,92.66 v2(240.32,92.64) 240.31,92.66 238.98,92.66 v2(238.97,92.65)
  TOP w0.305: 240.32,90.74 240.53,90.53 PC6365.1 ; PC6331.1 228.14,99.65 v2(228.42,99.65) ; PC6350.1 233.27,91.2 v2(233.32,91.25) ; PC6353.1 228.12,94.35 v2(228.42,94.05) ; PC6303.1 228.08,106.75 v2(228.42,106.75) 229.11,106.75 v2(229.12,106.76) ; 240.17,90.6 240.11,90.53 PC6358.1
  TOP w0.508: PC6328.1 v2(246.72,98.28)
  BOTTOM w0.254: RG544.1 v2(287.96,81.79)
  BOTTOM w0.3: UG9.BC49 v2(252.27,112.25)
  vias: v2(217.62,138.29) v2(217.69,137.28) v2(218.26,138.29) v2(218.32,137.28) v2(218.89,138.29) v2(218.96,137.28) v2(219.53,138.29) v2(219.59,137.28) v2(220.16,138.29) v2(220.23,137.28) v2(220.8,138.29) v2(220.86,137.28) v2(221.43,138.29) v2(221.5,137.28) v2(221.62,134.99) v2(221.62,134.1) v2(221.69,133.15) v2(221.69,132.13) v2(221.69,131.18) v2(222.07,138.29) v2(222.13,137.28) v2(222.26,134.99) v2(222.26,134.1) v2(222.32,133.15) v2(222.32,132.13) v2(222.32,131.18) v2(222.7,138.29) v2(222.77,137.28) v2(222.89,134.99) v2(222.89,134.1) v2(222.96,133.15) v2(222.96,132.13) v2(222.96,131.18) v2(223.53,134.99) v2(223.53,134.1) v2(223.59,133.15) v2(223.59,132.13) v2(223.59,131.18) v2(224.16,134.99) v2(224.16,134.1) v2(224.23,133.15) v2(224.23,132.13) v2(224.23,131.18) v2(224.86,133.15) v2(224.86,132.13) v2(224.86,131.18) v2(225.5,133.15) v2(225.5,132.13) v2(225.5,131.18) v2(226.13,133.15) v2(226.13,132.13) v2(226.13,131.18) v2(226.77,133.15) v2(226.77,132.13) v2(226.77,131.18) v2(228.42,103.95) v2(228.42,101.7) v2(228.42,96.85) v2(229.12,103.95) v2(229.12,101.72) v2(229.12,99.65) v2(229.12,96.85) v2(229.12,94.05) v2(230.52,106.76) v2(230.52,103.95) v2(230.52,99.65) v2(230.52,96.85) v2(230.52,94.05) v2(231.92,108.15) v2(231.92,106.76) v2(231.92,105.36) v2(231.92,103.96) v2(231.92,102.56) v2(231.92,98.2) v2(231.92,96.85) v2(231.92,95.45) v2(232.36,135.63) v2(232.42,136.45) v2(232.48,138.17) v2(232.48,137.34) v2(232.62,98.21) v2(232.62,96.85) v2(232.67,133.79) v2(232.67,132.52) v2(232.67,131.25) v2(233.05,136.45) v2(232.99,135.63) v2(233.12,138.17) v2(233.12,137.34) v2(233.31,133.79) v2(233.31,132.52) v2(233.31,131.25) v2(233.32,108.15) v2(233.32,106.76) v2(233.32,105.36) v2(233.32,103.96) v2(233.32,102.56) v2(233.32,98.2) v2(233.32,96.85) v2(233.32,95.45) v2(233.75,138.17) v2(233.75,137.34) v2(233.94,133.79) v2(233.94,132.52) v2(233.94,131.25) v2(234.39,138.17) v2(234.39,137.34) v2(234.58,133.79) v2(234.58,132.52) v2(234.58,131.25) v2(234.67,108.15) v2(234.67,105.35) v2(234.67,98.25) v2(234.67,95.45) v2(234.67,92.65) v2(234.72,106.75) v2(234.72,103.95) v2(234.72,101.15) v2(234.72,99.65) v2(234.72,96.8) v2(234.72,94.05) v2(235.02,138.17) v2(235.02,137.34) v2(235.21,133.79) v2(235.21,132.52) v2(235.21,131.25) v2(235.42,106.75) v2(235.42,103.95) v2(235.42,101.15) v2(235.42,99.6) v2(235.42,96.85) v2(235.42,94.05) v2(235.91,133.79) v2(235.91,132.52) v2(235.91,131.25) v2(236.55,133.79) v2(236.55,132.52) v2(236.55,131.25) v2(236.82,106.75) v2(236.82,103.95) v2(236.82,101.15) v2(236.82,99.6) v2(236.82,96.8) v2(236.82,94.05) v2(237.18,133.79) v2(237.18,132.52) v2(237.18,131.25) v2(237.82,133.79) v2(237.82,132.52) v2(237.82,131.25) v2(238.22,106.75) v2(238.22,103.95) v2(238.22,101.15) v2(238.22,99.6) v2(238.22,96.8) v2(238.22,94.05) v2(238.45,133.79) v2(238.45,132.52) v2(238.45,131.25) v2(238.96,138.23) v2(238.96,137.21) v2(238.96,136.2) v2(238.97,108.15) v2(238.92,106.75) v2(238.97,105.35) v2(238.92,103.95) v2(238.92,101.15) v2(238.92,99.65) v2(238.97,98.25) v2(238.92,96.85) v2(238.97,95.45) v2(238.92,94.05) v2(239.02,135.12) v2(239.09,133.79) v2(239.09,132.52) v2(239.09,131.25) v2(239.59,138.23) v2(239.59,137.21) v2(239.59,136.2) v2(239.66,135.12) v2(239.72,133.79) v2(239.72,132.52) v2(239.72,131.25) v2(240.23,138.23) v2(240.23,137.21) v2(240.23,136.2) v2(240.29,135.12) v2(240.36,133.79) v2(240.36,132.52) v2(240.36,131.25) v2(240.32,105.35) v2(240.32,103.95) v2(240.32,102.6) v2(240.32,98.25) v2(240.32,96.85) v2(240.32,95.45) v2(240.32,94.05) v2(240.86,138.23) v2(240.86,137.21) v2(240.86,136.2) v2(241.02,103.95) v2(241.02,102.6) v2(241.5,138.23) v2(241.5,137.21) v2(241.5,136.2) v2(241.72,105.35) v2(241.72,103.95) v2(241.72,102.6) v2(241.72,98.25) v2(241.72,96.85) v2(241.72,95.45) v2(241.72,94.05) v2(242.13,138.23) v2(242.13,137.21) v2(242.13,136.2) v2(243.12,106.75) v2(243.12,103.95) v2(243.12,101.15) v2(243.12,96.85) v2(243.12,94.05) v2(244.52,106.75) v2(244.52,103.95) v2(244.52,101.15) v2(244.52,99.62) v2(244.52,96.85) v2(244.52,94.05) v2(244.62,110.9) v2(245.22,106.75) v2(245.22,103.95) v2(245.22,101.15) v2(245.22,99.62) v2(245.22,96.85) v2(245.22,94.05) v2(245.87,110.95) v2(246.45,137.21) v2(246.45,136.2) v2(246.45,135.18) v2(246.45,134.23) v2(246.45,133.28) v2(246.45,132.39) v2(246.45,131.56) v2(246.67,113.05) v2(246.62,110.25) v2(246.62,108.85) v2(246.62,107.45) v2(247.09,137.21) v2(247.09,136.2) v2(247.09,135.18) v2(247.09,134.23) v2(247.09,133.28) v2(247.09,132.39) v2(247.09,131.56) v2(247.73,137.2) v2(247.72,136.2) v2(247.72,135.18) v2(247.72,134.23) v2(247.72,133.28) v2(247.72,132.39) v2(247.72,131.56) v2(248.02,113.05) v2(248.02,111.65) v2(248.02,110.25) v2(248.02,108.85) v2(248.36,137.2) v2(248.36,136.2) v2(248.36,135.18) v2(248.36,134.23) v2(248.36,133.28) v2(248.36,132.39) v2(248.36,131.56) v2(248.72,109.55) v2(249.06,137.21) v2(249.06,136.2) v2(248.99,135.18) v2(248.99,134.23) v2(248.99,133.28) v2(248.99,132.39) v2(248.99,131.56) v2(249.47,109.45) v2(249.69,137.21) v2(249.69,136.2) v2(249.69,135.18) v2(249.69,134.23) v2(249.69,133.28) v2(249.69,132.39) v2(249.69,131.56) v2(250.12,115.15) v2(250.12,113.75) v2(250.33,137.21) v2(250.33,136.2) v2(250.33,135.18) v2(250.33,134.23) v2(250.33,133.28) v2(250.33,132.39) v2(250.33,131.56) v2(250.82,114.45) v2(250.82,113.05) v2(250.96,137.21) v2(250.96,136.2) v2(250.96,135.18) v2(250.96,134.23) v2(250.96,133.28) v2(250.96,132.39) v2(250.96,131.56) v2(250.87,110.25) v2(251.6,137.21) v2(251.6,136.2) v2(251.6,135.18) v2(251.6,134.23) v2(251.6,133.28) v2(251.6,132.39) v2(251.6,131.56) v2(252.23,137.21) v2(252.23,136.2) v2(252.23,135.18) v2(252.23,134.23) v2(252.23,133.28) v2(252.23,132.39) v2(252.23,131.56) v2(252.22,117.25) v2(252.22,115.85) v2(252.87,137.21) v2(252.87,136.2) v2(252.87,135.18) v2(252.87,134.23) v2(252.87,133.28) v2(252.87,132.39) v2(252.87,131.56) v2(252.92,116.55) v2(253.5,137.21) v2(253.5,136.2) v2(253.5,135.18) v2(253.5,134.23) v2(253.5,133.28) v2(253.5,132.39) v2(253.5,131.56) v2(254.14,137.21) v2(254.14,136.2) v2(254.14,135.18) v2(254.14,134.23) v2(254.14,133.28) v2(254.14,132.39) v2(254.14,131.56) v2(258.2,137.91) v2(258.2,136.83) v2(258.2,135.88) v2(258.83,137.91) v2(258.83,136.83) v2(258.83,135.88) v2(259.47,137.91) v2(259.47,136.83) v2(259.47,135.88) v2(260.1,137.91) v2(260.1,136.83) v2(260.1,135.88) v2(260.17,134.67) v2(260.17,133.72) v2(260.74,137.91) v2(260.74,136.83) v2(260.74,135.88) v2(260.8,134.67) v2(260.8,133.72) v3(253.16,138.52)
+NVVDD2: length 41.2
  TOP w0.254: PC6377.1 237.09,105.08 v2(236.82,105.35)
  TOP w0.3: v2(229.12,95.45) 228.45,95.45 v2(228.43,95.47) ; v2(245.22,102.55) v2(244.52,102.55) ; v2(245.22,95.45) 245.19,95.42 v2(244.52,95.42) ; v2(229.12,102.6) 229.07,102.55 228.39,102.55 v2(228.38,102.56) ; v2(245.22,105.35) v2(244.52,105.35) ; v2(228.42,98.25) v2(229.12,98.25) ; v2(235.42,102.55) v2(234.77,102.55) ; v2(244.52,98.25) v2(245.22,98.25)
  TOP w0.305: 237.52,97.55 v2(238.22,98.25) ; 237.52,97.55 PC6362.1 ; 237.52,97.55 237.52,97.55 v2(236.82,98.25) 236.73,98.16 235.51,98.16 v2(235.42,98.25) ; v2(245.22,92.65) 245.19,92.62 v2(244.52,92.62) 244.45,92.69 PC6314.1 243.19,92.69 v2(243.12,92.62) ; v2(244.52,98.25) 244.48,98.29 PC6315.1 243.16,98.29 v2(243.12,98.25) ; v2(229.12,98.25) 229.13,98.26 PC6343.1 230.51,98.26 v2(230.52,98.25) ; v2(244.52,105.35) 244.14,104.97 PC6339.1 ; PC6317.1 244.63,108.04 v2(244.52,108.15) ; PC6319.1 229.66,100.89 v2(229.12,100.35) v2(228.42,100.35) ; v2(230.52,100.35) 230.19,100.02 PC6320.1 ; v2(243.12,100.45) 243.43,100.14 PC6338.1 244.17,100.14 v2(244.53,100.5) 245.21,100.5 v2(245.23,100.48) ; v2(238.87,102.55) v2(238.22,102.55) 237.9,102.55 PC6376.1 237.13,102.55 v2(236.82,102.55) ; PC6321.1 243.55,105.78 v2(243.12,105.35) ; v2(228.42,105.35) 228.45,105.38 v2(229.12,105.38) 229.39,105.65 PC6340.1 230.22,105.65 v2(230.52,105.35) ; v2(243.12,102.55) 243.18,102.61 PC6316.1 244.46,102.61 v2(244.52,102.55) ; v2(230.52,102.55) 230.34,102.73 PC6336.1 229.25,102.73 v2(229.12,102.6) ; v2(230.52,92.65) 230.49,92.62 PC6342.1 229.15,92.62 v2(229.12,92.65) v2(228.42,92.65) ; v2(230.52,108.18) 230.28,107.94 PC6318.1 229.36,107.94 v2(229.12,108.18) 228.48,108.18 v2(228.42,108.13) ; v2(244.52,95.42) 244.32,95.62 PC6337.1 243.29,95.62 v2(243.12,95.45) ; v2(229.12,95.45) 229.2,95.37 PC6341.1 230.44,95.37 v2(230.52,95.45) ; v2(238.22,92.65) 238.04,92.83 PC6361.1 237.05,92.83 v2(236.82,92.6)
  BOTTOM w0.254: v2(251.15,121.77) 250.95,121.77 250.64,121.47 PR6425.1
  BOTTOM w0.508: v2(289.7,90.01) 289.96,89.74 RG542.1
  vias: v2(235.42,108.15) v2(235.42,105.35) v2(235.42,100.35) v2(235.42,95.45) v2(235.42,92.6) v2(236.82,108.15) v2(236.82,95.45) v2(238.22,108.15) v2(238.22,105.35) v2(238.22,100.45) v2(238.22,95.45) v2(245.92,108.77) v2(276.59,62.64) v2(276.59,61.81) v2(276.59,60.93) v2(276.59,60.16) v2(277.22,62.64) v2(277.22,61.81) v2(277.22,60.93) v2(277.22,60.16) v2(278.46,60.76) v2(278.46,59.93) v2(278.46,59.05) v2(278.46,57.97) v2(278.72,66.27) v2(279.09,60.76) v2(279.09,59.93) v2(279.09,59.05) v2(279.15,57.97) v2(279.36,66.27) v2(279.73,60.76) v2(279.79,59.93) v2(279.79,59.05) v2(279.79,57.97) v2(279.99,66.27) v2(280.42,60.76) v2(280.42,59.93) v2(280.42,59.05) v2(280.42,57.97) v2(280.69,66.27) v2(281.06,60.76) v2(281.06,59.93) v2(281.06,59.05) v2(281.06,57.97) v2(281.33,66.27) v2(281.69,60.76) v2(281.69,59.93) v2(281.69,59.05) v2(281.69,57.97) v2(282.01,62.41) v2(282.01,61.78) v2(282.33,60.76) v2(282.33,59.93) v2(282.33,59.05) v2(282.33,57.97) v2(282.65,62.41) v2(282.65,61.78) v2(282.96,60.76) v2(282.96,59.93) v2(282.96,59.05) v2(282.96,57.97) v2(283.28,62.41) v2(283.28,61.78) v2(283.6,60.76) v2(283.6,59.93) v2(283.6,59.05) v2(283.6,57.97) v2(283.92,62.41) v2(283.92,61.78) v2(284.23,60.76) v2(284.23,59.93) v2(284.23,59.05) v2(284.23,57.97) v2(284.55,62.41) v2(284.55,61.78) v2(284.87,60.76) v2(284.87,59.93) v2(284.87,59.05) v2(284.87,57.97) v2(285.19,62.41) v2(285.19,61.78) v2(285.57,60.76) v2(285.5,59.93) v2(285.5,59.05) v2(285.5,57.97) v2(285.82,62.41) v2(285.82,61.78) v2(286.14,59.93) v2(286.14,59.05) v2(286.14,57.97) v2(286.2,60.76) v2(286.46,62.41) v2(286.46,61.78) v2(286.84,60.76) v2(286.77,59.93) v2(286.77,59.05) v2(286.77,57.97) v2(287.09,62.41) v2(287.09,61.78) v2(287.47,60.82) v2(287.47,60) v2(287.47,59.11) v2(287.47,58.03) v2(288.11,66.73) v2(288.11,66.03) v2(288.11,60.82) v2(288.11,60) v2(288.11,59.11) v2(288.11,58.03) v2(288.74,66.73) v2(288.74,66.03) v2(288.74,60.82) v2(288.74,60) v2(288.74,59.11) v2(288.74,58.03) v2(289.38,69.33) v2(289.38,68.7) v2(289.38,68.06) v2(289.38,67.43) v2(289.38,66.73) v2(289.38,66.03) v2(290.01,69.33) v2(290.01,68.7) v2(290.01,68.06) v2(290.01,67.43) v2(290.01,66.73) v2(290.01,66.03) v2(290.65,68.06) v2(290.65,67.43) v2(290.65,66.73) v2(290.65,66.03) v2(290.71,68.7) v2(291.28,68.06) v2(291.28,67.43) v2(291.28,66.73) v2(291.28,66.03) v3(276.34,59.52)
+PEX_PLL_HVDD: length 24.8
  TOP w0.089: v1(218.04,112.4) 218.18,112.26 CG34.1
  TOP w0.356: v2(219.25,111.68) 218.98,111.95 CG34.1
  TOP w0.508: v2(219.25,111.68) 219.67,111.26 LG1.1
  IN6 w0.381: v2(239.52,110.9) 238.81,110.19 226.87,110.19 225.56,111.5 224.61,111.5 224.1,110.99 219.94,110.99 v2(219.25,111.68)
  BOTTOM w0.3: v2(239.52,110.9) 239.52,111 UG9.BB30
+PEX_VDD: length 4.5
  TOP w0.254: CG311.1 245.14,113.72 v2(243.77,112.35)
  TOP w0.305: v2(243.77,112.35) v2(243.77,111.65)
  BOTTOM w0.25: UG9.BC17 v2(229.87,111.65) ; UG9.BC15 v2(229.07,111.65) ; UG9.BC18 v2(231.17,111.65)
  BOTTOM w0.254: UG9.BB15 228.77,111.05 v2(229.02,110.8)
  vias: v2(231.25,53.9) v2(231.25,53.32) v2(231.25,52.73) v2(231.83,53.9) v2(231.83,53.32) v2(231.83,52.73) v2(231.97,111.65) v2(232.43,53.27) v2(232.77,52.75) v2(232.99,110.8) v2(233.27,111.65) v2(234.07,111.65) v2(234.12,110.9) v2(241.67,112.35) v2(241.67,111.65) v2(241.62,110.9) v2(242.47,111.65) v2(242.52,110.9) v2(243.72,110.9) v3(230.97,111.1)
+RBIAS: length 4.2
  TOP w0.102: v1(276.7,159.44) 276.37,159.77 v2(275.9,159.77)
  TOP w0.508: RL3.1 275.37,159.77 v2(275.9,159.77)
  BOTTOM w0.203: v2(275.9,159.77) 275.47,160.2 275.47,161.44 275.27,161.64 UL1.10
+RTC_CELL: length 407
  TOP w0.356: v2(39.49,30.09) 39.06,30.09 38.55,30.59 RA25.1
  TOP w0.508: QE58.1 297.15,35.55 v2(297.15,38.22) 298.41,39.47 298.41,43.16 297.19,44.38 v3(296.11,44.38) 295.92,44.19 PD5.1 ; CH80.1 213.67,15.98 214.41,15.98 214.44,15.95 RH84.1 ; CH80.1 213.43,16.21 213.43,17.4 RH83.1 RH531.2 ; CH80.1 CH173.1 213.66,14.93 214.23,14.35 215.27,14.35 215.78,14.86 v2(215.78,15.18) 216.45,14.51 CH226.1
  IN2 w0.178: 203.68,37.2 203.68,37.11 202.75,36.17 201.12,36.17 200,37.3 200,37.31 199.76,37.54 199.75,37.54 199.52,37.77
  IN2 w0.203: 203.68,37.2 203.21,37.2 202.52,37.89 202.52,38.23 202.27,38.48 201.92,38.48 201.92,38.47 199.73,38.47 199.52,38.27 199.52,37.77
  IN2 w0.381: 192.1,32.61 192.62,32.61 194.76,34.75 194.76,35.11 195.14,35.49 197.43,35.49 197.87,35.93 197.87,36.88 198.34,37.35 199.08,37.35 199.38,37.65 199.4,37.65 199.52,37.77 ; 203.68,37.2 205.69,37.2 206.48,36.41 206.55,36.41 206.57,36.38 207.76,36.38 207.91,36.53 208.22,36.53 208.52,36.83 208.52,37.14 209.05,37.67 210.42,37.67 212.48,35.61 216.04,35.61 216.73,36.31 219.18,36.31
  IN2 w0.508: 219.18,36.31 220.16,36.31 220.77,35.7 223.36,35.7 225.81,38.15 231.03,38.15 231.4,38.52 234.99,38.52 235.41,38.1 237.44,38.1 238.96,36.58 239.85,36.58 241.58,34.85 241.58,32.37 242.99,30.95 248.6,30.95 249.27,30.28 257.14,30.28 257.39,30.03 265.37,30.03 266.35,29.05 272.39,29.05 273.42,28.02 275.6,28.02 275.98,27.64 275.98,26.37 276.71,25.64 278.71,25.64 284.34,20.01 289.8,20.01 290.4,19.41 292.83,19.41 v2(292.98,19.26) ; 192.1,32.61 191,32.61 190.47,32.08 189.68,32.08 189.58,32.19 185.05,32.19 184.41,31.55 v2(183.65,31.55) 183.46,31.55 182.76,30.85 129.86,30.85 120.89,21.89 120.88,21.89 120.39,21.4 100.59,21.4 96.1,16.91 84.25,16.91 82.61,15.27 56.61,15.27 55.44,16.44 44.82,16.44 43.93,17.33 43.93,18.8 43.09,19.64 37.11,19.64 35.38,21.38 35.38,22.47 33.87,23.98 33.87,24.13 33.87,25.47 34.4,26 34.98,26 37.47,28.49 37.47,29.18 38.38,30.09 v2(39.49,30.09)
  IN4 w0.508: v2(215.78,15.18) 215.78,14.79 215.32,14.33 214.71,14.33 214.64,14.26 214.64,14.26 214.53,14.15 206.28,14.15 205.71,14.72 204.03,14.72 203.23,15.52 201.31,15.52 200.89,15.1 193.94,15.1 193.3,15.74 193.3,16.69 192.92,17.07 192.87,17.07 192.8,17.14 192.28,17.14 192.21,17.07 190.64,17.07 189.56,15.99 189.22,15.99 189.15,15.93 184.79,15.93 v2(184.1,16.63)
  BOTTOM w0.508: v2(297.15,38.22) 297.15,34.5 295.98,33.33 293.01,33.33 292.5,32.82 292.5,20.11 292.97,19.64 292.97,19.26 v2(292.98,19.26) ; v2(184.1,16.63) 183.26,17.46 183.26,21.08 182.74,21.61 182.7,21.61 182.34,21.96 182.34,22 181.94,22.41 181.94,24.21 181.93,24.21 181.93,25.68 181.94,25.68 181.94,26.16 182.26,26.49 182.26,27.05 182.95,27.74 182.95,27.81 183.12,27.98 183.12,28.48 182.95,28.65 182.95,30.93 183.57,31.55 v2(183.65,31.55)
+TBTA_VBUS: length 2.9
  BOTTOM w0.254: JUSBC1.B9 191.35,181.15 191.27,181.07 191.27,180.72 v2(191.16,180.62) ; v2(202.8,161.24) 202.66,161.39 UT4.A10 UT4.B10 ; v2(194.11,180.68) 194.11,180.78 193.85,181.04 JUSBC1.B4
  vias: v2(191.65,178.83) v2(191.65,178.25) v2(193.68,178.71) v2(193.68,178.11) v2(203.12,160.75) v2(203.77,166.46) v2(203.77,165.83) v2(204.35,166.46) v2(204.35,165.83) v3(204.38,160.56)
+V_DDR_REFA: length 5.9
  TOP w0.508: CD18.1 154.45,52.02 v2(154.63,51.84) ; CD18.1 RH209.1 RH484.2 ; CD18.1 RH206.2
  BOTTOM w0.305: v2(154.63,51.84) 154.37,52.1 154.37,52.53 154.44,52.6 JDIMM1.164
+V_DDR_REFA_R: length 64.6
  TOP w0.508: RH484.1 156.23,54.33 156.47,54.57 156.47,54.84 v2(156.36,54.96) 155.95,55.37 CH101.1
  IN4 w0.508: v2(156.36,54.96) 156.25,54.85 155.65,54.85 155.07,55.43 155.07,62.67 153.49,64.25 152.94,64.25 141.04,76.15 141.04,98.29 140.4,98.93 135.26,98.93 134.69,99.5 134.69,102.14 134.05,102.77 134.05,103.5 134.4,103.85 v2(134.63,103.85)
+V_DDR_REFB: length 5.6
  TOP w0.508: RH207.2 RH485.2 RH210.1 CD29.1 154.44,42.25 v2(154.29,42.4)
  BOTTOM w0.305: v2(154.29,42.4) 154.44,42.24 JDIMM2.164
+V_DDR_REFB_R: length 77.4
  TOP w0.508: v2(152.66,38.74) CH100.1 RH485.1
  IN4 w0.508: v2(133.33,103.05) 133.33,102.21 132.81,101.69 132.81,100.67 133.81,99.67 133.81,96.7 135.13,95.37 137.63,95.37 138.02,94.99 138.02,93.58 136.4,91.97 136.4,90.14 140.02,86.52 140.02,75.73 151.77,63.98 151.77,54.54 151.39,54.16 151.39,50.41 151.77,50.03 151.77,40.82 152.66,39.93 v2(152.66,38.74)
AC_PRESENT: length 59.5
  IN3 w0.089: 219.18,21.43 217.48,21.43 v2(217.48,21.43)
  IN3 w0.102: v2(232.1,19.04) 231.64,19.5 227.2,19.5 226.45,20.25 224.15,20.25 223.2,21.2 223.08,21.32 220.58,21.32 220.55,21.35 220.07,21.35 219.99,21.43 219.18,21.43
  BOTTOM w0.102: v2(232.1,19.04) v1(232.68,18.46) 232.94,18.2 232.94,12.13 230.88,10.06 229.62,10.06 229.36,9.8 228.57,9.8 226.58,7.8 226.58,7.23 225.52,6.17 206.95,6.17 206.12,7 206.12,7.8 205.42,8.5 205.42,9.66 RH533.1 204.94,10.14 204.01,10.14 203.89,10.02 DH1.2
  BOTTOM w0.122: v2(217.48,21.43) 217.48,21.28 217.09,20.88 216.73,20.88 216.51,21.11 UH1.BG42
ACDET_CHG: length 4.5
  TOP w0.203: PU700.6 56.64,26.54 55.95,27.23 v2(55.83,27.23)
  TOP w0.254: v2(55.83,27.23) 55.63,27.23 55.16,27.71 PR716.2
  BOTTOM w0.254: v2(55.83,27.23) 56.34,26.72 PC719.1 56.32,26.67 PR719.1
ACDRV_CHG: length 2.1
  TOP w0.203: PU700.4 57.44,26.95 57.22,27.17 57.22,27.68
  TOP w0.508: 57.22,27.68 57.07,27.83 PR705.2
ACIN#: length 48.5
  TOP w0.102: UE1.18 319.84,15.08 318.78,14.02 318.01,14.02 317.55,14.48 316.93,14.48 v2(316.56,14.85) ; QE3.3 325.18,47.81 RE17.2 324.29,47.98 v2(324.24,47.93)
  IN3 w0.102: v2(324.24,47.93) 323.54,47.93 323.16,47.55 323.16,46.98 322.91,46.73 321.53,46.73 321.36,46.55 321.36,44.54 321.7,44.2 321.7,43.22 321.84,43.08 321.84,39.93 321.77,39.86 321.05,39.14 321.05,37.2 316.62,32.77 316.62,31.96 314.77,30.11 314.77,28.63 315.34,28.06 315.34,24.45 314.05,23.16 314.05,21.03 v2(314.15,20.94)
  BOTTOM w0.102: v2(316.56,14.85) 316.6,14.89 316.6,18.49 v2(314.15,20.94) ; v2(324.24,47.93) v1(323.34,47.93)
AD0_0: length 1.8
  TOP w0.102: RE43.2 225.8,159.16 UE3.31
AD0_1: length 4.1
  TOP w0.102: RE27.1 186.04,25.86 185.61,26.29 185.61,27.28 v1(186.09,27.77)
  TOP w0.107: RE27.1 186.6,25.33 UE4.31
AD0_2: length 3.5
  TOP w0.102: UE8.31 303.97,36.78 303.35,36.16 303.35,35.77 v1(303.02,35.44) 302.5,34.92 RE164.1
AD1_0: length 1.9
  TOP w0.102: UE3.32 226.19,158.66 RE40.2
AD1_1: length 3.2
  TOP w0.102: RE26.2 184.56,26.42 v1(184.12,26.42)
  TOP w0.107: UE4.32 186.1,24.88 RE26.2
AD1_2: length 4
  TOP w0.102: UE8.32 304.1,36.28 303.9,36.08 303.9,35.11 v1(302.89,34.1) 302.81,34.03 RE163.1
AD2_0: length 4.3
  TOP w0.102: v1(224.15,156.34) RE42.1 225.8,157.03 227.19,157.03 227.51,157.34 UE3.1
AD2_1: length 1.6
  TOP w0.107: UE4.1 184.34,23.5 RE29.1
AD2_2: length 4.3
  TOP w0.102: UE8.1 305.22,35.01 304.94,34.73 304.53,34.73 304.43,34.62 v1(304.43,34.28) 304.43,32.53 RE165.2
AD3_0: length 2.8
  TOP w0.102: RE44.1 226.21,156.54 v1(227.03,156.54) 228.01,157.52 UE3.2
AD3_1: length 1.4
  TOP w0.107: UE4.2 183.89,22.99 RE30.1
AD3_2: length 3.8
  TOP w0.102: RE162.1 v1(304.92,32.99) 304.92,33.5 305.72,34.29 UE8.2
AD_BID: length 8
  TOP w0.102: v1(286.93,10.1) RE64.1 RE66.2 CE28.1 291.74,10.1
  TOP w0.107: 291.74,10.1 292.74,11.1 293.25,11.1 293.54,10.82 UE5.66
ADP_I: length 284.6
  TOP w0.102: PR717.2 v1(52,27.42)
  TOP w0.107: v2(279.02,28.68) 279.15,28.54 279.15,26.42 279.85,25.73 279.85,20.89 281.98,18.76 281.98,18.31 284.49,15.8 284.49,10.72 285.45,9.76 287.38,9.76 287.46,9.68 287.46,8.42 287.76,8.12 288.26,8.12 288.36,8.22 289.01,8.22 289.11,8.12 PR23.2 293.14,9 UE5.65 ; v2(52.97,28.12) PR717.2
  IN2 w0.102: v2(279.02,28.68) 278.63,28.68 277.62,29.68 276.08,29.68 274.81,30.95 272.55,30.95 272.18,31.32 268.65,31.32 268,31.98 261.19,31.98 260.77,32.4 257.59,32.4 257.16,31.98 250.24,31.98 248.27,33.95 248.27,36.73 246.84,38.17 240.23,38.17 239.1,39.3 239.03,39.3 238.65,39.68 236.06,39.68 235.64,40.1 234.81,40.1 234.71,40.2 234.27,40.64 230.33,40.64 229.43,39.74 224.89,39.74 222.59,42.04 214.95,42.04 213.73,40.82 213.63,40.73 209.53,40.73 209.5,40.76 207,40.76 206.83,40.59 204.61,40.59 204.41,40.79 200.2,40.79 200.19,40.78 197.44,40.78 197.17,40.52 196.5,40.52 195.68,39.69 195.27,39.69 194.95,39.37 194.95,39.12 193.1,37.27 191.32,37.27 191.1,37.48 190.28,37.48 188.88,36.08 183.93,36.08 179.95,32.1 122.49,32.1 112.99,22.6 99.86,22.6 96.32,19.05 75.46,19.05 73.95,20.56 66.63,20.56 65.85,19.78 63.24,19.78 62.25,20.77 58.63,20.77 57.66,21.74 55.92,21.74 52.97,24.69 v2(52.97,28.12)
ADPIN: length 3.8
  TOP w0.102: v3(79.45,42.6) 79.45,41.38 v2(79.43,41.37) ; v2(79.43,41.37) v3(77.97,41.37) ; v2(79.43,41.37) v3(79.43,40.26)
ALERT#: length 23.9
  TOP w0.089: RG504.1 219.38,115.16 v2(220.07,115.85)
  IN1 w0.102: v2(220.07,115.85) 219.42,115.21 218.16,115.21 217.62,115.74 216.95,115.74 214.94,117.75 213.98,117.75 213.78,117.94 212.71,117.94 212.32,117.54 212.32,117.29 211.09,116.07 210.21,116.07 209.61,116.66 205.46,116.66 205.02,117.1 205.02,117.58 v2(205.48,118.04)
  BOTTOM w0.1: UG9.BJ3 v2(220.07,115.85)
  BOTTOM w0.102: v1(206.29,117.45) 206.14,117.45 205.56,118.04 v2(205.48,118.04) 204.73,118.04 204.11,118.66 QG501.4
ALIEN_LED_B_DRV#: length 20.4
  TOP w0.102: v2(229.82,156.96) 230.51,156.26 231.39,156.26 v1(231.47,156.18)
  TOP w0.254: UE3.5 229.51,157.27 v2(229.82,156.96)
  TOP w0.508: JLOGO.5 225.92,169.76 226.43,170.27 v2(226.45,170.27)
  IN1 w0.508: v2(229.82,156.96) 229.82,157.46 229,158.28 229,159.46 228.42,160.04 228.42,162.82 227.11,164.12 227.11,168.12 226.19,169.05 226.19,170.01 v2(226.45,170.27)
ALIEN_LED_G_DRV#: length 14.3
  TOP w0.127: v2(224.92,166.81) v1(224.92,166)
  TOP w0.254: v2(229.03,157.03) 229.01,157.05 UE3.4
  TOP w0.508: v2(224.92,166.81) JLOGO.4
  IN1 w0.508: v2(224.92,166.81) 224.92,165.72 225.92,164.72 225.92,163.42 227.04,162.3 227.04,160.53 228.37,159.2 228.37,158.01 229.03,157.35 v2(229.03,157.03)
ALIEN_LED_R_DRV#: length 18.9
  TOP w0.127: JLOGO.3 223.92,167.15 v1(223.12,166.35)
  TOP w0.254: UE3.3 228.51,157.15 v2(228.38,157.03)
  TOP w0.508: v2(223.72,169.54) 223.72,169.4 223.92,169.2 JLOGO.3
  IN1 w0.508: v2(228.38,157.03) 228.38,157.1 226.78,158.7 226.78,159.89 226.4,160.26 226.4,162.03 225.28,163.15 225.28,164.46 224.28,165.45 224.28,168.97 v2(223.72,169.54)
AMD#_NV: length 40.7
  TOP w0.102: v2(318.79,16.86) 318.79,18.2 318.3,18.7 UE1.27 ; v1(327.79,45.39) v2(328.4,45.39) 328.46,45.33 UE6.20
  IN1 w0.102: v2(328.4,45.39) 329.07,44.72 329.07,44.19 331.42,41.84 331.42,38.15 328.17,34.9 v2(328.17,31.37)
  IN3 w0.102: v2(328.17,31.37) 327.47,30.67 327.47,25.14 323.69,21.37 323.69,19.62 322.65,18.57 320.51,18.57 v2(318.79,16.86)
AMP_ASEL: length 2.1
  TOP w0.107: UA4.18 35.45,15.87 v2(35.26,16.06)
  BOTTOM w0.102: v1(36.22,15.55) 35.71,16.06 v2(35.26,16.06)
AMP_I2S_BCLK: length 342.1
  TOP w0.107: RA29.2 35.82,38.36 36.37,38.9 v1(37.79,38.9) 38.12,38.9 v2(38.87,38.16) ; v2(38.57,12.95) 38.36,12.95 38.02,12.61 UA4.10 ; v2(327.09,18.16) 326.59,18.66 JIO.15
  IN2 w0.102: v2(327.09,18.16) 326.64,17.71 326.63,17.71 325.98,17.06 324.25,17.06 323.32,17.99 321.32,17.99 321.13,17.99 320.08,19.04 316.95,19.04 312.97,15.07 310.5,15.07 308.16,12.73 304.42,12.73 303.07,14.07 300.1,14.07 299.96,13.94 297.97,13.94 297.82,13.78 294.52,13.78 293.91,14.39 293.09,14.39 292.69,14.79 292.1,15.38 279.37,15.38 279.03,15.04 277.5,15.04 276.77,15.77 265.12,15.77 264.06,14.71 253.01,14.71 251.8,13.49 240.78,13.49 240.03,12.75 217.24,12.75 216.39,11.9 210.68,11.9 209.97,11.19 208,11.19 207.29,11.9 201.54,11.9 200.05,10.41 193.1,10.41 191.52,11.99 191.52,13.64 191.97,14.09 191.97,14.57 190.63,15.91 186.45,15.91 185.24,17.12 182.75,17.12 179.55,20.32 169.93,20.32 169.48,19.88 128.06,19.88 126.45,18.27 99.69,18.27 96.75,15.33 84.9,15.33 83.26,13.69 55.39,13.69 54.4,14.68 46.31,14.68 45.14,13.52 43.85,13.52 42.81,12.47 39.04,12.47 v2(38.57,12.95)
  IN6 w0.102: v2(38.87,38.16) 37.98,37.27 37.98,29.09 39.33,27.74 39.33,16.58 37.75,15.01 37.75,13.77 v2(38.57,12.95)
AMP_I2S_BCLK_R: length 4.4
  TOP w0.102: v2(35.38,35.61) 34.59,35.61 v1(33.55,34.57)
  TOP w0.107: RA29.1 35.78,36.39 35.78,36.02 v2(35.38,35.61)
  BOTTOM w0.107: v2(35.38,35.61) 35.12,35.35 34.94,35.35 34.82,35.48 UA1.56
AMP_I2S_MCLK: length 336.7
  TOP w0.107: v2(38.87,37.56) 38.59,37.28 RA27.2 ; v2(39.32,13.39) 39.32,13.09 v1(39.06,12.83) 38.75,12.52 38.32,12.52 38.02,12.21 UA4.9 ; v2(326.45,18.16) JIO.14
  IN2 w0.102: v2(39.32,13.39) 39.94,12.76 42.56,12.76 44.8,15 54.59,15 55.67,13.92 83.17,13.92 84.8,15.56 96.66,15.56 99.59,18.49 126.36,18.49 127.97,20.1 169.39,20.1 169.84,20.55 179.64,20.55 182.84,17.35 185.33,17.35 186.55,16.14 190.72,16.14 192.2,14.66 192.2,13.99 191.75,13.55 191.75,12.09 193.2,10.64 199.96,10.64 201.45,12.13 207.39,12.13 208.1,11.42 209.88,11.42 210.59,12.13 216.3,12.13 217.14,12.98 239.94,12.98 240.68,13.72 251.7,13.72 252.92,14.94 263.97,14.94 265.03,16 279.1,16 279.49,15.61 282.97,15.61 292.19,15.61 292.91,14.89 293.18,14.62 294.01,14.62 294.62,14.01 297.72,14.01 297.88,14.16 299.83,14.16 299.97,14.3 303.17,14.3 304.51,12.96 308.06,12.96 310.4,15.29 312.88,15.29 316.85,19.27 320.18,19.27 321.23,18.22 323.41,18.22 324.27,17.36 325.66,17.36 v2(326.45,18.16)
  IN6 w0.102: v2(39.32,13.39) 40.34,14.42 40.34,29.53 40.73,29.91 40.73,33.04 41.23,33.54 41.23,34.41 39.28,36.37 39.28,37.15 v2(38.87,37.56)
AMP_I2S_MCLK_R: length 6.7
  TOP w0.102: v2(36.58,36.25) 36.58,36.19 35.43,35.03 v1(35.01,35.03)
  TOP w0.107: RA27.1 36.7,36.36 v2(36.58,36.25)
  BOTTOM w0.107: v2(36.58,36.25) 36.48,36.25 36.2,35.97 36.2,35.32 36.07,35.19 35.3,35.19 35.11,35 34.54,35 34.42,35.13 UA1.55
AMP_LDO_A1.5V: length 2.2
  BOTTOM w0.102: v1(37.16,14.67) 36.89,14.94 35.85,14.94 35.47,15.31 CA77.1
  vias: v2(33.98,16.06)
AUD_HP_OUT_L_CN: length 27.3
  TOP w0.102: v1(18.35,19.61) 18.07,19.89 v2(17.83,19.89)
  IN6 w0.254: v2(17.83,19.89) 16.86,19.89 16.52,19.55 16.52,7.04 15.58,6.1 JACK1.1
  BOTTOM w0.254: LA9.1 24.52,20.95 24.01,21.45 CA42.1 23.67,21.61 23.18,22.1 20.7,22.1 20.37,21.77 20.37,20.96 DA4.3 18.89,20.96 v2(17.83,19.89)
AUD_HP_OUT_R_CN: length 28.8
  TOP w0.254: v2(16.71,22.63) 16.46,22.38 v1(16.46,19.9) 16.46,17.76 17.76,16.45 18.54,16.45 v2(19.02,16.93)
  IN1 w0.254: v2(15.99,17.56) 14.72,17.56 13.97,16.81 9.53,16.81 8.32,15.6 JACK1.2
  BOTTOM w0.254: v2(19.02,16.93) CA43.1 20.11,17.51 20.37,17.77 DA4.2 20.04,19.36 17.24,19.36 15.99,18.11 v2(15.99,17.56) ; v2(16.71,22.63) 16.62,22.72 16.62,24.23 LA10.1
AUDIO_IRQ: length 3.6
  TOP w0.102: v1(35.35,32.5) 35.56,32.71 v2(36.84,32.71)
  TOP w0.107: v2(36.84,32.71) 37.38,33.26 RA24.2
  BOTTOM w0.107: UA1.6 36.18,32.91 36.38,32.71 v2(36.84,32.71)
B+: length 506.4
  TOP w0.508: 243.22,26.55 242.83,26.94 242.83,30 242.31,30.52 242.31,33 243.21,33.9 243.21,35.7 243.57,36.06 243.57,37.1 243.15,37.52 243.05,37.52 242.85,37.72 241.11,37.72 240.61,38.22 234.72,38.22 v2(234.39,37.89) ; v2(74.49,11.36) 74.3,11.17 PC10.1 73.73,11.74 73.81,11.81 PR12.1 73.81,14.52 72.06,16.27 70.8,16.27 70.44,15.91 PQ3.4
  TOP w1.016: 108.78,74.16 109.29,74.16 112.15,71.3 112.15,64.32 107.64,59.81 107.64,58.87 106.71,57.94 104.53,57.94 104.19,57.6 101.43,57.6 100.61,56.77
  TOP w1.524: 252.42,14.15 240.24,14.15 239.02,15.37 239.02,18.62 240.41,20.01 240.41,23.73 243.22,26.55 245.88,26.55 247.79,28.45 247.79,29.29 248.69,30.19 248.69,36.67 248.27,37.09 248.27,39.17 248.33,39.23
  TOP w2.54: 98.68,56.53 98.71,56.57 98.71,59.45 101.16,61.9 101.16,66.54 108.78,74.16
  TOP w3.556: 115.45,113.57 115.47,113.55 115.47,96.84 114.49,95.86 114.49,87.02 108.78,81.31 108.78,74.16 ; 115.45,123.05 115.47,123.07 115.47,126.78 117.67,128.98 129.5,128.98 133.16,132.64 135.26,132.64 137.99,135.37 137.99,137.91
  IN1 w3.048: 225.81,6.71 224.8,5.69 202.27,5.69 ; 106.31,20.95 117.36,20.95 119.77,18.53 131.26,18.53 137.11,24.37 151.2,24.37 157.04,18.53 168.63,18.53 174.41,12.75 180.86,12.75 181.37,12.24 181.7,12.1 182.41,11.63 183,11.04 183.47,10.33 183.61,10 184.11,9.5 184.11,7.67
  IN3 w3.048: 115.39,120.32 115.39,94.16 113.99,92.76 113.99,79.68 101.41,67.11 101.41,61.77 98.18,58.54 98.18,57.01
  BOTTOM w0.508: v2(102.52,23.99) 99.37,20.84 97.2,20.84 96.72,21.33 96.08,21.33 95.58,20.82 95.58,9.33 94.58,8.32 76.51,8.32 74.49,10.34 v2(74.49,11.36)
  BOTTOM w3.556: 115.52,119.05 115.52,85.78 106.56,76.83 106.56,72.13 102.5,68.06 102.5,62.6 101.16,61.27 ; 137.23,134.42 136.53,134.42 130.69,128.58 121.37,128.58
  vias: v2(55.64,35.42) v2(55.64,34.84) v2(55.64,34.24) v2(55.76,33.39) v2(55.86,36.44) v2(55.93,32.76) v2(56.24,36.88) v2(56.18,35.74) v2(56.18,35.11) v2(56.18,34.47) v2(56.18,33.84) v2(56.51,32.76) v2(56.74,37.2) v2(56.74,36.57) v2(56.74,35.93) v2(56.77,35.3) v2(56.77,34.66) v2(56.77,34.03) v2(56.77,33.39) v2(57.1,32.76) v2(57.35,34.66) v2(57.35,34.03) v2(57.35,33.39) v2(57.73,32.76) v2(57.98,34.66) v2(57.98,34.03) v2(57.98,33.39) v2(58.37,32.76) v2(58.62,34.66) v2(58.62,34.03) v2(58.62,33.39) v2(59.25,34.66) v2(59.25,34.03) v2(59.25,33.39) v2(87.96,33.39) v2(87.96,32.76) v2(87.96,32.12) v2(87.96,31.49) v2(87.96,30.85) v2(87.96,30.22) v2(88.59,32.76) v2(88.59,32.12) v2(88.59,31.49) v2(88.59,30.85) v2(88.59,30.22) v2(89.23,32.76) v2(89.23,32.12) v2(89.23,31.49) v2(89.23,30.85) v2(89.23,30.22) v2(94.62,52.85) v2(94.62,52.25) v2(95.26,53.46) v2(95.26,52.85) v2(95.26,52.25) v2(95.87,54.05) v2(95.87,53.46) v2(95.87,52.85) v2(95.87,52.25) v2(96.19,54.63) v2(96.47,54.05) v2(96.47,53.46) v2(96.47,52.85) v2(96.47,52.25) v2(96.78,54.63) v2(97.05,54) v2(97.48,54.56) v2(97.93,54.98) v2(102.88,23.49) v2(103.17,24.01) v2(103.5,23.52) v2(103.82,24.03) v2(104.13,23.52) v2(104.44,24.01) v2(104.66,24.63) v2(104.72,25.26) v2(104.76,23.52) v2(105.09,24.03) v2(105.23,24.95) v2(118.82,125.15) v2(118.82,124.51) v2(118.82,123.88) v2(119.4,125.15) v2(119.4,124.51) v2(119.4,123.88) v2(137.58,142.48) v2(137.58,141.9) v2(137.58,141.32) v2(137.58,140.73) v2(137.58,140.15) v2(138.16,142.48) v2(138.16,141.9) v2(138.16,141.32) v2(138.16,140.73) v2(138.16,140.15) v2(138.74,142.48) v2(138.74,141.9) v2(138.74,141.32) v2(138.74,140.73) v2(139.62,156.71) v2(139.62,156.12) v2(139.62,155.54) v2(140.2,156.71) v2(140.2,156.12) v2(140.2,155.54) v2(154.54,170.75) v2(154.54,170.17) v2(154.54,169.59) v2(155.13,170.75) v2(155.13,170.17) v2(155.13,169.59) v2(247.97,41.02) v2(248.52,40.83) v2(248.65,41.49) v2(252.97,12.75) v2(252.97,12.17) v2(253.55,12.75) v2(253.55,12.17) v2(254.14,12.75) v2(254.14,12.17) v3(83.19,43.87)
B+_1.0VS_VGAP: length 1.3
  BOTTOM w0.102: v1(243.51,40.2) 243.51,41.16 243.77,41.43
B+_+1.8VGS:
  vias: v1(232.72,40.21)
B+_BIAS: length 321.6
  TOP w0.508: R179.2 205.67,9.27 v2(206.07,8.88)
  IN2 w0.508: v2(274.96,8.18) 273.5,6.72 271.92,6.72 271.6,7.04 271.6,10.09 269.95,11.74 261.77,11.74 260.14,10.65 258.26,8.77 258.26,7.1 257.38,6.22 230.78,6.22 228.8,4.25 211.29,4.25 206.65,8.88 v2(206.07,8.88) 205.33,9.62 204.07,9.62 201.05,6.59 187.46,6.59 181.36,12.69 177.3,12.69 169.62,5.01 157.74,5.01 154.89,7.86 139.14,7.86 130.37,16.63 112.02,16.63 108.15,12.75 91.77,12.75 87.58,8.56 71.13,8.56 69.26,10.43 69.26,11.26
  IN2 w1.524: 29.6,7.23 29.6,7.67 30.4,8.47 31.46,8.47 31.56,8.37 36.08,8.37 ; 66,10.6 62.47,10.6 61.71,9.83 55.36,9.83 53.83,11.36 43.06,11.36 41.14,9.44
  IN3 w0.508: v2(324.65,11.66) 324.48,11.66 323.73,10.91 323.73,10.34 322.91,9.52 319.54,9.52 316.25,6.22 v2(289.76,6.22)
  IN4 w0.508: v2(289.76,6.22) 289.05,6.22 288.24,7.04 286.14,7.04 285.26,6.16 279.65,6.16 277.63,8.18 v2(274.96,8.18)
  vias: v2(27.38,4.31) v2(27.38,3.67) v2(27.89,3.99) v2(67.06,12.04) v2(67.69,12.04) v3(66.96,13.77)
B+_VCCIO:
  vias: v2(119.06,121.73)
BATDRV_CHG: length 30.7
  TOP w0.102: v2(78.3,29.26) 78.25,29.26 v1(77.67,28.68)
  TOP w0.203: PU700.18 57.44,21.16 v2(57.41,21.14)
  TOP w0.254: PR733.2 78.37,29.2 v2(78.3,29.26)
  IN3 w0.254: v2(57.41,21.14) 57.6,21.14 58.28,20.46 61.76,20.46 62.18,20.88 65.01,20.88 65.3,20.59 70.48,20.59 70.85,20.96 75.52,20.96 78.3,23.74 v2(78.3,29.26)
BATLOW#: length 9.4
  TOP w0.102: UT1.F2 176.37,169.34 176.33,169.29 176.27,169.29 176.09,169.11 175.75,169.11 175.75,169.11 175.6,169.11 175.56,169.07 175.56,169.07 175.19,168.7 174.11,168.7 174.01,168.6 173.75,168.6 173.4,168.25 173.4,167.81 173.11,167.52 173.11,165.19 172.82,164.9 v1(172.6,164.9) 171.52,164.9 171.36,164.75 171.36,164.7 RT31.2 RT14.1
