# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS#0: length 57.2
  IN6 w0.081: v2(114.07,58.66) 114.07,58.65 114.34,58.39 114.5,58.39 114.64,58.53 114.64,59.88 114.55,59.98 114.17,59.98 113.94,60.21 113.94,60.67 114.16,60.88 114.56,60.88 114.66,60.98 114.66,61.3 114.57,61.39 114.15,61.39 113.94,61.6 113.94,62.04 114.16,62.27 114.53,62.27 114.64,62.38 114.64,66.66 115.16,67.17 115.79,67.17 116.23,67.62 116.23,68.95 121.22,73.95 121.22,78.91 125.93,83.62 125.93,86.72 127.45,88.25 127.45,94.05 129.99,96.59 129.99,96.66 130.42,97.08 130.81,97.08 130.87,97.02 v2(131.14,97.02)
  BOTTOM w0.076: UC1.BR5 132.89,97.44 132.89,97.33 132.97,97.26 133.39,97.26 133.49,97.35 133.49,97.51 133.13,97.87 132.84,97.87 132.7,97.72 131.76,97.72 131.53,97.49 131.33,97.49 131.14,97.31 v2(131.14,97.02)
  BOTTOM w0.107: 114.2,58.43 114.07,58.56 v2(114.07,58.66) ; JDIMM1.11 114.19,60.77 114.32,60.64
  BOTTOM w0.114: 114.32,60.64 114.32,60.49 114.32,60.48 114.32,60.28 114.57,60.02 114.57,58.6 114.37,58.4 114.28,58.4 114.25,58.43 114.2,58.43
DDR_A_DQS#1: length 54.4
  IN6 w0.081: v2(119.19,57.39) 119.37,57.21 119.63,57.21 119.72,57.3 119.72,59.24 119.26,59.71 119.26,61.33 120.54,62.61 120.54,67.89 126.71,74.06 126.71,78.09 131.02,82.4 131.02,92.05 131.92,92.94 132.25,92.94 132.42,92.78 v2(132.72,92.78)
  BOTTOM w0.076: UC1.BL3 135.76,96.69 135.9,96.55 135.9,95.87 136.28,95.49 136.28,95.18 133.6,92.5 132.87,92.5 132.72,92.64 v2(132.72,92.78)
  BOTTOM w0.107: JDIMM1.32 119.44,54.53
  BOTTOM w0.114: 119.44,54.53 119.58,54.66 119.58,55.05 119.26,55.36 118.88,55.36 118.37,55.87 118.37,56.89 118.68,57.2 119.01,57.2 v2(119.19,57.39)
DDR_A_DQS#2: length 51.3
  IN6 w0.081: v2(124.69,58.66) 124.99,58.35 125.56,58.35 125.78,58.57 125.78,59.41 125.55,59.64 125.55,60.34 125.82,60.61 125.82,63.86 126.82,64.86 126.82,67.26 131.01,71.45 131.01,75.85 135.09,79.92 135.09,88.58 134.38,89.29 134.38,90.64 134.61,90.87 134.84,90.87 v2(135.08,91.11)
  BOTTOM w0.076: v2(135.08,91.11) 135.29,90.9 135.51,90.9 138.65,94.04 138.65,94.73 138.4,94.97 138.4,95.2 138.4,95.85 138.4,96.24 138.55,96.39 138.55,96.8 138.47,96.87 138.21,96.87 138.11,96.78 UC1.BG3
  BOTTOM w0.107: JDIMM1.53 124.69,60.77
  BOTTOM w0.114: v2(124.69,58.66) 124.87,58.47 125.13,58.47 125.3,58.64 125.3,59.45 124.85,59.9 124.85,60.62 124.69,60.77
DDR_A_DQS#3: length 50.1
  IN6 w0.081: v2(130.29,57.39) 131.3,57.39 131.51,57.6 131.51,59.99 132.04,60.52 132.04,65.3 134.98,68.25 134.98,73.68 139.52,78.22 139.52,87.9 139.18,88.24 139.18,91.54 139.35,91.71 139.35,91.73 139.56,91.95 139.57,91.95 139.72,92.1 v2(139.72,92.21)
  BOTTOM w0.076: v2(139.72,92.21) 139.8,92.13 140.75,92.13 141.04,92.43 141.04,93.78 140.92,93.9 140.92,95.2 140.92,95.85 140.92,96.39 UC1.BD3
  BOTTOM w0.107: JDIMM1.74 129.94,54.63
  BOTTOM w0.114: 129.94,54.63 130.08,54.77 130.08,54.93 129.49,55.52 129.49,56.8 129.83,57.13 130.03,57.13 v2(130.29,57.39)
DDR_A_DQS#4: length 49.1
  IN6 w0.081: v2(158.69,90.24) 158.53,90.4 158.33,90.4 158.15,90.22 158.15,89.85 158.15,89.78 161.41,86.53 161.41,68.76 157.81,65.15 157.81,62.64 157.99,62.46 158.12,62.46 158.36,62.22 158.36,61.78 158.1,61.52 157.89,61.52 157.74,61.37 157.74,61.08 157.85,60.97 158.22,60.97 158.44,60.75 158.44,60.3 158.22,60.08 157.98,60.08 157.44,59.55 157.44,58.46 157.58,58.32 157.71,58.32 158.09,58.7 v2(158.09,58.76)
  BOTTOM w0.076: UC1.AA3 158.69,96.41 158.69,96.15 158.69,95.5 158.69,92.94 159.39,92.24 159.39,91.51 158.59,90.71 158.59,90.34 v2(158.69,90.24)
  BOTTOM w0.107: 158.27,58.59 v2(158.09,58.76) ; JDIMM1.177 157.69,60.77
  BOTTOM w0.114: 158.27,58.59 158.33,58.59 158.5,58.75 158.5,59.57 158.45,59.62 158.45,59.8 157.93,60.32 157.93,60.54 157.69,60.77
DDR_A_DQS#5: length 49.6
  IN6 w0.081: v2(162.11,90.49) 161.88,90.49 161.74,90.35 161.74,90.23 165.66,86.32 165.66,67.48 163.16,64.98 163.16,61.09 162.95,60.87 162.95,60.2 163.13,60.02 163.4,60.02 163.69,59.74 163.69,59.31 163.51,59.13 163.22,59.13 163.06,58.97 163.06,58.36 162.72,58.02 162.72,57.42 162.87,57.27 163.27,57.27 v2(163.51,57.51)
  BOTTOM w0.076: UC1.U3 161.2,96.41 161.2,96.15 161.2,95.5 161.2,94.44 162.31,93.33 162.31,90.92 162.11,90.71 v2(162.11,90.49)
  BOTTOM w0.107: JDIMM1.198 162.94,54.63 ; 163.27,57.27 v2(163.51,57.51)
  BOTTOM w0.114: 162.94,54.63 163.08,54.76 163.08,55.05 162.71,55.41 162.71,57 162.97,57.26 163.26,57.26 163.27,57.27
DDR_A_DQS#6: length 49.8
  IN6 w0.081: v2(165.58,90.83) 165.58,91.01 165.75,91.18 165.85,91.18 167.92,89.11 167.92,88.83 168.97,87.78 168.99,87.78 169.58,87.19 169.58,65.62 167.9,63.94 167.9,60.06 168.11,59.85 168.31,59.85 168.43,59.73 168.43,59.44 168.31,59.32 167.95,59.32 167.73,59.1 167.73,58.63 168.02,58.34 168.81,58.34 168.81,58.34 168.82,58.34 v2(169.02,58.14)
  BOTTOM w0.076: v2(165.58,90.83) 165.58,90.95 166.32,91.68 166.32,92.39 163.71,94.99 163.71,95.27 163.71,95.27 163.71,95.5 163.71,95.5 163.71,95.92 163.71,95.92 163.71,96.15 163.71,96.15 163.71,96.41 UC1.P3
  BOTTOM w0.114: JDIMM1.219 168.19,60.85 168.35,60.7 168.35,59.95 167.85,59.46 167.85,58.61 168.11,58.35 168.81,58.35 v2(169.02,58.14)
DDR_A_DQS#7: length 50
  IN6 w0.081: v2(167.41,94.61) 167.74,94.61 167.91,94.78 169.11,94.78 174.17,89.72 174.17,57.36 174.33,57.2 174.5,57.2 v2(174.74,57.45)
  BOTTOM w0.076: UC1.L3 166.23,96.41 166.23,96.15 166.23,95.5 166.23,95.07 166.91,94.39 167.3,94.39 167.41,94.5 v2(167.41,94.61)
  BOTTOM w0.107: 173.58,54.76 173.44,54.62 JDIMM1.240
  BOTTOM w0.114: v2(174.74,57.45) 174.52,57.23 174.16,57.23 173.82,56.88 173.82,55.72 173.63,55.53 173.63,54.8 173.58,54.76
DDR_A_MA0: length 48
  IN6 w0.089: 152.65,85.65 152.65,86.37 152.41,86.6 152.41,87.37 152.04,87.74 152.04,90.02 151.77,90.29 151.77,90.8 152.01,91.03 v2(152.31,91.03)
  IN6 w0.13: v2(148.86,57.25) 147.74,58.37 147.74,60.98 147.88,61.12 147.88,67.97 152.65,72.73 152.65,85.65
  BOTTOM w0.076: UC1.AH3 153.48,96.41 153.48,96.15 153.48,96.15 153.48,95.27 153.48,95.27 153.48,91.36 153.15,91.03 v2(152.31,91.03)
  BOTTOM w0.185: JDIMM1.144 147.44,55.84 v2(148.86,57.25)
DDR_A_MA1: length 47.8
  IN6 w0.13: v2(147.3,92.71) 148.83,91.17 148.83,87.64 148.94,87.53 148.94,73.37 144.79,69.22 144.79,64.43 144.91,64.3 144.91,62.72 144.04,61.85 144.04,61.66 143.91,61.53 143.71,61.53 143.58,61.4 143.58,61.14 143.71,61.01 143.91,61.01 144.04,60.88 144.04,60.62 143.91,60.49 143.71,60.49 143.58,60.36 143.58,60.1 143.71,59.97 143.91,59.97 144.04,59.84 v2(144.04,59.67)
  BOTTOM w0.076: v2(147.3,92.71) 147.85,93.26 147.85,95.01 147.73,95.14 147.73,95.2 147.73,95.71 147.73,96 147.88,96.15 147.88,97.04 UC1.AP4
  BOTTOM w0.185: JDIMM1.133 144.69,60.73 145.06,60.36 145.06,58.53 144.88,58.35 144.66,58.35 144.53,58.47 144.53,59.48 144.35,59.67 v2(144.04,59.67)
DDR_A_MA2: length 48
  IN6 w0.13: v2(149.4,97.01) 148.92,96.52 148.92,93.53 149.74,92.7 149.74,87.81 149.86,87.69 149.86,82.05 150.38,81.53 150.38,73.52 145.7,68.84 145.7,64.81 145.83,64.68 145.83,62.33 144.96,61.47 144.96,58.04 v2(145.62,57.38)
  BOTTOM w0.076: UC1.AN4 149.08,97.34 v2(149.4,97.01)
  BOTTOM w0.185: v2(145.62,57.38) 144.67,56.44 144.67,55.25 144.44,55.03 JDIMM1.132
DDR_A_MA3: length 47.6
  IN6 w0.13: v2(144.04,58.4) 144.5,58.86 144.5,61.66 145.37,62.52 145.37,64.49 145.25,64.62 145.25,69.03 149.92,73.7 149.92,81.34 149.4,81.86 149.4,87.52 149.36,87.56 149.36,91.27 v2(147.3,93.34)
  BOTTOM w0.076: v2(147.3,93.34) 147.67,93.72 147.67,94.22 147.56,94.34 147.56,95.13 147.56,95.27 147.56,95.64 147.56,95.64 147.56,95.92 147.56,96.14 147.62,96.21 147.62,97.44 UC1.AP5
  BOTTOM w0.185: v2(144.04,58.4) 143.47,58.98 143.47,59.77 144.19,60.5 JDIMM1.131
DDR_A_MA4: length 47.1
  IN6 w0.13: v2(147.3,91.31) 146.9,90.92 146.9,89.88 147.92,88.86 147.92,87.66 148.02,87.56 148.02,73.75 143.87,69.6 143.87,64.78 143.49,64.4 143.49,62.6 142.65,61.76 142.65,56.55 143.29,55.91 v2(144.05,55.91)
  BOTTOM w0.076: UC1.AP2 147.89,95.76 147.89,95.27 148.05,95.11 148.05,92.99 147.72,92.66 147.72,91.74 v2(147.3,91.31)
  BOTTOM w0.185: v2(144.05,55.91) 143.44,55.3 JDIMM1.128
DDR_A_MA5: length 46.6
  IN6 w0.13: v2(144.05,57.13) 143.24,57.13 143.11,57.26 143.11,61.56 143.95,62.41 143.95,64.21 144.33,64.59 144.33,69.41 148.48,73.56 148.48,87.48 148.38,87.59 148.38,89.63 v2(147.33,90.68)
  BOTTOM w0.076: v2(147.33,90.68) 147.38,90.68 147.97,91.27 147.97,92.45 148.26,92.74 148.26,95.3 UC1.AP1
  BOTTOM w0.185: JDIMM1.126 142.94,56.64 143.43,57.13 v2(144.05,57.13)
DDR_A_MA6: length 48.4
  IN6 w0.13: v2(141.72,58.32) 142.19,58.79 142.19,61.95 143.03,62.79 143.03,64.59 143.42,64.97 143.42,65.38 143.26,65.53 143.09,65.53 142.94,65.68 142.94,65.99 143.09,66.14 143.26,66.14 143.42,66.29 143.42,69.79 147.56,73.94 147.56,87.51 147.47,87.61 147.47,88.62 v2(146.16,89.93)
  BOTTOM w0.076: v2(146.16,89.93) 146.4,89.69 147.44,89.69 148.28,90.53 148.28,92.25 148.49,92.46 148.49,95.06 148.45,95.09 148.45,95.27 148.45,95.92 148.45,96.41 UC1.AP3
  BOTTOM w0.185: JDIMM1.127 143.19,60.4 142.95,60.15 142.95,59.23 142.03,58.32 v2(141.72,58.32)
DDR_A_MA7: length 49
  IN6 w0.13: v2(146.16,88.02) 146.42,88.02 146.64,87.8 146.64,75.34 143.06,71.75 143.06,71.53 143.33,71.25 143.33,71.03 143.11,70.82 142.9,70.82 142.62,71.09 142.4,71.09 142.02,70.72 142.02,70.41 142.15,70.29 142.35,70.29 142.5,70.13 142.5,69.83 142.38,69.7 142.19,69.7 142.02,69.54 142.02,64.92 141.27,64.17 141.27,63.95 141.43,63.79 141.59,63.79 141.74,63.64 141.74,63.33 141.59,63.18 141.41,63.18 141.26,63.03 141.26,57.13 141.42,56.97 v2(141.72,56.97)
  BOTTOM w0.076: v2(146.16,88.02) 146.68,88.02 148.91,90.25 UC1.AN1
  BOTTOM w0.185: JDIMM1.122 141.94,54.87 142.26,55.19 142.26,56.78 142.07,56.97 v2(141.72,56.97)
DDR_A_MA8: length 49.2
  IN6 w0.13: v2(141.73,59.68) 141.73,62.13 142.57,62.97 142.57,64.6 142.48,64.7 142.48,66.43 142.63,66.58 142.81,66.58 142.96,66.74 142.96,67.04 142.81,67.19 142.63,67.19 142.48,67.35 142.48,67.65 142.63,67.8 142.81,67.8 142.96,67.95 142.96,68.26 142.81,68.41 142.63,68.41 142.48,68.56 142.48,68.93 142.63,69.08 142.81,69.08 142.96,69.23 142.96,70.01 144.09,71.14 144.09,71.36 143.82,71.63 143.82,71.86 144.13,72.18 144.35,72.18 144.61,71.91 144.83,71.91 145.05,72.13 145.05,72.35 144.79,72.61 144.79,72.83 145.01,73.05 145.23,73.05 145.52,72.76 145.74,72.76 145.96,72.98 145.96,73.2 145.66,73.49 145.66,73.71 145.88,73.93 146.1,73.93 146.4,73.63 146.61,73.63 146.84,73.86 146.84,74.07 146.54,74.37 146.54,74.59 147.1,75.15 147.1,88.36 146.8,88.66 v2(146.16,88.66)
  BOTTOM w0.076: v2(146.16,88.66) 146.87,88.66 148.69,90.48 148.69,95.09 148.63,95.15 148.63,95.27 148.63,95.92 148.63,96.41 UC1.AN3
  BOTTOM w0.185: JDIMM1.125 142.69,60.64 142.44,60.39 142.44,59.87 142.25,59.68 v2(141.73,59.68)
DDR_A_MA9: length 46.7
  IN6 w0.13: v2(146.84,97.01) 145.72,95.9 145.72,75.72 141.1,71.1 141.1,65.3 140.34,64.54 140.34,58.68 v2(139.85,58.19)
  BOTTOM w0.076: v2(146.84,97.01) 146.51,97.34 UC1.AT4
  BOTTOM w0.185: v2(139.85,58.19) 141.23,59.57 141.23,59.62 141.28,59.67 141.28,60.29 141.69,60.7 JDIMM1.121
DDR_A_MA10: length 47.5
  IN6 w0.089: v2(152.31,92.87) 152.68,92.87 153.12,92.44 153.12,87.67 154.22,86.57 154.22,85.65
  IN6 w0.13: 154.22,85.65 154.22,72.08 150.46,68.32 150.46,64.98 149.47,63.98 149.47,56.34 v2(148.86,55.73)
  BOTTOM w0.076: v2(152.31,92.87) 152.91,93.47 152.91,95.74 UC1.AH2
  BOTTOM w0.185: JDIMM1.146 149.94,55.87 149.76,56.05 149.18,56.05 v2(148.86,55.73)
DDR_A_MA11: length 50.3
  IN6 w0.13: v2(146.16,86.75) 146.18,86.73 146.18,75.53 141.56,70.91 141.56,65.11 140.8,64.35 140.8,54.93 140.93,54.8 142.35,54.8 142.5,54.96 142.5,55.62 142.35,55.78 v2(141.73,55.78)
  BOTTOM w0.076: v2(146.16,86.75) 149.2,89.79 149.2,95.75 UC1.AN2
  BOTTOM w0.185: JDIMM1.120 141.44,55.49 v2(141.73,55.78)
DDR_A_MA12: length 47.5
  IN6 w0.13: v2(144.46,94.37) 145.15,94.37 145.42,94.1 145.42,87.81 145.26,87.65 145.26,75.91 140.64,71.29 140.64,65.49 140.09,64.93 139.79,64.93 139.45,64.59 139.45,62.69 139.6,62.53 139.73,62.53 139.88,62.38 139.88,62.07 139.73,61.91 139.6,61.91 139.45,61.76 139.45,61.45 139.6,61.29 139.73,61.29 139.88,61.14 139.88,60.83 139.73,60.67 139.6,60.67 139.45,60.52 139.45,59.7 139.6,59.54 v2(139.85,59.54)
  BOTTOM w0.076: v2(144.46,94.37) 144.46,94.25 144.75,93.97 144.98,93.97 145.21,94.2 145.21,95.06 145.21,95.06 145.21,95.2 145.21,95.2 145.21,95.2 145.21,95.57 145.21,95.57 145.21,95.71 145.21,95.71 145.21,95.85 ; 145.21,95.85 145.21,95.85 145.21,95.85 ; 145.21,95.85 145.21,96.22 145.21,96.22 145.21,96.36 145.21,96.87 145.21,97.12 145.42,97.34 UC1.AU4
  BOTTOM w0.185: v2(139.85,59.54) 140.02,59.37 140.28,59.37 140.79,59.88 140.79,60.45 141.19,60.85 JDIMM1.119
DDR_A_MA13: length 51.4
  IN6 w0.13: v2(153.45,54.91) 153.9,54.91 154.05,55.07 154.05,55.59 154.21,55.74 154.52,55.74 154.67,55.59 154.67,55.07 154.83,54.91 155.3,54.91 155.46,55.07 155.46,56.51 154.71,57.25 154.71,60.63 154.87,60.79 154.87,65.53 159.1,69.75 159.1,86.14 155.71,89.53 155.71,91.37 155.41,91.66 v2(154.82,91.66)
  BOTTOM w0.076: UC1.AE3 155.99,96.41 155.99,96.15 155.99,95.5 155.99,92.83 v2(154.82,91.66)
  BOTTOM w0.185: JDIMM1.158 152.94,54.44 153.41,54.91 v2(153.45,54.91)
DDR_A_MA14_WE#: length 50.5
  IN6 w0.089: 155.59,85.65 155.59,86.34 153.65,88.28 153.65,96.21 v2(154.38,96.94)
  IN6 w0.13: v2(150.91,60.04) 151.22,60.04 151.38,60.2 151.38,60.49 151.22,60.64 151,60.64 150.84,60.8 150.84,61.11 151,61.26 151.22,61.26 151.38,61.42 151.38,61.7 151.22,61.85 151,61.85 150.84,62.01 150.84,62.32 151,62.47 151.22,62.47 151.38,62.63 151.38,63.95 151.84,64.41 151.84,66.67 152.09,66.92 152.09,67.15 151.84,67.4 151.84,67.62 152.06,67.84 152.28,67.84 152.54,67.58 152.75,67.58 152.97,67.8 152.97,68.02 152.65,68.34 152.65,68.56 152.85,68.76 153.11,68.76 153.41,68.46 153.63,68.46 153.85,68.68 153.85,68.9 153.53,69.22 153.53,69.44 153.74,69.65 153.98,69.65 154.29,69.34 154.51,69.34 154.73,69.56 154.73,69.77 154.41,70.1 154.41,70.31 154.63,70.53 154.85,70.53 155.16,70.22 155.39,70.22 155.59,70.43 155.59,85.65
  BOTTOM w0.076: UC1.AG4 153.56,97.34 153.49,97.26 153.49,97.04 153.56,96.97 154.05,96.97 154.08,96.94 v2(154.38,96.94)
  BOTTOM w0.185: JDIMM1.151 151.19,61.02 151.61,60.61 151.61,60.51 151.6,60.5 151.6,59.95 151.45,59.81 151.34,59.81 151.31,59.78 151.18,59.78 v2(150.91,60.04)
DDR_A_MA15_CAS#: length 51.5
  IN6 w0.13: v2(153.5,56.49) 154.1,56.49 154.25,56.64 154.25,56.92 154.1,57.08 154.01,57.08 153.85,57.23 153.85,57.54 154.01,57.7 154.1,57.7 154.25,57.85 154.25,58.16 154.1,58.32 154.04,58.32 153.88,58.47 153.88,58.78 154.04,58.94 154.1,58.94 154.25,59.09 154.25,59.4 154.1,59.56 154.05,59.56 153.9,59.71 153.9,61.03 154.41,61.55 154.41,65.71 158.64,69.94 158.64,86.05 155.57,89.12 v2(154.82,89.12)
  BOTTOM w0.076: v2(154.82,89.12) 154.36,89.12 154.19,88.95 154.19,88.57 154.38,88.38 155.27,88.38 156.73,89.84 156.73,95.11 UC1.AD1
  BOTTOM w0.185: JDIMM1.156 152.44,55.43 v2(153.5,56.49)
DDR_A_MA16_RAS#: length 48.9
  IN6 w0.089: v2(154.38,97.54) 153.47,96.63 153.47,88.08 155.14,86.42 155.14,85.65
  IN6 w0.13: 155.14,85.65 155.14,71.69 151.38,67.94 151.38,64.6 150.92,64.14 150.92,63.77 150.38,63.24 150.38,57.52 v2(150.91,57)
  BOTTOM w0.076: v2(154.38,97.54) 154.27,97.65 153.51,97.65 UC1.AH4
  BOTTOM w0.185: v2(150.91,57) 151.66,56.25 151.66,55.25 151.44,55.04 JDIMM1.152
DDR_A_ODT0: length 50.9
  IN6 w0.089: v2(154.82,90.39) 154.61,90.39 154.44,90.22 154.44,89 155.12,88.32 155.71,88.32 158.08,85.95 158.08,85.65
  IN6 w0.13: v2(152.85,57.25) 153.32,57.72 153.32,61.25 153.85,61.78 153.85,65.94 158.08,70.17 158.08,85.65
  BOTTOM w0.076: UC1.AD3 156.17,96.41 156.17,96.15 156.17,96.15 156.17,95.92 156.17,95.92 156.17,95.5 156.17,95.5 156.17,95.27 156.17,95.27 156.17,95.17 156.37,94.97 156.37,91.94 v2(154.82,90.39)
  BOTTOM w0.185: JDIMM1.155 152.19,59.47 151.94,59.21 151.59,59.21 151.41,59.04 151.41,58.65 151.59,58.47 152.22,58.47 152.34,58.35 152.34,57.34 152.52,57.17 152.77,57.17 v2(152.85,57.25)
DDR_A_ODT1: length 51.1
  IN6 w0.089: 156.61,85.65 156.61,85.96 154.03,88.54 154.03,93.41 v2(154.82,94.2)
  IN6 w0.13: 156.61,85.65 156.61,72.74 156.76,72.59 157.01,72.59 157.16,72.43 157.16,72.13 157.01,71.98 156.76,71.98 156.61,71.82 156.61,71.52 156.76,71.37 157.01,71.37 157.16,71.21 157.16,70.91 157.01,70.76 156.76,70.76 156.61,70.6 156.61,69.99 152.86,66.25 152.86,63.99 152.4,63.52 152.4,59.42 151.93,58.95 151.93,58.76 152.31,58.39 152.49,58.39 v2(152.88,58.77)
  BOTTOM w0.076: UC1.AE4 155.61,97.34 155.26,96.98 155.26,94.77 154.82,94.34 v2(154.82,94.2)
  BOTTOM w0.185: JDIMM1.161 153.69,60.68 154.06,60.32 154.06,57.95 153.89,57.78 153.6,57.78 153.42,57.95 153.42,58.6 153.25,58.77 v2(152.88,58.77)
DDR_A_PAR: length 50
  IN6 w0.089: 153.2,85.65 153.2,86.42 152.76,86.86 152.76,90.25 152.6,90.41 v2(152.29,90.41)
  IN6 w0.13: v2(148.86,58.77) 148.3,59.33 148.3,60.59 148.44,60.73 148.44,67.74 153.2,72.5 153.2,85.65
  BOTTOM w0.076: v2(152.29,90.41) 151.9,90.41 151.65,90.16 151.65,89.46 151.84,89.27 152.6,89.27 153.64,90.32 153.64,95.2 153.64,95.44 153.64,96.22 153.64,96.39 UC1.AG3
  BOTTOM w0.185: JDIMM1.143 147.19,58.67 147.52,58.35 148.43,58.35 v2(148.86,58.77)
DDR_B_ACT#: length 67.1
  IN1 w0.089: v2(146.09,100.27) 145.34,99.52 145.34,93.05 143.9,91.61 143.9,88.26 141.91,86.26 141.91,85.65
  IN1 w0.13: 141.91,85.65 141.91,83.33 136.29,77.72 136.29,64.84 136.08,64.63 136.08,61.78 135.49,61.19 135.49,53.01 135.07,52.59 135.07,45.79 v2(136.66,44.2)
  BOTTOM w0.076: v2(146.09,100.27) UC1.AT9
  BOTTOM w0.185: JDIMM2.114 139.94,41.68 137.42,44.2 v2(136.66,44.2)
DDR_B_ALERT#: length 65
  IN1 w0.089: 144.18,85.65 144.18,86.94 145.04,87.81 145.04,89.66 146.31,90.93 146.31,93.59 147.47,94.75 147.47,98.85 147.57,98.95 147.73,99.11 147.73,100.08 v2(147.92,100.27)
  IN1 w0.13: v2(139.72,44.1) 138.68,45.14 138.68,47.99 138.15,48.52 138.15,60.43 138.66,60.94 138.66,76.88 144.18,82.4 144.18,85.65
  BOTTOM w0.076: v2(147.92,100.27) UC1.AR8
  BOTTOM w0.185: JDIMM2.116 140.44,42.24 140.45,42.24 140.45,42.61 140.44,42.62 140.44,43.38 v2(139.72,44.1)
DDR_B_BA0: length 67.7
  IN1 w0.089: 155.24,85.65 155.24,87.45 154.07,88.62 154.07,95.52 153.66,95.93 153.66,99.34 153.81,99.48 153.81,99.87 v2(153.41,100.27)
  IN1 w0.13: v2(150.99,42.93) 150.62,43.3 149.52,43.3 149.37,43.45 149.37,43.75 149.52,43.9 149.9,43.9 150.05,44.06 150.05,44.37 149.9,44.52 149.52,44.52 149.37,44.68 149.37,47.93 149.28,48.02 149.28,51.18 149.43,51.33 149.8,51.33 149.96,51.49 149.96,51.8 149.8,51.95 149.43,51.95 149.28,52.11 149.28,52.54 149.43,52.7 150.15,52.7 150.3,52.85 150.3,61.06 149.71,61.65 149.71,70.57 155.24,76.1 155.24,85.65
  BOTTOM w0.076: v2(153.41,100.27) UC1.AH8
  BOTTOM w0.185: JDIMM2.150 150.94,42.88 v2(150.99,42.93)
DDR_B_BA1: length 69.5
  IN1 w0.089: 154.32,85.65 154.32,87.3 153.68,87.94 153.68,95.41 153.31,95.78 153.31,98.53 153.04,98.79 153.04,100.13 152.93,100.24 v2(152.49,100.24)
  IN1 w0.13: 154.32,85.65 154.32,78.19 154.17,78.03 153.89,78.03 153.74,77.88 153.74,77.57 153.89,77.41 154.17,77.41 154.32,77.26 154.32,76.48 154.06,76.22 153.88,76.22 153.6,76.5 153.42,76.5 153.23,76.32 153.23,76.13 153.51,75.86 153.51,75.67 153.33,75.49 153.15,75.49 152.87,75.77 152.68,75.77 152.5,75.58 152.5,75.4 152.78,75.12 152.78,74.94 150,72.16 149.78,72.16 149.25,72.69 149.03,72.69 148.77,72.43 148.77,72.21 149.3,71.68 149.3,71.49 148.71,70.9 148.71,61.22 149.29,60.64 149.29,53.99 148.36,53.06 148.36,47.61 v2(148.47,47.5)
  BOTTOM w0.076: UC1.AH9 152.85,100.6 v2(152.49,100.24)
  BOTTOM w0.185: JDIMM2.145 149.69,47.94 149.52,47.76 149.03,47.76 148.85,47.94 148.85,49.79 148.67,49.97 148.18,49.97 148,49.79 148,47.65 148.15,47.5 v2(148.47,47.5)
DDR_B_BG0: length 62.9
  IN1 w0.089: v2(147.02,100.28) 147.25,100.28 147.46,100.06 147.46,99.1 147.39,99.03 147.29,98.93 147.29,94.87 145.99,93.57 145.99,90.85 144.79,89.65 144.79,88.15 143.39,86.75 143.39,85.65
  IN1 w0.13: 143.39,85.65 143.39,82.72 137.77,77.1 137.77,64.22 137.56,64.02 137.56,61.16 136.97,60.58 136.97,47.88 v2(138.12,46.74)
  BOTTOM w0.076: UC1.AR9 147.34,100.6 v2(147.02,100.28)
  BOTTOM w0.185: v2(138.12,46.74) 138.85,46.74 138.93,46.81 139.07,46.81 140.19,47.94 JDIMM2.115
DDR_B_BG1: length 65.5
  IN1 w0.089: v2(146.88,98.91) 145.81,97.84 145.81,91.06 144.53,89.78 144.53,88.15 142.93,86.54 142.93,85.65
  IN1 w0.13: 142.93,85.65 142.93,82.91 137.31,77.29 137.31,64.42 137.1,64.21 137.1,61.35 136.51,60.77 136.51,47.7 137.08,47.13 137.08,45.33 137.21,45.2 137.86,45.2 v2(138.13,45.47)
  BOTTOM w0.076: v2(146.88,98.91) 147.27,99.3 UC1.AR7
  BOTTOM w0.185: JDIMM2.113 139.69,48.16 138.85,47.31 137.71,47.31 137.42,47.02 137.42,46.18 v2(138.13,45.47)
DDR_B_CKE0: length 69.1
  IN1 w0.089: v2(147.01,99.66) 146.74,99.66 145.62,98.54 145.62,91.21 144.28,89.86 144.28,88.14 142.37,86.23 142.37,85.65
  IN1 w0.13: v2(136.66,45.47) 136.41,45.47 136.28,45.6 136.28,45.9 136.09,46.09 135.66,46.09 135.53,46.22 135.53,46.52 135.66,46.64 136.15,46.64 136.28,46.77 136.28,47.03 136.15,47.16 135.66,47.16 135.53,47.29 135.53,47.55 135.68,47.71 135.8,47.71 135.95,47.86 135.95,48.17 135.8,48.33 135.68,48.33 135.53,48.48 135.53,48.79 135.68,48.95 135.8,48.95 135.95,49.1 135.95,49.41 135.8,49.57 135.68,49.57 135.53,49.72 135.53,52.4 135.95,52.82 135.95,61 136.54,61.59 136.54,64.44 136.75,64.65 136.75,77.52 142.37,83.14 142.37,85.65
  BOTTOM w0.076: v2(147.01,99.66) 146.72,99.95 UC1.AT8
  BOTTOM w0.185: JDIMM2.109 138.69,48.11 138.49,47.9 136.51,47.9 135.97,47.36 135.97,45.65 136.14,45.47 v2(136.66,45.47)
DDR_B_CKE1: length 67.9
  IN1 w0.089: 141.45,85.65 141.45,86.25 143.65,88.45 143.65,91.61 145.16,93.12 145.16,100.05 v2(146.07,100.95)
  IN1 w0.13: v2(136.66,42.93) 134.61,44.98 134.61,52.78 135.03,53.2 135.03,61.38 135.62,61.97 135.62,64.82 135.84,65.04 135.84,77.91 141.45,83.52 141.45,85.65
  BOTTOM w0.076: v2(146.07,100.95) 146.36,101.25 UC1.AT10
  BOTTOM w0.185: JDIMM2.110 138.94,41.69 137.7,42.93 v2(136.66,42.93)
DDR_B_CLK0: length 65.2
  IN1 w0.081: v2(149.75,100.28) 150.14,99.89 150.14,99.39 150.79,98.74 151.16,98.74 151.47,98.44 151.66,98.44 152.2,97.9 152.2,97.35 151.93,97.08 151.72,97.08 151.03,96.4 151.03,95.11 151.62,94.52 151.62,90.12 151.78,89.95 151.78,79.71 151.77,79.7 146.2,74.12 146.2,54.47 145.04,53.31 145.04,46.1 145.25,45.89 145.33,45.89 v2(145.62,45.6)
  BOTTOM w0.076: UC1.AM9 150.07,100.6 v2(149.75,100.28)
  BOTTOM w0.107: JDIMM2.137 145.69,48.09 ; 145.44,45.78 v2(145.62,45.6)
  BOTTOM w0.114: 145.44,45.78 145.42,45.78 145.41,45.78 145.15,45.78 144.79,46.14 144.79,47.01 145.32,47.54 145.7,47.54 145.81,47.65 145.81,47.97 145.69,48.09
DDR_B_CLK1: length 66.9
  IN1 w0.081: v2(150.66,99.62) 150.84,99.8 150.95,99.8 151.1,99.66 151.1,99.39 151.41,99.07 151.79,99.07 152.57,98.29 152.57,95.17 152.85,94.89 152.85,88.79 152.47,88.41 152.47,79.41 146.9,73.83 146.9,54.2 146.06,53.37 146.06,44 146.4,43.67 147.02,43.67 147.13,43.56 147.13,43.06 147.05,42.98 145.7,42.98 v2(145.62,43.06)
  BOTTOM w0.076: UC1.AM7 v2(150.66,99.62)
  BOTTOM w0.107: JDIMM2.138 145.94,41.66
  BOTTOM w0.114: v2(145.62,43.06) 145.19,42.62 145.19,42.26 145.48,41.96 145.9,41.96 145.99,41.88 145.99,41.7 145.94,41.66
DDR_B_CLK#0: length 65.2
  IN1 w0.081: v2(145.62,46.23) 145.44,46.05 145.32,46.05 145.2,46.17 145.2,53.24 146.35,54.4 146.35,74.06 151.94,79.65 151.94,90.02 151.78,90.18 151.78,94.59 151.19,95.17 151.19,96.34 151.78,96.93 152,96.93 152.36,97.28 152.36,97.96 151.73,98.59 151.53,98.59 151.22,98.9 150.85,98.9 150.3,99.45 150.3,99.95 150.11,100.14 150.11,100.43 149.75,100.79 v2(149.75,100.91)
  BOTTOM w0.076: UC1.AN9 149.39,100.6 149.4,100.6 149.43,100.6 v2(149.75,100.91)
  BOTTOM w0.107: JDIMM2.139 146.2,48.06
  BOTTOM w0.114: v2(145.62,46.23) 145.41,46.03 145.25,46.03 145.04,46.24 145.04,46.91 145.42,47.3 145.81,47.3 146.06,47.55 146.06,47.92 146.2,48.06
DDR_B_CLK#1: length 66.8
  IN1 w0.081: v2(150.66,100.27) 150.66,100.09 150.79,99.96 151.02,99.96 151.26,99.72 151.26,99.45 151.48,99.23 151.85,99.23 152.72,98.36 152.72,95.24 153.01,94.95 153.01,88.73 152.63,88.35 152.63,79.34 147.06,73.77 147.06,54.14 146.22,53.3 146.22,44.07 146.46,43.83 147.09,43.83 147.29,43.63 147.29,43 147.11,42.82 145.94,42.82 145.78,42.66 145.78,42.66 145.62,42.5 v2(145.62,42.42)
  BOTTOM w0.076: UC1.AM8 v2(150.66,100.27)
  BOTTOM w0.114: JDIMM2.140 146.44,41.77 146,42.22 145.82,42.22 v2(145.62,42.42)
DDR_B_CS#0: length 70.9
  IN1 w0.089: 156.72,85.65 156.72,87.82 155.51,89.02 155.51,95.4 154.76,96.15 154.76,98.13 154.76,99.05 154.44,99.38 154.44,100.55 154.7,100.81 154.7,101.03 v2(155.22,101.54)
  IN1 w0.13: 156.72,85.65 156.72,75.47 151.19,69.94 151.19,64.09 151.81,63.47 151.81,61.63 152.36,61.08 152.36,54.8 152.49,54.67 153.04,54.67 153.17,54.54 153.17,54.31 153.02,54.15 152.49,54.15 152.36,54.02 152.36,53.54 151.78,52.95 151.78,51.22 151.17,50.6 151.17,47.55 v2(150.99,47.37)
  BOTTOM w0.076: v2(155.22,101.54) 155.22,101.95 155.14,102.03 154.91,102.03 UC1.AF11
  BOTTOM w0.185: v2(150.99,47.37) 150.64,47.37 149.93,46.66 149.93,44.31 149.75,44.12 149.42,44.12 149.23,44.32 149.23,46.79 150.34,47.9 150.35,47.9 150.57,48.12 150.57,48.13 150.69,48.25 JDIMM2.149
DDR_B_CS#1: length 68.1
  IN1 w0.089: v2(156.09,98.95) 155.72,98.58 155.72,97.07 156.6,96.19 156.6,90.41 158.76,88.25 158.76,85.65
  IN1 w0.13: 158.76,85.65 158.76,74.62 155.27,71.13 155.27,70.48 155.14,70.35 154.51,70.35 154.38,70.22 154.38,69.95 154.53,69.8 155.13,69.8 155.29,69.65 155.29,69.34 155.13,69.18 154.6,69.18 154.38,68.96 154.38,68.71 154.53,68.56 155.13,68.56 155.29,68.41 155.29,68.1 155.13,67.94 154.6,67.94 154.38,67.72 154.38,67.47 154.53,67.32 155.13,67.32 155.29,67.17 155.29,66.86 155.13,66.7 154.6,66.7 154.38,66.48 154.38,62.9 155.42,61.86 155.42,53.7 154.2,52.48 154.2,50.66 154.2,50.66 154.2,50.17 154,49.98 154,49.79 154.27,49.53 154.27,49.14 154.17,49.04 153.91,49.04 153.65,49.3 153.46,49.3 153.33,49.17 153.33,45.93 153.2,45.8 153.02,45.8 v2(152.85,45.97)
  BOTTOM w0.076: v2(156.09,98.95) 156.04,98.95 UC1.AE7
  BOTTOM w0.185: JDIMM2.157 152.69,48.23 153.36,47.57 153.36,46.08 153.18,45.9 152.92,45.9 v2(152.85,45.97)
DDR_B_D0: length 73.2
  IN1 w0.081: v2(130.45,101.74) 130.44,101.75 130.17,101.75 129.74,101.32 129.74,101.11 126.92,98.29 126.92,91.73 118.61,83.42 118.61,71.62 112.27,65.28 112.27,62.2 112.37,62.1 112.97,62.1 113.06,62 113.06,61.81 112.97,61.71 112.37,61.71 112.27,61.61 112.27,61.41 112.37,61.31 112.97,61.31 113.06,61.21 113.06,61.01 112.97,60.91 112.37,60.91 112.27,60.81 112.27,55.46 112.37,55.36 112.97,55.36 113.06,55.26 113.06,55.06 112.97,54.96 112.37,54.96 112.27,54.86 112.27,54.66 112.37,54.56 112.97,54.56 113.06,54.47 113.06,54.27 112.97,54.17 112.37,54.17 112.27,54.07 112.27,53.87 112.37,53.77 112.97,53.77 113.06,53.67 113.06,53.48 112.97,53.38 112.37,53.38 112.27,53.28 112.27,52.87 111.72,52.32 111.72,50.71 112.06,50.37 v2(112.06,47.19)
  BOTTOM w0.076: UC1.BT11 131.62,101.84 131.46,101.68 130.52,101.68 130.46,101.74 v2(130.45,101.74)
  BOTTOM w0.114: v2(112.06,47.19) 112.19,47.33 JDIMM2.3
DDR_B_D1: length 74.2
  IN1 w0.081: v2(112.06,44.65) 112.53,45.13 112.53,52.43 113.37,53.27 113.37,60.25 113.47,60.35 113.65,60.35 113.75,60.45 113.75,60.65 113.65,60.74 113.47,60.74 113.37,60.84 113.37,61.04 113.47,61.14 113.65,61.14 113.75,61.24 113.75,61.44 113.65,61.54 113.47,61.54 113.37,61.64 113.37,61.83 113.47,61.93 113.65,61.93 113.75,62.03 113.75,62.23 113.65,62.33 113.47,62.33 113.37,62.43 113.37,65.72 117.69,70.05 117.81,70.05 117.95,69.91 118.06,69.91 118.18,70.03 118.18,70.14 118.04,70.28 118.04,70.39 118.15,70.51 118.27,70.51 118.41,70.37 118.52,70.37 118.64,70.49 118.64,70.6 118.5,70.74 118.5,70.86 118.91,71.27 118.91,83.29 127.22,91.6 127.22,98.19 129.74,100.71 v2(129.95,100.71)
  BOTTOM w0.076: UC1.BR11 132.77,101.84 132.47,101.53 131.54,101.53 131.44,101.43 131.16,101.43 130.43,100.71 v2(129.95,100.71)
  BOTTOM w0.114: v2(112.06,44.65) 113.44,43.27 JDIMM2.8
DDR_B_D2: length 71.8
  IN1 w0.081: v2(130.17,99.11) 130.35,98.93 130.35,98.38 129.29,97.32 129.29,91.55 120.6,82.85 120.6,69.35 116.34,65.1 116.34,62.84 116.05,62.55 115.54,62.55 115.44,62.45 115.44,60.57 115.54,60.48 115.97,60.48 116.06,60.38 116.06,55.47 115.97,55.37 115.54,55.37 115.44,55.27 115.44,55.07 115.54,54.97 115.97,54.97 116.06,54.87 116.06,54.68 115.97,54.58 115.54,54.58 115.44,54.48 115.44,54.28 115.54,54.18 115.97,54.18 116.06,54.08 116.06,53.8 115.07,52.8 115.07,52.15 114.94,52.03 114.94,48.1 114.64,47.8 114.64,43.71 v2(115.34,43)
  BOTTOM w0.089: UC1.BT9 131.32,101.05 130.07,99.8 130.07,99.43 130.17,99.33 v2(130.17,99.11)
  BOTTOM w0.114: JDIMM2.16 115.45,42.9 v2(115.34,43)
DDR_B_D3: length 72.1
  IN1 w0.081: v2(115.34,45.54) 115.6,45.54 116.16,46.1 116.16,47.99 116.97,48.8 116.97,60.84 117.24,61.11 117.24,64.72 122.01,69.49 122.01,72.58 121.91,72.68 121.6,72.68 121.5,72.78 121.5,72.98 121.6,73.08 121.91,73.08 122.01,73.18 122.01,73.38 121.91,73.48 121.6,73.48 121.5,73.57 121.5,73.77 121.6,73.87 121.91,73.87 122.01,73.97 122.01,74.17 121.91,74.27 121.6,74.27 121.5,74.37 121.5,74.57 121.6,74.66 121.83,74.66 121.93,74.76 121.93,75.04 121.83,75.14 121.59,75.14 121.5,75.23 121.5,75.43 121.59,75.52 121.83,75.52 121.93,75.62 121.93,77.57 122.01,77.65 122.04,77.65 122.12,77.73 122.12,77.89 122.04,77.97 122.01,77.97 121.93,78.05 121.93,78.22 122.01,78.3 122.04,78.3 122.12,78.38 122.12,78.54 122.04,78.62 122.01,78.62 121.93,78.7 121.93,78.87 122.01,78.95 122.04,78.95 122.12,79.03 122.12,79.19 122.04,79.27 122.01,79.27 121.93,79.35 121.93,79.52 122.01,79.6 122.04,79.6 122.12,79.68 122.12,79.84 122.04,79.92 122.01,79.92 121.93,80 121.93,80.17 122.01,80.25 122.04,80.25 122.12,80.33 122.12,80.49 122.04,80.57 122.01,80.57 121.93,80.65 121.93,80.82 122.01,80.9 122.04,80.9 122.12,80.98 122.12,81.14 122.04,81.22 122.01,81.22 121.93,81.3 121.93,81.5 123.12,82.69 123.12,84.05 130.7,91.63 130.7,92.71 132.41,94.41 132.41,99.37 131.78,100 131.78,100.56 v2(131.74,100.61)
  BOTTOM w0.076: UC1.BR8 132.66,100.61 v2(131.74,100.61)
  BOTTOM w0.114: v2(115.34,45.54) 116.69,46.89 JDIMM2.21
DDR_B_D4: length 74.4
  IN1 w0.081: v2(112.06,45.92) 111.42,46.56 111.42,47.47 111.52,47.57 111.66,47.57 111.76,47.67 111.76,47.87 111.66,47.97 111.52,47.97 111.42,48.07 111.42,48.27 111.52,48.36 111.66,48.36 111.76,48.46 111.76,48.66 111.66,48.76 111.52,48.76 111.42,48.86 111.42,49.06 111.52,49.16 111.66,49.16 111.76,49.26 111.76,49.45 111.66,49.55 111.52,49.55 111.42,49.65 111.42,49.85 111.52,49.95 111.66,49.95 111.76,50.05 111.76,50.25 111.66,50.35 111.52,50.35 111.42,50.44 111.42,52.45 111.97,53 111.97,53.42 111.89,53.5 111.47,53.5 111.39,53.58 111.39,53.75 111.47,53.83 111.89,53.83 111.97,53.91 111.97,65.41 118.31,71.75 118.31,83.55 126.62,91.85 126.62,98.39 129.42,101.2 129.42,101.26 130.16,101.99 130.16,102.09 130.24,102.17 v2(130.78,102.17)
  BOTTOM w0.076: v2(130.78,102.17) 130.85,102.17 131.14,101.88 131.43,101.88 131.68,102.13 133.36,102.13 UC1.BP11
  BOTTOM w0.114: JDIMM2.7 113.19,47.82 112.59,47.21 112.59,46.45 v2(112.06,45.92)
DDR_B_D5: length 74.9
  IN1 w0.081: v2(131.32,102.27) 131.32,102.08 130.55,101.31 130.55,100.79 130.06,100.3 129.73,100.3 128.25,98.83 128.25,98.33 127.52,97.6 127.52,91.48 119.21,83.17 119.21,70.61 117.61,69.02 117.5,69.02 117.36,69.15 117.24,69.15 117.13,69.04 117.13,68.92 117.27,68.79 117.27,68.67 117.15,68.56 117.04,68.56 116.9,68.69 116.78,68.69 116.67,68.58 116.67,68.46 116.81,68.33 116.81,68.21 116.69,68.1 116.58,68.1 116.44,68.23 116.32,68.23 116.21,68.12 116.21,68 116.35,67.86 116.35,67.75 113.71,65.11 113.71,62.88 114.05,62.54 114.05,59.84 113.67,59.46 113.67,53.14 112.83,52.3 112.83,44.16 v2(112.06,43.38)
  BOTTOM w0.076: UC1.BN11 134.07,101.84 133.57,102.33 131.38,102.33 v2(131.32,102.27)
  BOTTOM w0.114: v2(112.06,43.38) 112.44,43 JDIMM2.4
DDR_B_D6: length 73.2
  IN1 w0.081: v2(131.2,100.39) 131.27,100.33 131.27,100.13 132.21,99.19 132.21,94.54 130.45,92.78 130.45,91.85 122.82,84.23 122.82,82.82 121.63,81.62 121.63,79 121.53,78.91 121.29,78.91 121.2,78.81 121.2,78.62 121.29,78.52 121.53,78.52 121.63,78.42 121.63,78.23 121.53,78.13 121.29,78.13 121.2,78.04 121.2,77.84 121.29,77.75 121.53,77.75 121.63,77.65 121.63,77.46 121.53,77.36 121.29,77.36 121.2,77.27 121.2,77.07 121.29,76.98 121.53,76.98 121.63,76.88 121.63,76.69 121.53,76.59 121.29,76.59 121.2,76.49 121.2,76.3 121.29,76.2 121.53,76.2 121.63,76.11 121.63,75.91 121.53,75.82 121.29,75.82 121.2,75.72 121.2,72.39 121.3,72.29 121.61,72.29 121.71,72.19 121.71,71.99 121.61,71.89 121.3,71.89 121.2,71.8 121.2,71.6 121.3,71.5 121.61,71.5 121.71,71.4 121.71,71.2 121.61,71.1 121.3,71.1 121.2,71 121.2,70.8 121.3,70.71 121.61,70.71 121.71,70.61 121.71,70.41 121.61,70.31 121.3,70.31 121.2,70.21 121.2,70.01 121.3,69.91 121.61,69.91 121.71,69.81 121.71,69.62 121.61,69.52 121.3,69.52 121.2,69.42 121.2,69.1 116.94,64.85 116.94,61.24 116.67,60.97 116.67,49.87 116.57,49.77 116.06,49.77 115.96,49.67 115.96,49.47 116.06,49.37 116.57,49.37 116.67,49.28 116.67,48.92 115.34,47.6 v2(115.34,46.81)
  BOTTOM w0.076: v2(131.2,100.39) 131.35,100.25 132.18,100.25 132.24,100.31 132.53,100.31 132.89,99.95 133.35,99.95 UC1.BP8
  BOTTOM w0.114: JDIMM2.17 115.69,47.16 v2(115.34,46.81)
DDR_B_D7: length 73.8
  IN1 w0.081: v2(130.45,99.58) 130.64,99.39 130.64,98.34 129.63,97.33 129.63,91.46 122.52,84.35 122.52,82.94 120.9,81.32 120.9,69.23 116.64,64.97 116.64,61.37 116.37,61.09 116.37,53.15 116.27,53.05 115.8,53.05 115.71,52.95 115.71,52.75 115.8,52.65 116.27,52.65 116.37,52.55 116.37,51.91 116.27,51.81 115.34,51.81 115.24,51.72 115.24,51.45 115.34,51.35 116.27,51.35 116.37,51.26 116.37,51.02 116.27,50.92 115.76,50.92 115.66,50.82 115.66,50.4 115.56,50.3 115.34,50.3 115.24,50.2 115.24,47.98 114.94,47.67 114.94,44.67 v2(115.34,44.27)
  BOTTOM w0.076: UC1.BN8 133.83,99.79 132.65,99.79 132.59,99.73 132.24,99.73 132.17,99.79 131.5,99.79 131.38,99.67 131.15,99.67 131.01,99.53 130.5,99.53 v2(130.45,99.58)
  BOTTOM w0.114: JDIMM2.20 116.45,41.92 116.28,42.09 116.28,43.33 v2(115.34,44.27)
DDR_B_D8: length 73.3
  IN1 w0.081: v2(135.28,102.23) 135.28,101.86 134.41,100.99 134.41,100.03 132.99,98.6 132.99,94.67 130.89,92.57 130.89,90.79 123.85,83.75 123.85,82.39 122.66,81.19 122.66,75.31 122.74,75.23 122.86,75.23 122.94,75.15 122.94,74.98 122.86,74.9 122.74,74.9 122.66,74.82 122.66,74.66 122.74,74.58 122.86,74.58 122.94,74.5 122.94,74.33 122.86,74.25 122.74,74.25 122.66,74.17 122.66,74.01 122.74,73.93 122.86,73.93 122.94,73.84 122.94,73.68 122.86,73.6 122.74,73.6 122.66,73.52 122.66,73.36 122.74,73.28 122.86,73.28 122.94,73.19 122.94,73.03 122.86,72.95 122.74,72.95 122.66,72.87 122.66,72.71 122.74,72.63 122.86,72.63 122.94,72.54 122.94,72.38 122.86,72.3 122.74,72.3 122.66,72.22 122.66,72.06 122.74,71.98 122.86,71.98 122.94,71.89 122.94,71.73 122.86,71.65 122.74,71.65 122.66,71.57 122.66,71.13 122.74,71.05 123.13,71.05 123.21,70.97 123.21,69.66 118.52,64.97 118.52,61.35 117.88,60.71 117.88,55.58 118.33,55.13 118.33,49.12 116.92,47.71 116.92,43.71 v2(117.63,43)
  BOTTOM w0.076: v2(135.28,102.23) 135.61,102.56 UC1.BL12
  BOTTOM w0.114: v2(117.63,43) 117.45,42.81 JDIMM2.24
DDR_B_D9: length 73
  IN1 w0.081: v2(117.63,44.27) 117.23,44.67 117.23,47.59 118.63,48.99 118.63,55.25 118.2,55.68 118.2,60.6 118.82,61.22 118.82,64.85 123.51,69.54 123.51,71.29 123.43,71.37 123.34,71.37 123.26,71.45 123.26,71.61 123.34,71.69 123.43,71.69 123.51,71.77 123.51,71.94 123.43,72.02 123.34,72.02 123.26,72.1 123.26,72.26 123.34,72.34 123.43,72.34 123.51,72.42 123.51,72.59 123.43,72.67 123.34,72.67 123.26,72.75 123.26,72.91 123.34,72.99 123.43,72.99 123.51,73.07 123.51,73.24 123.43,73.32 123.34,73.32 123.26,73.4 123.26,73.56 123.34,73.64 123.43,73.64 123.51,73.72 123.51,73.89 123.43,73.97 123.34,73.97 123.26,74.05 123.26,74.21 123.34,74.29 123.43,74.29 123.51,74.37 123.51,74.99 123.42,75.09 123.34,75.09 123.26,75.17 123.26,75.4 123.34,75.48 123.42,75.48 123.51,75.57 123.51,75.8 122.96,76.35 122.96,81.06 124.15,82.26 124.15,83.62 131.13,90.61 131.13,92.37 133.17,94.41 133.17,98.53 134.64,99.99 134.64,100.67 136.08,102.11 v2(136.08,102.22)
  BOTTOM w0.076: v2(136.08,102.22) UC1.BL11
  BOTTOM w0.114: JDIMM2.28 118.45,43.45 v2(117.63,44.27)
DDR_B_D10: length 71.6
  IN1 w0.081: v2(135.28,100.66) 134.87,100.24 134.87,99.95 133.36,98.45 133.36,94.28 131.32,92.24 131.32,90.37 124.45,83.5 124.45,82.13 123.31,80.99 123.31,80.08 123.54,79.85 123.72,79.85 123.81,79.75 123.81,79.56 123.72,79.46 123.35,79.46 123.26,79.36 123.26,79.17 123.35,79.07 123.72,79.07 123.81,78.98 123.81,78.78 123.72,78.69 123.35,78.69 123.26,78.59 123.26,78.4 123.35,78.3 123.72,78.3 123.81,78.21 123.81,78.01 123.72,77.92 123.35,77.92 123.26,77.82 123.26,77.63 123.35,77.53 123.72,77.53 123.81,77.43 123.81,77.24 123.72,77.14 123.35,77.14 123.26,77.05 123.26,76.48 123.81,75.92 123.81,69.41 119.12,64.72 119.12,62.7 119.22,62.61 119.58,62.61 119.68,62.51 119.68,62.32 119.58,62.22 119.22,62.22 119.12,62.12 119.12,61.93 119.22,61.83 119.58,61.83 119.68,61.74 119.68,61.54 119.58,61.45 119.22,61.45 119.12,61.35 119.12,61.1 118.48,60.46 118.48,60.14 118.58,60.04 118.93,60.04 119.03,59.94 119.03,59.75 118.93,59.65 118.58,59.65 118.48,59.55 118.48,59.35 118.58,59.25 118.93,59.25 119.03,59.15 119.03,58.95 118.93,58.85 118.58,58.85 118.48,58.76 118.48,55.82 118.93,55.38 118.93,48.87 117.63,47.56 v2(117.63,46.81)
  BOTTOM w0.076: v2(135.28,100.66) UC1.BL8
  BOTTOM w0.114: v2(117.63,46.81) 117.69,46.87 JDIMM2.25
DDR_B_D11: length 72.2
  IN1 w0.081: v2(136.95,100.27) 136.54,99.87 136.54,99.36 137.55,98.35 137.55,94.23 137.24,93.92 137.24,93.9 135.47,92.14 135.47,89.78 132.36,86.66 132.14,86.66 126.71,81.23 126.71,80.92 126.62,80.84 126.58,80.84 126.5,80.75 126.5,80.59 126.58,80.51 126.62,80.51 126.71,80.43 126.71,80.27 126.62,80.19 126.58,80.19 126.5,80.1 126.5,79.94 126.58,79.86 126.62,79.86 126.71,79.78 126.71,69.32 122.24,64.86 122.24,60.4 122.05,60.22 122.05,48.01 121.8,47.77 121.8,45.15 121.64,44.99 121.52,44.99 121.42,44.89 121.42,44.69 121.52,44.59 121.75,44.59 121.85,44.49 121.85,44.27 121.75,44.17 121.53,44.17 121.42,44.06 121.42,43.87 121.52,43.77 121.7,43.77 121.8,43.67 121.8,43.46 121.7,43.36 121.09,43.36 120.99,43.46 120.99,43.86 v2(120.59,44.27)
  BOTTOM w0.076: v2(136.95,100.27) UC1.BJ8
  BOTTOM w0.114: v2(120.59,44.27) 120.81,44.27 121.94,43.13 JDIMM2.42
DDR_B_D12: length 73.6
  IN1 w0.081: v2(120.59,46.81) 120.59,47.41 121.45,48.26 121.45,49.24 121.35,49.34 120.96,49.34 120.86,49.44 120.86,49.64 120.96,49.74 121.35,49.74 121.45,49.84 121.45,60.46 121.64,60.65 121.64,65.11 125.32,68.79 125.32,69.43 125.42,69.53 125.76,69.53 125.86,69.62 125.86,69.82 125.76,69.92 125.42,69.92 125.32,70.02 125.32,70.22 125.42,70.32 125.76,70.32 125.86,70.42 125.86,70.62 125.76,70.71 125.42,70.71 125.32,70.81 125.32,71.01 125.42,71.11 125.76,71.11 125.86,71.21 125.86,71.41 125.76,71.51 125.42,71.51 125.32,71.61 125.32,71.8 125.42,71.9 125.76,71.9 125.86,72 125.86,72.2 125.76,72.3 125.42,72.3 125.32,72.4 125.32,72.6 125.42,72.7 125.76,72.7 125.86,72.79 125.86,72.99 125.76,73.09 125.42,73.09 125.32,73.19 125.32,73.39 125.42,73.49 125.76,73.49 125.86,73.59 125.86,73.79 125.76,73.88 125.42,73.88 125.32,73.98 125.32,80.69 126.21,81.58 126.21,81.7 126.05,81.85 126.05,81.97 126.17,82.08 126.28,82.08 126.44,81.93 126.55,81.93 126.67,82.04 126.67,82.16 126.51,82.31 126.51,82.43 126.63,82.54 126.74,82.54 126.9,82.39 127.01,82.39 127.13,82.5 127.13,82.62 126.97,82.77 126.97,82.89 127.09,83 127.2,83 127.36,82.85 127.47,82.85 127.59,82.96 127.59,83.08 127.34,83.33 127.34,83.44 127.42,83.53 127.6,83.53 127.82,83.31 127.93,83.31 133.55,88.92 133.55,91.75 136.48,94.68 136.48,95.68 135.59,96.57 135.59,98.16 136.16,98.73 136.16,100.43 136.53,100.8 136.53,101.16 v2(136.95,101.57)
  BOTTOM w0.076: v2(136.95,101.57) UC1.BJ11
  BOTTOM w0.114: JDIMM2.37 120.69,46.91 v2(120.59,46.81)
DDR_B_D13: length 73.2
  IN1 w0.081: v2(120.59,45.54) 120.93,45.54 121.23,45.84 121.23,47.62 121.75,48.14 121.75,60.34 121.94,60.53 121.94,64.99 126.16,69.2 126.16,74.25 126.06,74.35 125.72,74.35 125.62,74.45 125.62,74.65 125.72,74.75 126.06,74.75 126.16,74.85 126.16,75.05 126.06,75.14 125.72,75.14 125.62,75.24 125.62,75.44 125.72,75.54 126.06,75.54 126.16,75.64 126.16,75.84 126.06,75.94 125.72,75.94 125.62,76.04 125.62,76.18 125.7,76.27 125.78,76.27 125.87,76.35 125.87,76.51 125.78,76.59 125.7,76.59 125.62,76.67 125.62,76.83 125.7,76.92 125.78,76.92 125.87,77 125.87,77.16 125.78,77.24 125.7,77.24 125.62,77.32 125.62,77.48 125.7,77.57 125.78,77.57 125.87,77.65 125.87,77.81 125.78,77.89 125.7,77.89 125.62,77.97 125.62,78.27 125.7,78.35 126.17,78.35 126.25,78.43 126.25,78.59 126.17,78.67 125.7,78.67 125.62,78.75 125.62,78.97 125.71,79.07 126.09,79.07 126.18,79.16 126.18,79.35 126.09,79.45 125.71,79.45 125.62,79.55 125.62,79.74 125.71,79.84 126.09,79.84 126.18,79.93 126.18,80.13 126.09,80.22 125.71,80.22 125.62,80.32 125.62,80.57 126.72,81.67 133.87,88.82 133.87,91.8 136.67,94.6 136.67,95.76 136.38,96.04 136.38,98.06 136.35,98.1 136.35,100.33 v2(136.95,100.92)
  BOTTOM w0.076: v2(136.95,100.92) UC1.BJ10
  BOTTOM w0.114: JDIMM2.41 121.69,46.64 v2(120.59,45.54)
DDR_B_D14: length 71.3
  IN1 w0.081: v2(117.63,45.54) 118.63,46.54 118.63,47.95 119.23,48.56 119.23,51.3 119.33,51.4 119.5,51.4 119.6,51.5 119.6,51.7 119.5,51.8 119.33,51.8 119.23,51.89 119.23,52.9 119.36,53.03 119.5,53.03 119.6,53.13 119.6,53.33 119.5,53.42 119.33,53.42 119.23,53.52 119.23,53.7 119.36,53.82 119.5,53.82 119.6,53.92 119.6,54.12 119.5,54.22 119.33,54.22 119.23,54.31 119.23,54.49 119.36,54.61 119.5,54.61 119.6,54.71 119.6,54.91 119.5,55.01 119.33,55.01 119.23,55.11 119.23,55.5 118.79,55.95 118.79,58.19 119.33,58.73 119.33,60.51 120.04,61.22 120.04,63.4 119.94,63.5 119.52,63.5 119.42,63.6 119.42,63.79 119.52,63.89 119.94,63.89 120.04,63.98 120.04,64.18 119.94,64.27 119.52,64.27 119.42,64.37 119.42,64.56 119.52,64.66 119.94,64.66 120.04,64.76 120.04,65.22 124.11,69.29 124.11,81.25 124.75,81.89 124.75,83.38 132.15,90.77 132.15,91.32 135.28,94.46 135.28,95.54 134.22,96.61 134.22,98.1 135.32,99.21 v2(135.32,99.84)
  BOTTOM w0.076: v2(135.32,99.84) UC1.BL7
  BOTTOM w0.114: JDIMM2.29 118.69,46.6 v2(117.63,45.54)
DDR_B_D15: length 71.7
  IN1 w0.081: v2(136.95,99.62) 137.81,98.76 137.81,94.21 135.7,92.1 135.7,89.47 132.66,86.43 132.33,86.43 127.01,81.1 127.01,69.2 122.55,64.74 122.55,62.12 122.64,62.02 123.04,62.02 123.14,61.92 123.14,61.73 123.04,61.63 122.64,61.63 122.55,61.54 122.55,61.34 122.64,61.25 123.04,61.25 123.14,61.15 123.14,60.96 123.04,60.86 122.64,60.86 122.55,60.76 122.55,54.98 122.47,54.9 122.45,54.9 122.35,54.8 122.35,54.6 122.45,54.5 122.68,54.5 122.78,54.4 122.78,54.2 122.68,54.1 122.45,54.1 122.35,54 122.35,53.81 122.45,53.71 122.68,53.71 122.78,53.61 122.78,53.41 122.68,53.31 122.45,53.31 122.35,53.21 122.35,53.01 122.45,52.92 122.68,52.92 122.78,52.82 122.78,52.62 122.68,52.52 122.45,52.52 122.33,52.4 122.33,43.57 121.76,43 v2(120.59,43)
  BOTTOM w0.076: v2(136.95,99.62) UC1.BJ7
  BOTTOM w0.114: v2(120.59,43) 120.94,42.64 JDIMM2.38
DDR_B_D16: length 70.1
  IN1 w0.081: v2(138.78,102.21) 138.23,101.66 138.23,100.15 137.98,99.9 137.98,99.33 138.34,98.96 138.34,94.31 136.08,92.05 136.08,89.59 133.41,86.91 133.41,86.34 127.74,80.67 127.74,68.89 124.3,65.45 124.3,64.4 124.2,64.3 123.93,64.3 123.83,64.2 123.83,64.01 123.93,63.92 124.2,63.92 124.3,63.82 124.3,63.63 124.2,63.53 123.93,63.53 123.83,63.43 123.83,63.24 123.93,63.14 124.2,63.14 124.3,63.05 124.3,62.82 124.2,62.73 123.93,62.73 123.83,62.63 123.83,62.44 123.93,62.34 124.2,62.34 124.3,62.24 124.3,61.95 124.21,61.87 123.92,61.87 123.83,61.79 123.83,61.62 123.92,61.54 124.21,61.54 124.3,61.46 124.3,61.3 124.21,61.22 123.72,61.22 123.64,61.14 123.64,60.97 123.72,60.89 124.21,60.89 124.3,60.81 124.3,60.58 123.66,59.95 123.66,48.65 123.76,48.55 124.2,48.55 124.3,48.46 124.3,48.26 124.2,48.17 123.76,48.17 123.66,48.07 123.66,47.52 v2(122.95,46.81)
  BOTTOM w0.076: v2(138.78,102.21) UC1.BG11
  BOTTOM w0.114: v2(122.95,46.81) 122.69,47.06 JDIMM2.45
DDR_B_D17: length 69.3
  IN1 w0.081: v2(138.78,101.57) 138.41,101.21 138.41,100.07 138.16,99.82 138.16,99.4 138.52,99.04 138.52,94.24 136.3,92.02 136.3,89.28 133.7,86.68 133.7,86.21 128.04,80.55 128.04,68.77 124.6,65.32 124.6,60.46 123.99,59.85 123.99,49.86 124.08,49.76 124.31,49.76 124.41,49.67 124.41,49.47 124.31,49.38 124.06,49.38 123.96,49.28 123.96,49.05 124.06,48.95 124.47,48.95 124.6,48.82 124.6,47.94 123.39,46.74 123.39,45.32 123.3,45.24 123.18,45.24 123.12,45.3 123.04,45.3 122.95,45.39 v2(122.95,45.54)
  BOTTOM w0.076: v2(138.78,101.57) UC1.BG10
  BOTTOM w0.114: v2(122.95,45.54) 123.69,46.28 JDIMM2.49
DDR_B_D18: length 68.7
  IN1 w0.081: v2(122.95,44.27) 123.69,45 123.69,46.61 124.89,47.82 124.89,49.61 124.32,50.19 124.32,56.4 124.42,56.5 124.73,56.5 124.83,56.6 124.83,56.79 124.73,56.89 124.38,56.89 124.29,56.98 124.29,59.73 124.89,60.33 124.89,65.2 128.34,68.64 128.34,80.42 134.03,86.11 134.03,86.7 136.5,89.17 136.5,91.97 138.7,94.16 138.7,99.11 138.6,99.22 138.37,99.45 138.37,99.73 138.78,100.14 v2(138.78,100.27)
  BOTTOM w0.076: v2(138.78,100.27) UC1.BG8
  BOTTOM w0.114: JDIMM2.50 123.94,43.43 123.11,44.27 v2(122.95,44.27)
DDR_B_D19: length 69
  IN1 w0.081: v2(126.63,45.54) 126.84,45.33 127.02,45.33 127.3,45.62 127.3,57.99 127.4,58.08 127.74,58.08 127.83,58.18 127.83,58.38 127.74,58.48 127.4,58.48 127.3,58.58 127.3,58.78 127.4,58.88 127.74,58.88 127.83,58.98 127.83,59.17 127.74,59.27 127.4,59.27 127.3,59.37 127.3,59.57 127.4,59.67 127.74,59.67 127.83,59.77 127.83,59.97 127.74,60.07 127.4,60.07 127.3,60.17 127.3,60.36 127.4,60.46 127.74,60.46 127.83,60.56 127.83,60.76 127.74,60.86 127.4,60.86 127.3,60.96 127.3,61.18 127.4,61.28 127.4,65.04 130.17,67.81 130.17,79.48 135.69,85.01 135.69,85.81 140.33,90.45 140.33,92.21 140.61,92.48 140.61,97.93 140.67,98 140.67,98.7 140.06,99.31 140.06,99.77 139.69,100.15 v2(139.69,100.28)
  BOTTOM w0.076: UC1.BF8 139.35,99.95 v2(139.69,100.28)
  BOTTOM w0.114: v2(126.63,45.54) 126.19,45.98 JDIMM2.59
DDR_B_D20: length 70.8
  IN1 w0.081: v2(126.63,43) 127.91,44.27 127.91,53.56 127.99,53.64 128.2,53.64 128.28,53.73 128.28,53.89 128.2,53.97 127.99,53.97 127.91,54.05 127.91,54.21 127.99,54.29 128.2,54.29 128.28,54.38 128.28,54.54 128.2,54.62 127.99,54.62 127.91,54.7 127.91,54.86 127.99,54.94 128.2,54.94 128.28,55.03 128.28,55.19 128.2,55.27 127.99,55.27 127.91,55.35 127.91,55.51 127.99,55.59 128.2,55.59 128.28,55.68 128.28,55.84 128.2,55.92 127.99,55.92 127.91,56 127.91,56.31 128.44,56.84 128.44,61.3 128.64,61.5 128.64,65.43 130.77,67.56 130.77,79.23 136.3,84.75 136.3,85.72 140.77,90.19 140.77,91.95 141.03,92.21 141.03,92.36 141.06,92.39 141.06,98.81 140.47,99.41 140.47,99.94 140.24,100.17 140.24,101.66 v2(139.69,102.21)
  BOTTOM w0.076: v2(139.69,102.21) UC1.BF11
  BOTTOM w0.114: v2(126.63,43) 126.94,42.69 JDIMM2.62
DDR_B_D21: length 70.6
  IN1 w0.081: v2(139.69,101.57) 140.07,101.2 140.07,100.06 140.26,99.86 140.26,99.36 140.85,98.78 140.85,92.36 140.55,92.07 140.55,90.33 136,85.78 136,84.88 130.47,79.35 130.47,67.69 128.34,65.56 128.34,64.97 128.26,64.89 127.92,64.89 127.83,64.81 127.83,64.65 127.92,64.57 128.26,64.57 128.34,64.49 128.34,62.56 128.26,62.48 127.79,62.48 127.71,62.4 127.71,62.24 127.79,62.16 128.26,62.16 128.34,62.08 128.34,61.63 128.14,61.43 128.14,58.06 127.61,57.53 127.61,57.3 127.71,57.2 127.97,57.2 128.07,57.1 128.07,56.91 127.97,56.81 127.71,56.81 127.61,56.71 127.61,45.24 v2(126.63,44.27)
  BOTTOM w0.076: v2(139.69,101.57) UC1.BF10
  BOTTOM w0.114: JDIMM2.58 125.94,43.58 v2(126.63,44.27)
DDR_B_D22: length 67.6
  IN1 w0.081: v2(122.95,43) 123.94,43 124.02,43.08 124.02,43.41 123.94,43.49 123.87,43.49 123.77,43.59 123.77,43.79 123.87,43.89 124.29,43.89 124.39,43.99 124.39,44.19 124.29,44.29 124.09,44.29 123.99,44.39 123.99,46.49 125.19,47.7 125.19,65.07 128.64,68.52 128.64,80.3 134.34,85.99 134.34,86.62 136.7,88.99 136.7,91.92 138.89,94.1 138.89,99.51 v2(138.78,99.62)
  BOTTOM w0.076: v2(138.78,99.62) UC1.BG7
  BOTTOM w0.114: JDIMM2.46 122.94,42.99 v2(122.95,43)
DDR_B_D23: length 68.3
  IN1 w0.081: v2(139.69,99.62) 139.69,99.38 140.49,98.58 140.49,98.12 140.39,98.02 140.39,92.61 140.12,92.33 140.12,90.56 135.39,85.84 135.39,85.13 129.87,79.61 129.87,67.94 127.1,65.17 127.1,62.77 127,62.67 126.6,62.67 126.5,62.57 126.5,62.38 126.6,62.28 127,62.28 127.1,62.19 127.1,61.96 127,61.87 126.6,61.87 126.5,61.77 126.5,61.58 126.6,61.48 126.91,61.48 127,61.39 127,61.19 126.9,61.09 126.6,61.09 126.5,60.99 126.5,60.79 126.6,60.69 126.9,60.69 127,60.59 127,55.31 126.9,55.21 126.71,55.21 126.61,55.11 126.61,54.91 126.71,54.81 126.9,54.81 127,54.72 127,54.52 126.9,54.42 126.71,54.42 126.61,54.32 126.61,54.12 126.71,54.02 126.9,54.02 127,53.92 127,53.72 126.9,53.63 126.71,53.63 126.61,53.53 126.61,53.33 126.71,53.23 126.9,53.23 127,53.13 127,51.71 126.9,51.62 126.71,51.62 126.61,51.52 126.61,51.32 126.71,51.22 126.9,51.22 127,51.12 127,49.9 126.9,49.8 126.71,49.8 126.61,49.7 126.61,49.5 126.71,49.41 126.9,49.41 127,49.31 127,49.11 126.9,49.01 126.71,49.01 126.61,48.91 126.61,48.71 126.71,48.61 126.9,48.61 127,48.51 127,48.32 126.9,48.22 126.71,48.22 126.61,48.12 126.61,47.92 126.71,47.82 126.9,47.82 127,47.72 127,47.18 v2(126.63,46.81)
  BOTTOM w0.076: v2(139.69,99.62) UC1.BF7
  BOTTOM w0.114: v2(126.63,46.81) 127.19,47.37 JDIMM2.63
DDR_B_D24: length 69.4
  IN1 w0.081: v2(132.17,43) 133.65,44.48 133.65,54.18 133.73,54.26 134.04,54.26 134.12,54.34 134.12,54.5 134.04,54.58 133.73,54.58 133.65,54.67 133.65,54.83 133.73,54.91 134.04,54.91 134.12,54.99 134.12,55.15 134.04,55.23 133.73,55.23 133.65,55.32 133.65,55.66 134.27,56.28 134.27,61.7 134.86,62.28 134.86,65.14 135.08,65.36 135.08,78.23 140.17,83.32 140.17,86.05 141.36,87.24 141.87,87.24 143.43,88.8 143.43,91.73 143.96,92.27 143.96,99.23 142.98,100.21 142.98,101.68 v2(142.43,102.22)
  BOTTOM w0.076: v2(142.43,102.22) UC1.BB11
  BOTTOM w0.114: JDIMM2.84 132.44,42.72 v2(132.17,43)
DDR_B_D25: length 68.8
  IN1 w0.081: v2(141.52,102.21) 140.97,101.66 140.97,100.09 140.8,99.92 140.8,99.32 141.27,98.85 141.27,92.3 141.21,92.23 141.21,92 140.98,91.78 140.98,90.02 137.03,86.07 137.03,84.45 131.5,78.92 131.5,67.26 129.43,65.18 129.43,55.35 129.53,55.25 130.05,55.25 130.14,55.15 130.14,54.99 130.06,54.91 129.26,54.91 129.15,54.8 129.15,54.58 129.22,54.52 129.98,54.52 130.14,54.35 130.14,54.2 130.06,54.12 129.22,54.12 129.15,54.05 129.15,53.79 129.22,53.72 129.98,53.72 130.14,53.56 130.14,53.36 130.05,53.27 129.53,53.27 129.43,53.17 129.43,47.22 v2(129.02,46.81)
  BOTTOM w0.076: v2(141.52,102.21) UC1.BC11
  BOTTOM w0.114: v2(129.02,46.81) 128.19,47.64 JDIMM2.67
