# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_B_EC: length 292.2
  TOP w0.102: v2(201.58,174.33) 202.05,174.33 202.59,174.87 QE13.2 ; UE6.22 328.58,44.33 v2(328.43,44.48)
  IN4 w0.102: v2(328.43,44.48) 328.8,44.11 328.8,43.5 329.3,43 329.3,42.66 327.85,41.2 327.11,41.2 325.37,39.46 325.37,36.06 324.3,34.99 322.86,34.99 322.25,34.38 321.55,34.38 320.96,34.98 292.42,34.98 290.94,36.46 282.93,36.46 281.64,35.17 278.22,35.17 277.4,36 273.38,36 273.15,36.22 272.84,36.22 265.99,43.07 259.41,43.07 259.27,43.2 258.61,43.87 240.17,43.87 239.59,44.44 236.36,44.44 236.01,44.09 235.88,43.96 228.77,43.96 228.4,44.33 224.66,44.33 224.38,44.61 214.16,44.61 213.36,45.41 211.39,45.41 209.95,46.85 209.38,46.85 208.58,47.64 208.58,52.54 207.18,53.94 202.92,53.94 201.62,55.24 201.62,61 200.43,62.2 200.43,64.03 197.91,66.55 193.06,66.55 192.2,67.41 192.2,68.28 189.34,71.14 189.34,78.6 188.78,79.16 188.78,81.67 189.19,82.08 189.32,82.21 189.43,82.33 189.43,87.62 189.32,87.74 189.32,96.53 189.19,96.66 186.57,99.27 186.57,100.19 186.95,100.57 186.95,104.96 186.42,105.49 186.42,107.98 187.42,108.97 187.42,110.51 188.98,112.08 188.98,113.97 188.98,114.41 191.11,116.53 191.11,119.42 192.62,120.94 192.62,123.09 195.39,125.85 195.39,126.45 195.94,127.01 195.94,127.8 196.57,128.43 196.57,147.96 196.31,148.23 193.09,151.45 193.09,153.55 191.7,154.93 191.7,159.62 196.27,164.19 196.27,165.18 195.59,165.87 195.59,168.15 196.3,168.86 196.3,171.82 197.43,172.95 200.21,172.95 v2(201.58,174.33)
PWR_G#: length 24.3
  TOP w0.102: RE156.2 198.76,175.1 198.76,176.33 199.61,177.17 200.37,177.17 RE155.1 200.53,176.69 200.43,176.58 199.78,176.58 199.46,176.26 QE21.3 198.87,174.55 198.87,173.18 199.28,172.76 199.85,172.76 200.64,171.97 200.64,171.97 201.02,171.59 v1(204.09,171.59) 205.61,171.59 207.26,169.94 210.74,169.94 211.32,169.36 JPWR.3
PWR_G_7313#: length 41.3
  TOP w0.254: UE3.16 232.21,162.16 232.42,162.36 232.42,162.97 v2(231.54,163.85)
  TOP w0.508: QE21.4 199.46,173.53 199.96,174.03 v2(199.96,174.32)
  IN3 w0.508: v2(231.54,163.85) 230.28,163.85 228.33,165.8 228.33,166.19 226.9,167.61 222.98,167.61 222.12,168.48 208.68,168.48 206.9,170.25 206.9,170.61 206.67,170.85 206.67,171.12 205.49,172.29 204.38,172.29 203.89,172.77 203.44,172.77 202.19,174.02 202.19,174.08 202.19,174.08 202.19,174.58 201.81,174.96 200.47,174.96 199.96,174.45 v2(199.96,174.32)
PWR_G_EC: length 300.9
  TOP w0.102: QE21.2 200.11,175.14 v2(199.32,174.35) ; v2(330.85,36.69) 331.52,36.02 332.45,36.02 334.81,38.39 v1(334.81,40.34) 335.73,41.27 335.73,44.57 335.35,44.95 334.02,44.95 333.9,44.83 UE6.10
  IN4 w0.089: 213.18,43.88 213.18,43.51 213.74,42.95
  IN4 w0.102: v2(199.32,174.35) 198.55,173.57 197.4,173.57 195.82,171.99 195.82,169.03 195.13,168.34 195.13,165.64 195.82,164.96 195.82,164.38 191.25,159.81 191.25,154.74 192.63,153.36 192.63,151.26 194.81,149.08 196.12,147.77 196.12,128.62 195.49,127.99 195.49,127.2 194.88,126.59 194.88,125.99 189.33,120.45 189.33,115.47 187.78,113.92 187.78,111.52 186.96,110.7 186.96,109.16 185.96,108.17 185.96,105.3 186.5,104.77 186.5,100.76 186,100.26 186,99.2 186.34,98.86 188.32,96.88 188.32,95.88 188.83,95.38 188.83,87.58 188.98,87.43 188.98,82.52 188.65,82.2 188.32,81.86 188.32,78.97 188.88,78.41 188.88,70.95 191.75,68.09 191.75,67.22 192.87,66.09 197.72,66.09 199.91,63.91 199.91,62.07 201.16,60.81 201.16,53.04 201.16,53.03 201.16,49.65 203.73,47.07 208.39,47.07 209.07,46.39 209.76,46.39 211.2,44.95 212.23,44.95 213.18,44 213.18,43.88 ; v2(330.85,36.69) 329.19,36.69 328.3,35.8 325.76,35.8 324.49,34.53 323.05,34.53 322.44,33.93 321.36,33.93 320.77,34.52 292.23,34.52 291.44,35.31 282.42,35.31 281.08,33.96 279.96,33.96 279.21,34.71 278.01,34.71 277.19,35.54 272.88,35.54 265.8,42.61 259.22,42.61 258.81,43.01 258.53,43.3 241.5,43.3 241.44,43.23 236.22,43.23 235.95,43.5 228.58,43.5 228.38,43.7 224.52,43.7 224.48,43.74 224.08,44.15 221.66,44.15 221.06,43.55 220.93,43.42 218.17,43.42 217.71,42.95 213.74,42.95
PWR_LED#: length 56
  TOP w0.203: v2(303.98,7.95) 303.94,7.99 UE5.92
  TOP w0.432: v2(323.92,45.96) 323.54,45.96 323.29,46.22 QE4.2
  IN3 w0.508: v2(303.98,7.95) 303.77,8.16 303.77,9.66 306.54,12.44 310.78,12.44 310.87,12.53 311.24,12.53 311.6,12.89 311.6,13.26 312.75,14.41 313.35,14.41 313.45,14.51 313.49,14.51 315.34,16.36 315.34,16.49 318.59,19.74 318.59,19.81 320.05,21.27 320.05,24.18 320.85,24.98 320.85,26.08 319.69,27.23 319.69,29.15 325.96,35.42 325.96,43.71 325.14,44.53 324.3,44.53 323.95,44.89 323.95,45.56 323.92,45.58 v2(323.92,45.96)
PWR_R#: length 11.1
  TOP w0.102: RE158.2 v2(204.99,176.11) 205.72,176.11 RE157.1 ; v1(211.26,174.11) 210.13,172.98 v2(210.13,172.52)
  TOP w0.107: RE158.2 204.31,175.75 204.41,175.65 QE22.3
  IN3 w0.102: v2(210.13,172.52) 209.62,173.03 208.92,173.03 205.84,176.11 v2(204.99,176.11)
PWR_R_7313#: length 40.1
  TOP w0.127: v2(233.18,162.68) 233.23,162.73 v1(233.89,162.73)
  TOP w0.254: v2(233.18,162.68) 232.86,162.36 232.86,161.85 232.67,161.66 UE3.15
  TOP w0.508: QE22.4 v2(204.41,174.05)
  IN3 w0.508: v2(204.41,174.05) 204.9,173.56 207.46,173.56 209.55,171.46 220.93,171.46 223.51,168.88 229.07,168.88 230.16,167.79 232.13,167.79 232.55,167.38 232.55,165.84 233.89,164.49 233.89,163.39 v2(233.18,162.68)
PWR_R_EC: length 298.6
  TOP w0.102: QE22.2 v2(205.06,174.48) ; v2(331.89,39.39) 331.99,39.28 v1(332.5,39.28) 333.09,39.88 333.09,41.52 332.54,42.07 UE6.6
  IN4 w0.089: 213.5,43.46 213.5,43.88
  IN4 w0.102: 213.5,43.46 213.77,43.18 217.67,43.18 218.13,43.65 220.83,43.65 220.97,43.78 220.97,43.78 221.56,44.38 224.17,44.38 224.62,43.93 228.47,43.93 228.68,43.73 235.97,43.73 236.01,43.77 236.31,43.46 241.34,43.46 241.4,43.53 258.62,43.53 259.04,43.11 259.31,42.84 265.9,42.84 272.97,35.77 277.28,35.77 278.11,34.94 279.3,34.94 280.05,34.19 280.98,34.19 283.02,36.23 290.85,36.23 292.33,34.75 320.86,34.75 321.46,34.15 322.34,34.15 322.95,34.76 324.4,34.76 326.38,36.74 326.51,36.74 328.44,38.67 329.55,38.67 329.97,39.09 331.59,39.09 v2(331.89,39.39) ; 213.5,43.88 213.5,44.25 212.57,45.18 211.29,45.18 209.85,46.62 209.28,46.62 208.35,47.55 208.35,52.44 207.08,53.71 202.82,53.71 201.39,55.14 201.39,60.91 200.19,62.11 200.19,63.95 197.81,66.32 192.96,66.32 191.97,67.31 191.97,68.18 189.11,71.05 189.11,78.5 188.55,79.06 188.55,81.77 189.09,82.3 189.2,82.42 189.2,87.53 189.09,87.64 189.09,96.44 186.57,98.95 186.57,98.95 186.34,99.18 186.34,100.28 186.72,100.66 186.72,104.86 186.19,105.39 186.19,108.07 187.19,109.07 187.19,110.61 188.76,112.18 188.76,113.87 188.76,114.5 188.76,114.5 188.76,114.57 189.56,115.37 189.56,120.35 195.11,125.9 195.11,126.49 195.72,127.1 195.72,127.9 196.34,128.53 196.34,147.87 196.21,148 196.21,148 194.9,149.31 192.86,151.35 192.86,153.45 191.47,154.84 191.47,159.71 196.05,164.28 196.05,165.05 195.36,165.74 195.36,168.25 196.07,168.96 196.07,171.92 197.39,173.23 199.53,173.23 200.36,174.07 200.36,174.53 200.72,174.88 204.66,174.88 v2(205.06,174.48)
PWR_SRC_ON: length 15.2
  BOTTOM w0.102: RV12.1 160.14,168.14 160.14,169.46 160.64,169.95 160.64,170.45 160.47,170.62 QV1.3 158.76,170.62 158.33,170.18 156.87,170.18 156.16,169.46 156.16,168.52 156.04,168.41 154.23,168.41 153.43,169.21 CV15.2 RV9.2 151.2,169.21 v1(150.73,169.68)
PWR_VGA_CORE_BOOT1: length 2.9
  BOTTOM w0.102: PR8205.2 v1(245.07,31.62)
  BOTTOM w0.203: PR8205.2 246.19,32.06 245.53,32.73 PU8200.1
PWR_VGA_CORE_BOOT1_1: length 2.6
  BOTTOM w0.254: PC8206.2 249.11,31.87 v1(248.86,31.62) PR8205.1
PWR_VGA_CORE_BOOT2_1: length 1.8
  BOTTOM w0.102: PC8213.2 248.9,39.11 v1(249.32,39.54)
PWR_VGA_CORE_LGATE1: length 23.4
  IN4 w0.508: v2(265.21,28.86) 264.64,28.86 262.33,31.17 258.25,31.17 257.75,31.68 249.85,31.68 247.53,33.99 v2(247.15,33.99)
  BOTTOM w0.102: v1(266.71,28.92) 266.04,28.25 PQ8200.6
  BOTTOM w0.203: PU8200.19 246.84,34.31 v2(247.15,33.99) 247.19,33.96 PR8206.2
PWR_VGA_CORE_LGATE2: length 9.1
  IN4 w0.508: v2(247.15,35.36) 248.83,35.36 251.21,32.98 v2(251.21,32.95)
  BOTTOM w0.102: v1(250.62,31.44) 251.21,32.03 v2(251.21,32.95)
  BOTTOM w0.203: v2(247.15,35.36) 247.02,35.36 246.77,35.11 PU8200.17
  BOTTOM w0.508: v2(251.21,32.95) 251.87,32.29 PQ8201.6
PWR_VGA_CORE_PHASE1: length 23.6
  TOP w0.102: v1(265.12,36.88) PR8204.1
  TOP w0.254: PR8204.1 265.12,35.28 v2(264.25,34.41)
  IN4 w0.508: v2(263.34,27.8) 260.61,30.53 257.99,30.53 257.48,31.04 249.56,31.04 247.4,33.2 247.04,33.2 v2(246.91,33.34)
  BOTTOM w0.203: PC8206.1 247.4,33.2 247.04,33.2 v2(246.91,33.34) 246.77,33.47 246.77,33.74 246.6,33.91 PU8200.20
PWR_VGA_CORE_PHASE2: length 6.6
  TOP w0.102: PR8210.1 v1(254.43,35.42)
  IN4 w0.508: v2(247.15,36) 249.09,36 250.3,34.79 v2(251.28,34.79)
  vias: v2(251.7,34.34)
PWR_VGA_CORE_REFIN: length 7.3
  TOP w0.102: PR8215.2 v1(241.58,31.61)
  TOP w0.254: PR8218.2 PC8217.1 PR8215.2 ; PR8218.2 PR8211.1 ; PR8218.2 241.89,34.46 v2(242.2,34.15)
  BOTTOM w0.203: PR8208.2 242.2,33.06 v2(242.2,34.15) 242.35,34.31 PU8200.7
PWR_VGA_CORE_SS: length 2.2
  BOTTOM w0.203: PU8200.11 243.93,36.62 v1(243.26,37.28) 243.21,37.33 PC8216.1
PWR_VGA_CORE_TON: length 3
  BOTTOM w0.102: v1(241.21,34.43) 241.45,34.66 PR8202.1
  BOTTOM w0.203: PU8200.9 242.73,35.11 242.41,35.42 PR8202.1
PWR_VGA_CORE_TON_1: length 2.7
  BOTTOM w0.102: PR8201.1 v1(240.53,38.15)
  BOTTOM w0.203: PR8201.1 PC8205.1 PR8202.2
PWR_VGA_CORE_UGATE1: length 17.2
  IN4 w0.508: v2(259.15,28.39) 259.15,28.47 257.22,30.41 249.12,30.41 247.28,32.25 v2(245.33,32.25)
  BOTTOM w0.203: v2(245.33,32.25) 245.31,32.27 245.31,32.3 245.13,32.48 PU8200.2
  BOTTOM w0.508: PQ8200.1 259.29,28.25 v2(259.15,28.39)
PWR_VGA_CORE_UGATE2: length 17.3
  IN4 w0.508: v2(258.39,31.93) 258.01,32.31 250.11,32.31 247.7,34.73 246.83,34.73 246.2,35.36 246.2,35.45 245.34,36.3 v2(245.34,37.02)
  BOTTOM w0.203: PU8200.14 245.13,36.82 245.33,37.02 v2(245.34,37.02)
  BOTTOM w0.508: v2(258.39,31.93) PQ8201.1
PWR_VGA_CORE_VREF: length 5
  TOP w0.102: v1(242.64,34.51) 242.3,34.85 v2(242.19,34.85)
  TOP w0.254: v2(242.19,34.85) 242.19,35.65 241.6,36.24 PC8215.1
  BOTTOM w0.203: PR8208.1 241.69,34.47 242.07,34.85 v2(242.19,34.85) 242.33,34.71 PU8200.8
PWRSHARE_EN_EC#: length 318.2
  TOP w0.102: v2(25.03,44.11) 25.03,44.12 24.96,44.19 24.77,44.19 24.6,44.36 UU1.5 ; v1(306.93,26.88) 307.19,26.61 v2(307.83,26.61)
  TOP w0.107: v2(308.47,20.58) 308.31,20.41 UE5.119
  IN2 w0.089: 197.32,45.7 197.63,45.39 199.64,45.39 199.77,45.52 199.78,45.52 199.95,45.7 201.58,45.7 201.58,45.7 ; 196.46,45.7 196.4,45.63 195.8,45.04 195.18,45.04 195.06,44.92 194.31,44.92
  IN2 w0.102: v2(25.03,44.11) 25.03,44.12 25.29,44.38 25.73,44.38 26.54,45.19 27.49,45.19 28.04,45.74 28.87,45.74 29.37,46.24 30.3,46.24 31.93,47.87 37.34,47.87 37.9,48.43 48.65,48.43 50.15,46.93 53.15,46.93 53.63,46.45 54.23,46.45 54.91,47.13 57.19,47.13 58.3,48.23 63.93,48.23 64.16,48.46 64.63,48.46 65.52,47.57 87.22,47.57 87.41,47.76 96.39,47.76 96.95,47.2 98.88,47.2 99.04,47.03 107.21,47.03 108.2,46.04 109.93,46.04 111.49,47.6 112.48,47.6 113.1,46.98 113.1,42.41 114.35,41.16 133.36,41.16 134.16,40.36 182.57,40.36 184.26,42.05 184.73,42.05 185.65,42.98 186.05,43.38 189.11,43.38 190.64,44.92 194.31,44.92 ; 201.58,45.7 202.1,46.21 209.91,46.21 210.17,46.47 211.18,46.47 211.89,45.76 217.48,45.76 217.72,45.52 217.86,45.38 224.07,45.38 225.31,44.15 229.3,44.15 229.54,44.39 233.76,44.39 234.95,45.58 238.13,45.58 241.33,42.38 243.9,42.38 245.36,43.84 266.01,43.84 275.9,33.96 279.29,33.96 283.73,29.52 290.32,29.52 294.66,25.17 301.97,25.17 301.97,25.18 304.25,25.18 304.25,25.17 305.31,25.17 306.28,26.15 307.36,26.15 v2(307.83,26.61) ; 196.46,45.7 196.67,45.9 197.11,45.9 197.32,45.7
  BOTTOM w0.107: v2(308.47,20.58) 307.95,21.11 307.95,26.5 v2(307.83,26.61)
REFADJ: length 3.5
  BOTTOM w0.203: PR6040.1 278.79,144.83 v1(278.79,144.16) 278,143.37 277.62,143.37 277.21,142.96 PU6000.40
REFIN: length 7.2
  IN1 w0.254: v2(278.86,142.07) 280.65,143.86 v2(281.2,143.86)
  BOTTOM w0.102: PR6045.1 280.56,144.66 v1(280.35,144.87)
  BOTTOM w0.203: PU6000.1 278.67,141.87 v2(278.86,142.07) 279.54,142.74 PR6053.1
  BOTTOM w0.254: PR6045.1 280.89,143.63 281.12,143.86 v2(281.2,143.86)
REGN_CHG: length 17.1
  TOP w0.203: v2(60.71,23.29) 60.55,23.29 60.22,23.63 PU700.24
  TOP w0.254: v2(53.98,28.69) 53.98,29.2 54.86,30.08 v1(55.53,30.08) 56.04,29.57 PR714.1
  IN3 w0.254: v2(53.98,28.69) 54.62,28.69 55.34,27.97 55.34,27.03 55.63,26.75 57.85,26.75 58.28,26.32 59.15,26.32 60.71,24.76 v2(60.71,23.29)
  BOTTOM w0.254: PC710.1 59.91,23.17 60.04,23.29 v2(60.71,23.29)
REMOTE1+: length 131
  IN3 w0.254: v2(178.13,114.99) 177.68,115.43 177.68,119.81 176.03,121.46 176.03,124.72 175.87,124.88 175.87,125.44 174.89,126.42 170.82,126.42 168.03,129.21 160.03,129.21 157.96,131.28 144.37,131.28 v2(142.76,132.9)
  BOTTOM w0.254: C2500.1 141.43,132.51 Q2407.2 142.93,132.25 Q2407.1 v2(142.76,132.9) ; v2(178.13,114.99) 178.36,114.99 181.03,112.31 181.03,109.66 179.68,108.31 179.45,108.31 179.02,107.88 179.02,107.65 179.02,107.42 178.39,106.78 178.39,97.28 175.64,94.53 175.64,90.62 175.66,90.59 175.66,87.46 180.9,82.22 182.36,82.22 183.82,80.76 183.82,72.5 181.72,70.4 181.72,62.45 183.45,60.72 183.45,51.05 184.33,50.18 185.23,50.18 185.43,49.97 C2502.1 186.33,49.58 186.33,48.56 186.39,48.49 U2407.2
REMOTE1-: length 128.3
  IN3 w0.254: v2(142.17,132.9) 142.19,132.9 142.19,133.03 142.25,133.09 142.25,133.11 142.63,133.49 142.99,133.49 144.69,131.79 158.17,131.79 160.24,129.72 168.24,129.72 171.03,126.93 175.1,126.93 176.37,125.65 176.37,121.61 178.02,119.95 178.02,115.73 v2(178.13,115.62)
  BOTTOM w0.254: R184.1 C2502.2 185.43,50.89 185.23,50.68 184.54,50.68 183.96,51.26 183.96,60.93 182.23,62.66 182.23,70.19 184.33,72.29 184.33,80.97 182.57,82.73 181.11,82.73 176.17,87.67 176.17,90.81 176.15,90.83 176.15,93.12 175.98,93.28 175.98,94.39 178.73,97.14 178.73,106.64 179.36,107.27 179.36,107.51 179.66,107.8 179.89,107.8 181.54,109.45 181.54,112.53 178.44,115.62 v2(178.13,115.62) ; v2(142.17,132.9) 142.19,132.9 142.06,133.02 142.06,133.17 Q2407.3 141.55,133.42 C2500.2
REMOTE2+: length 184.8
  TOP w0.254: Q2408.1 275.73,131.35 Q2408.2 275.08,129.68 C2505.1 275.48,129.29 275.48,128.87 v2(275.44,128.83)
  IN3 w0.254: v2(217.42,48.9) 217.41,48.91 217.41,49.99 213.53,53.87 213.53,66.13 213.16,66.5 v2(213.02,66.5)
  IN4 w0.254: v2(213.02,66.5) 213.1,66.42 213.53,66.42 213.81,66.71 213.81,87.79 216.12,90.1 226.32,90.1 226.93,90.71 226.93,110.47 226.17,111.23 226.17,117.29 226.82,117.94 228.22,117.94 231.24,120.96 232.34,120.96 233.73,122.34 233.73,122.43 234.7,123.41 238.66,123.41 240.1,124.84 250.83,124.84 251.77,125.78 257.14,125.78 259.46,123.46 274.04,123.46 275.48,124.9 275.48,128.21 275.44,128.25 v2(275.44,128.83)
  IN6 w0.254: v2(217.42,48.9) 217.41,48.89 217.41,48.78 217.01,48.38 216.36,48.38 215.47,49.27 210.48,49.27 209.87,49.87 209.87,52.03 207.28,54.62 203.27,54.62 200.87,52.22 200.87,51.63 199.75,50.5 194.84,50.5 194.57,50.78 191.94,50.78 191.35,51.36 v2(190.76,51.36)
  BOTTOM w0.254: U2407.4 187.39,48.61 C2504.1 187.79,49.95 188.99,51.15 190.25,51.15 190.47,51.36 v2(190.76,51.36)
REMOTE2-: length 182.6
  TOP w0.254: v2(276.03,128.83) 275.99,128.87 275.99,129.29 C2505.2 276.38,129.68 Q2408.3
  IN3 w0.254: v2(213.02,65.92) 213.02,53.66 216.9,49.78 216.9,49 v2(216.81,48.91)
  IN4 w0.254: v2(213.02,65.92) 213.74,65.92 214.32,66.5 214.32,87.58 216.5,89.75 226.47,89.75 227.28,90.56 227.28,110.61 226.51,111.37 226.51,117.15 226.96,117.59 228.36,117.59 231.38,120.62 232.48,120.62 234.01,122.15 234.16,122.15 234.92,122.9 238.87,122.9 240.31,124.34 251.04,124.34 251.98,125.28 256.93,125.28 259.25,122.95 274.25,122.95 275.99,124.69 275.99,128.21 276.03,128.25 v2(276.03,128.83)
  IN6 w0.254: v2(190.76,51.95) 190.84,51.87 191.57,51.87 192.15,51.29 194.78,51.29 195.05,51.01 199.54,51.01 200.36,51.84 200.36,52.44 203.06,55.13 207.5,55.13 210.38,52.24 210.38,50.09 210.69,49.77 215.68,49.77 216.57,48.89 216.8,48.89 216.81,48.9 v2(216.81,48.91)
  BOTTOM w0.254: v2(190.76,51.95) 190.64,51.95 190.56,51.87 190.26,51.87 190.04,51.65 188.78,51.65 187.1,49.97 R184.2 186.88,49.89 C2504.2 186.89,49 U2407.3
REMOTE3+: length 120.1
  IN6 w0.254: v2(285.78,38.98) 285.87,38.9 285.87,38.22 285.52,37.87 282.95,37.87 282.74,38.09 278.44,38.09 277.74,37.39 274.06,37.39 265.87,45.58 247.24,45.58 245.53,47.29 229.8,47.29 229.22,47.87 216.14,47.87 215.26,48.76 210.69,48.76 210.27,48.76 209.36,49.66 209.36,51.82 207.07,54.11 203.48,54.11 201.38,52.01 201.38,51.42 201.37,51.41 201.37,51.38 199.98,50 194.63,50 194.36,50.27 191.73,50.27 191.42,50.57 190.48,50.57 v2(190.41,50.64)
  BOTTOM w0.254: Q2411.1 286.14,36.17 Q2411.2 285.49,37.96 C2511.1 285.82,38.29 285.82,38.95 v2(285.78,38.98) ; v2(190.41,50.64) 190.36,50.59 189.89,50.59 189.3,50 189.3,46.65 189.38,46.58 189.38,45.94 C2510.1 188.63,45.74 187.89,46.48 U2407.5
REMOTE3-: length 117.5
  IN6 w0.254: v2(190.41,50.06) 190.42,50.07 191.21,50.07 191.52,49.76 194.15,49.76 194.42,49.49 200.19,49.49 201.88,51.17 201.88,51.19 201.89,51.21 201.89,51.8 203.69,53.6 206.86,53.6 208.85,51.61 208.85,49.45 210.06,48.25 210.48,48.25 210.48,48.25 210.9,48.25 215.05,48.25 215.93,47.36 229.01,47.36 229.59,46.78 245.32,46.78 247.03,45.07 265.66,45.07 273.85,36.88 277.95,36.88 278.65,37.58 282.53,37.58 282.74,37.37 285.73,37.37 286.38,38.01 286.38,38.98 v2(286.37,38.98)
  BOTTOM w0.254: R185.2 C2510.2 189.49,45.14 189.63,45.14 189.89,45.4 189.89,46.79 189.81,46.86 v1(189.81,49.22) 189.81,49.79 190.1,50.08 190.39,50.08 v2(190.41,50.06) ; v2(286.37,38.98) 286.33,38.95 286.33,38.29 C2511.2 286.79,37.83 Q2411.3
RESET_N: length 2.6
  BOTTOM w0.076: UT4.F11 203.63,164.37
  BOTTOM w0.107: 203.63,164.37 203.66,164.33 204.06,164.33 204.69,164.97 205.31,164.97 205.42,165.07 RT102.1
RF_+1VALWP: length 5.2
  TOP w0.102: v1(243.85,15.41) 243.85,16.04 PR306.1
  TOP w0.254: PR306.1 243.2,17.2 242.77,17.63 242.77,19.52 243.05,19.81 PU300.5
RING2: length 16.5
  TOP w0.102: v1(29.41,20.64) 29.09,20.96 v2(29.09,21.96)
  IN1 w1.016: 24.58,32.5 23.86,32.5 22.42,31.07 22.42,27.45 23.63,26.24 26.65,26.24 27.86,25.04 27.86,22.79
  vias: v2(26.15,32.88) v2(26.62,32.53) v2(28.45,21.97)
RING2_R: length 32.8
  IN1 w1.016: 27.43,20.4 26.88,20.95 24.49,20.95 23,22.44 22.08,22.44 ; JACK1.4 5.67,5.52 6.69,4.5 14.74,4.5 17.1,6.86 17.1,15.17 16.86,15.41 16.86,19.9 16.91,19.96
  vias: v1(27.56,21.01) v2(17.59,21.44) v2(17.59,20.79) v2(21.24,21.61) v2(21.83,21.61) v2(27.44,19.29) v2(28.01,19.55)
RJ45_CT:
  vias: v1(252.57,166.7) v2(262.39,166.87) v2(263.22,166.87)
RJ45_CT0: length 3.5
  TOP w0.127: v2(248.36,165.09) v1(246.96,165.09)
  TOP w0.508: RL12.1 v2(248.36,165.09)
  BOTTOM w0.508: v2(248.36,165.09) 248.38,165.11 TL1.15
RJ45_CT1: length 3.3
  TOP w0.127: v2(249.63,165.09) v1(250.81,165.09)
  TOP w0.508: RL11.1 v2(249.63,165.09)
  BOTTOM w0.508: v2(249.63,165.09) 249.65,165.11 TL1.16
RJ45_CT2: length 3.3
  TOP w0.127: v2(255.98,165.09) v1(254.78,165.09)
  TOP w0.508: RL10.1 v2(255.98,165.09)
  BOTTOM w0.508: TL1.21 256,165.11 v2(255.98,165.09)
RJ45_CT3: length 3.6
  TOP w0.127: v2(257.25,165.09) v1(258.71,165.09)
  TOP w0.508: RL9.1 257.18,165.15 v2(257.25,165.09)
  BOTTOM w0.508: v2(257.25,165.09) 257.27,165.11 TL1.22
RJ45_MDIN0: length 10.3
  BOTTOM w0.292: JLAN.2 250.03,172.47 249.79,172.23 249.79,171.8 250.47,171.12 250.47,170.38 248.94,168.85 v1(248.94,168.84) 248.93,168.84 248.92,168.82 246.77,168.82 246.36,168.42 246.36,168.16 246.64,167.88 246.94,167.88 247.11,167.72 TL1.14
RJ45_MDIN1: length 7.7
  TOP w0.292: JLAN.6 254.15,172.47 251.72,170.04 251.72,169.1 v2(251.8,169.03)
  BOTTOM w0.254: TL1.18 252.19,168.06 251.75,168.49 251.75,168.98 v2(251.8,169.03)
RJ45_MDIN2: length 7.4
  BOTTOM w0.292: TL1.20 254.73,168.31 v1(254.72,169.22) 254.72,170.23 254.05,170.91 254.05,171.73 253.82,171.95 253.82,172.63 253.81,172.65 253.81,173.48 JLAN.5
RJ45_MDIN3: length 8.5
  TOP w0.292: v2(259.04,168.2) 259.04,168.32 258.81,168.55 258.81,168.56 258.14,169.23 257.51,169.23 256.17,170.57 256.17,172.01 256.62,172.47 JLAN.8
  BOTTOM w0.292: v2(259.04,168.2) 259.1,168.27 259.6,168.27 259.81,168.06 TL1.24
RJ45_MDIP0: length 10.4
  BOTTOM w0.292: JLAN.1 249.64,172.67 249.37,172.41 249.37,171.63 250.05,170.95 250.05,170.55 248.74,169.24 246.58,169.24 v1(246.21,168.87) 245.94,168.6 245.94,167.95 245.84,167.84 TL1.13
RJ45_MDIP1: length 7.7
  TOP w0.292: JLAN.3 251.68,172.18 252.1,171.76 252.1,171.02 251.3,170.22 251.3,170.2 251.3,170.19 251.3,169.11 v2(251.21,169.03)
  BOTTOM w0.254: v2(251.21,169.03) 251.32,168.92 251.32,168.44 250.92,168.03 TL1.17
RJ45_MDIP2: length 7.5
  BOTTOM w0.292: TL1.19 253.46,167.66 254.3,168.5 254.3,169.33 254.31,169.33 254.31,170.06 253.63,170.74 253.63,171.55 253.4,171.78 253.4,172.46 253.17,172.69 252.92,172.69 JLAN.4
RJ45_MDIP3: length 8.5
  TOP w0.292: JLAN.7 255.76,172.2 255.75,172.19 255.75,170.4 v1(255.76,170.38) 257.33,168.81 257.97,168.81 258.39,168.39 v2(258.39,168.2)
  BOTTOM w0.292: TL1.23 258.54,168.06 v2(258.39,168.2)
ROM_CS#: length 39.9
  TOP w0.114: UG16.1 195.45,113.31 196.42,114.28 197.76,114.28 198.21,114.74 198.68,115.2 198.68,116.18 199.82,117.32 203.15,117.32 204.57,115.9 206.04,115.9 207.22,114.72 v2(207.36,114.72) 207.8,114.72 209.38,116.31 211.52,116.31 213.86,118.65 215.12,118.65 RG579.2
  IN6 w0.081: v2(220.77,116.45) 220.64,116.32 218.54,116.32 218.11,115.89 217,115.89 215.59,114.48 213.97,114.48 213.67,114.18 207.91,114.18 v2(207.36,114.72)
  BOTTOM w0.1: UG9.BJ4 v2(220.77,116.45)
ROM_SCLK: length 33.5
  TOP w0.114: v2(220.07,117.15) 219.6,116.68 219.21,116.68 219.07,116.54 218.36,116.54 218.06,116.84 217.16,116.84 216.85,116.53 215.71,116.53 213.1,113.92 210.01,113.92 v2(208.86,112.77)
  BOTTOM w0.1: UG9.BK3 v2(220.07,117.15)
  BOTTOM w0.114: v2(208.86,112.77) 208.29,113.34 208,113.34 206.45,114.89 206.45,115.66 205.16,116.95 202.31,116.95 201.65,116.28 201.65,115.07 RG86.1 201.32,114.32 RG148.2 200.4,112.98 199.87,112.45 199.87,110.44 199.53,110.1 v1(199.53,109.26) RG89.2 RG75.2
ROM_SI: length 31.3
  TOP w0.114: v2(200.22,109.46) 200.22,107.01 v2(199.75,106.54)
  IN6 w0.081: v2(200.22,109.46) 200.22,109.68 202.02,111.48 202.02,112.03 205.84,115.85 208.32,115.85 208.71,115.46 210.08,115.46 210.88,114.66 213.49,114.66 213.91,115.08 215.02,115.08 ; v2(219.36,117.16) 219.17,117.35 217.31,117.35 216.93,116.98
  IN6 w0.089: 215.02,115.08 215.56,115.08 216.48,116.01 216.48,116.53 216.93,116.98
  BOTTOM w0.1: UG9.BK2 v2(219.36,117.16)
  BOTTOM w0.114: RG149.2 RG87.2 RG84.1 200.35,110.3 200.35,109.59 v2(200.22,109.46) ; v2(199.75,106.54) 199.96,106.54 RG77.2
ROM_SO: length 33.4
  TOP w0.114: v2(208.69,114.58) 208.7,114.58 208.7,114.58 208.61,114.58 207.77,113.75 206.54,113.75 205.2,115.1 201.86,115.1 200.57,113.81 RG88.2 RG85.1 200.57,111.9 199.6,110.94 v1(199.18,110.94) 199.09,110.85 RG580.2 198.55,109.87 198.48,109.94 196.46,109.94 196.05,110.35 196.05,111.33 195.8,111.58 UG16.4
  IN6 w0.081: v2(208.69,114.58) 208.7,114.58 208.89,114.39 213.58,114.39 213.99,114.8 215.64,114.8 216.73,115.9 216.73,116.39 216.99,116.64 217.09,116.64 217.09,116.64 217.39,116.64 217.39,116.64 217.81,116.64 218.01,116.56 220.18,116.56 v2(220.77,117.15)
  BOTTOM w0.1: UG9.BK4 v2(220.77,117.15)
RPD_G1: length 5.3
  BOTTOM w0.076: UT4.K9 202.16,166.5 202.41,166.75 202.41,166.76 202.41,166.76 202.41,166.97 202.41,166.97 202.41,167.1 202.67,167.37 202.67,167.43 203.27,168.02 203.35,168.02
  BOTTOM w0.089: 203.35,168.02 203.71,168.39
  BOTTOM w0.102: 203.71,168.39 204.45,169.13 RT64.1 204.45,170.33 204.31,170.47 v1(204.31,170.63)
RPD_G2: length 4.2
  BOTTOM w0.076: 203.66,167.45 203.51,167.45 203.34,167.28 203.22,167.28 202.91,166.97 202.91,166.69 202.66,166.44 UT4.K10
  BOTTOM w0.127: RT65.1 205.1,168.9 205.1,168.21 v1(204.79,167.9) 204.45,167.57 203.78,167.57 203.66,167.45
RST#: length 4.2
  TOP w0.102: v1(332.71,40.85) 332.43,40.57 331.87,40.57 CE55.2 ; CE55.2 331.42,41.77 331.31,41.87 331.31,41.88 331.04,42.15 UE6.3 ; CE55.2 RE91.2
RT8812_PVCC: length 5
  BOTTOM w0.102: PC8200.1 247.97,36.81 v1(248.95,37.8)
  BOTTOM w0.203: PR8200.1 247.78,34.85 247.09,34.85 246.94,34.71 PU8200.18
  BOTTOM w0.254: PR8200.1 PC8200.1
RTC_CELL: length 96.3
  TOP w0.102: v2(300.49,30.47) 300.62,30.34 RE662.1 301.11,30.9 301.75,31.53 QE58.2 ; UE10.22 314.98,59.32 314.75,59.08 314.56,59.08 v2(314.49,59.01)
  IN1 w0.102: v2(314.49,59.01) 317.13,59.01 318.88,57.25 319.19,57.25 319.62,56.82 319.62,55.02 319.44,54.84 319.44,52.56 321.6,50.4 325.09,50.4 326.76,48.73 326.98,48.73 328.2,47.5 328.2,47.27 328.52,46.96 330.09,46.96 330.46,47.32 330.46,48.03 330.89,48.47 331.94,48.47 332.88,47.53 332.88,38.2 331.81,37.14 330.72,37.14 330.03,36.45 330.03,35.59 330.51,35.11 331.86,35.11 332.32,34.65 332.32,29.77 330.86,28.31 325.32,28.31 325.13,28.12 v2(325.13,27.8)
  IN6 w0.102: v2(300.49,30.47) 300.3,30.28 300.3,29.2 300.97,28.53 302.35,28.53 303.02,27.87 305.51,27.87 308.3,25.07 308.81,25.07 309.7,24.18 311.73,24.18 311.98,24.44 313.57,24.44 314.27,23.74 315.73,23.74 317.38,22.09 319.48,22.09 320.18,21.39 321.38,21.39 322.91,22.91 324.75,22.91 325.13,23.3 v2(325.13,27.8)
  BOTTOM w0.102: v2(300.49,30.47) v1(300.49,31.07)
RTD3_CIO_PWR_EN: length 199.5
  TOP w0.102: RT16.2 172.07,165.34 v2(171.71,165.34)
  IN1 w0.089: v2(218.38,31.04) 218.16,31.27 217.99,31.27 217.84,31.12 217.56,31.12 217.22,31.47 217.22,31.83 217.23,31.84 217.23,32.33 217.1,32.45 216.6,32.45 216.16,32.89 216.16,33.91 217.29,35.03 218.18,35.03 218.39,35.23 218.39,36 217.81,36.57 217.81,38.34 218.75,39.28 218.75,40.97 218.74,40.98 218.74,43.78 218.73,43.79 218.73,43.88
  IN1 w0.102: v2(218.56,44.05) 218.56,44.05 218.59,44.05 218.73,43.91 218.73,43.88
  IN2 w0.089: 177.88,92.9 177.88,93.71 179.26,95.09 179.26,105.21 179.53,105.49
  IN2 w0.102: 177.88,92.9 177.88,82.67 176.6,81.4 176.6,72.51 182.89,66.22 184.18,66.22 188.54,61.86 188.96,61.86 189.96,60.86 191.39,60.86 v2(191.63,61.1) ; 179.53,105.49 181.56,107.51 181.56,121.97 189.2,129.61 189.2,144.57 187.96,145.81 187.96,149.06 183.19,153.83 175.24,153.83 174.67,153.25 174.2,153.25 172.51,154.94 172.51,157.78 171.33,158.96 171.33,161.34 171.26,161.42 171.26,164.85 171.39,164.98 171.61,164.98 171.71,165.09 v2(171.71,165.34)
  IN3 w0.089: 218.72,43.88 218.77,43.82 218.77,43.43 218.19,42.85 213.75,42.85 212.73,43.88
  IN3 w0.102: 212.73,43.88 212.36,44.25 212.17,44.25 209.94,46.48 209.94,47.98 208.58,49.33 208.58,52.59 206.51,54.66 203.02,54.66 202,55.68 202,60.84 200.54,62.3 200.54,63.43 198.29,65.69 196.22,65.69 192.57,62.04 192.57,61.12 192.33,60.88 191.84,60.88 v2(191.63,61.1) ; 218.72,43.88 218.72,43.89 v2(218.56,44.06)
  BOTTOM w0.089: v2(218.38,31.04) 218.15,31.28 217.98,31.28 217.76,31.05 217.36,31.05 217.03,31.39 216.54,31.39 216.47,31.32 215.93,31.32 UH1.BF21
RTD3_CIO_PWR_EN_R: length 7.4
  TOP w0.102: RT36.2 171.45,166.26 171.61,166.42 171.61,166.76 171.85,167 172.2,167 RT16.1 172.86,166.72 172.86,167.59 173.17,167.9 173.17,168.34 173.66,168.82 173.92,168.82 174.02,168.93 175.09,168.93 175.46,169.3 175.67,169.3 175.71,169.34 UT1.F1
RTD3_USB_PWR_EN: length 204.2
  TOP w0.102: RT12.2 169.43,168.1 169.43,169.29 v1(169.52,169.39)
  TOP w0.107: v2(168.79,167.69) 169.02,167.69 RT12.2
  IN1 w0.089: v2(217.82,31.76) 217.91,31.67 217.91,31.45 217.76,31.3 217.64,31.3 217.4,31.54 217.4,31.76 217.4,31.77 217.4,32.4 217.18,32.63 216.67,32.63 216.34,32.96 216.34,33.83 217.36,34.85 218.26,34.85 218.56,35.16 218.56,36.07 217.99,36.64 217.99,38.27 218.93,39.2 218.93,41.04 218.92,41.05 218.92,43.85 218.92,43.86 218.95,43.86 218.96,43.87 218.96,43.88
  IN1 w0.102: v2(219.15,44.05) 219.02,44.05 218.96,43.99 218.96,43.88
  IN2 w0.089: 177.65,93.73 177.65,93.73 179.08,95.17 179.08,105.29 179.35,105.55 179.35,105.56 179.36,105.58
  IN2 w0.102: v2(168.79,167.69) 169.17,167.3 169.17,165.28 170.39,164.06 170.84,164.06 171.03,163.87 171.03,161.33 171.1,161.25 171.1,158.86 172.28,157.68 172.28,154.85 174.11,153.03 174.76,153.03 175.33,153.6 183.1,153.6 187.73,148.97 187.73,145.71 188.97,144.47 188.97,129.71 181.33,122.07 181.33,107.61 179.36,105.64 179.36,105.58 ; 177.65,93.73 177.65,93.73 177.65,82.77 176.37,81.49 176.37,72.41 182.79,65.99 184.08,65.99 188.44,61.63 188.87,61.63 189.87,60.63 191.53,60.63 v2(191.65,60.51)
  IN3 w0.089: 218.95,43.87 218.95,43.36 218.27,42.68 213.68,42.68 212.66,43.7 212.65,43.7 212.61,43.74 212.59,43.71 212.57,43.71 212.56,43.72
  IN3 w0.102: v2(191.65,60.51) 191.8,60.66 192.42,60.66 192.79,61.03 192.79,61.94 196.31,65.46 198.19,65.46 200.31,63.34 200.31,62.2 201.77,60.74 201.77,55.59 202.92,54.44 206.42,54.44 208.35,52.5 208.35,49.24 209.71,47.88 209.71,46.39 212.08,44.02 212.26,44.02 212.56,43.72 ; v2(219.15,44.05) 219.01,43.91 219.01,43.9 219,43.89 218.97,43.89 218.95,43.87
  BOTTOM w0.089: UH1.BE21 215.55,31.3 215.74,31.49 216.35,31.49 216.42,31.56 217.1,31.56 217.43,31.23 217.69,31.23 217.96,31.5 217.96,31.63 v2(217.82,31.76)
RTD3_USB_PWR_EN_R: length 13.9
  TOP w0.102: UT1.D4 v2(177.39,170.17)
  TOP w0.107: v2(168.74,167.09) 169.11,167.09 RT37.1 169.53,167.5 169.53,167.54 169.68,167.7 169.68,167.77 RT12.1
  IN1 w0.102: v2(177.39,170.17) 176.79,170.17 176.06,169.43 170.91,169.43 169.74,168.27 169.74,167.44 169.39,167.09 v2(168.74,167.09)
  BOTTOM w0.102: v3(169.88,167.71) 169.26,167.09 v2(168.74,167.09)
SA_SW: length 2.8
  TOP w0.102: PR5002.1 v1(180.38,137.79)
  TOP w0.508: PR5002.1 v2(181.7,139.25)
SATA_DET#: length 3.3
  TOP w0.356: RS8.2 124,11.38 v1(123.34,10.72) v2(122.56,10.72)
  BOTTOM w0.254: JHDD.19 122.42,10.87 v2(122.56,10.72)
SATA_GP0: length 165.5
  IN6 w0.089: 192.16,26.6 192.34,26.77 196.71,26.77 196.76,26.82 196.82,26.82 197.08,27.09 198.59,27.09 199.72,25.96 200.34,25.96 201.84,24.47 202.31,24.47 203.4,23.37 203.4,22.73 203.6,22.53 ; 211.49,16.96 211.65,17.12 211.65,17.12 212.04,17.52 212.55,17.52 212.87,17.84 ; v2(206.7,21.77) 206.96,21.52 206.96,19.15 207.41,18.69
  IN6 w0.102: v2(206.7,21.77) 206.7,22.09 206.51,22.28 205.97,22.28 205.97,22.29 205.74,22.29 205.49,22.53 203.6,22.53 ; v2(120.4,14.69) 122.68,16.98 125.78,16.98 128.82,20.02 160.23,20.02 162.54,22.33 162.56,22.33 163.01,22.79 179.27,22.79 181.59,25.1 182.21,25.1 183.65,26.55 185.31,26.55 187.32,28.55 189.04,28.55 189.4,28.18 189.4,27.03 189.71,26.72 189.92,26.72 191.1,25.55 191.7,25.55 192.02,25.87 192.02,26.46 192.16,26.6 ; 211.49,16.96 211.33,16.8 209.37,16.8 208.98,17.18 208.92,17.18 207.41,18.69 ; v2(234.26,18.98) 234.2,18.98 233.79,18.57 233.61,18.57 233.17,18.14 231.09,18.14 230.95,18.27 230.76,18.47 227.28,18.47 226.92,18.12 225.43,18.12 225.26,17.94 222.65,17.94 222.61,17.9 222.61,17.9 222.49,17.78 220.74,17.78 220.61,17.64 219.23,17.64 219.13,17.74 218.67,17.74 218.29,18.12 217.15,18.12 216.33,17.3 214.39,17.3 213.85,17.84 212.87,17.84
  BOTTOM w0.089: UH1.AH41 206.98,21.77 v2(206.7,21.77)
  BOTTOM w0.102: v2(234.26,18.98) 234.62,18.98 RS3.1 ; JHDD.16 120.92,12.36 121.19,12.63 121.19,13.91 v2(120.4,14.69) 120.4,14.98 117.27,18.11 107.31,18.11 103.17,13.97 97.71,13.97 97.48,14.2 v1(97.48,15.84) RS2.1
SATA_GP1: length 39.6
  IN6 w0.089: 219.18,18.93 218.46,18.93 218.13,18.6
  IN6 w0.102: 219.18,18.93 220.43,18.93 220.76,19.26 222.04,19.26 222.41,18.89 224.74,18.89 225.06,19.21 225.06,19.49 225.2,19.63 226.43,19.63 227.26,18.81 230.74,18.81 231.18,18.37 233.08,18.37 233.66,18.95 v2(233.66,19.01) ; v2(207.9,21.02) 207.9,18.8 209.5,17.2 210.89,17.2 211.91,18.22 214,18.22 214.54,17.67 215.84,17.67 216.19,18.02 216.77,18.6 218.13,18.6
  BOTTOM w0.102: v2(233.66,19.01) 234.3,19.65 v1(234.73,19.65) 235.42,19.65 R364.1 235.63,19.14 236.19,18.58 236.19,17.57 236.74,17.02 236.74,15.61 237.02,15.32 JSSD3.69
  BOTTOM w0.122: UH1.AJ43 207.62,20.74 v2(207.9,21.02)
SATA_GP3: length 97.2
  TOP w0.102: v1(274.01,7.99) R365.1
  TOP w0.107: R365.1 v2(273.19,9.07)
  IN6 w0.089: 219.18,20.06 218.64,20.06 217.61,19.03 216.69,19.03 216.24,18.58 209.8,18.58 v2(209.56,18.34)
  IN6 w0.102: v2(276.33,18.69) 276.33,19.14 275.45,20.02 272.36,20.02 272.23,20.14 267.05,20.14 266.89,20.3 266.89,20.3 266.37,20.82 260.62,20.82 255.86,25.58 250.7,25.58 248.55,23.43 248.55,18.37 248.01,17.83 246.85,17.83 246.11,17.09 242.31,17.09 241.57,17.83 241.33,18.08 236.37,18.08 234.89,19.56 233.63,19.56 233.21,19.13 233.21,18.83 232.97,18.6 231.28,18.6 230.63,19.24 227.2,19.24 226.59,19.86 223.73,19.86 222.75,20.84 221.9,20.84 221.76,20.7 220.26,20.7 219.62,20.06 219.18,20.06
  BOTTOM w0.089: v2(209.56,18.34) 209.63,18.42 UH1.AN47
  BOTTOM w0.102: v2(276.33,18.69) 276.33,17.8 276.58,17.55 276.58,11.06 277.19,10.45 277.19,9.83 276.42,9.07 v2(273.19,9.07)
  BOTTOM w0.107: JSSD2.69 273.17,9.06 v2(273.19,9.07)
SATA_GP4: length 143.1
  TOP w0.102: v1(327.97,34) 327.84,33.87 R363.1 327.37,33.06 v2(327.16,32.85)
  IN1 w0.097: 301.05,24.76 298.4,24.76 296.23,22.6
  IN1 w0.102: v2(265.41,26.77) 271.04,26.77 273.04,24.76 279.92,24.76 282.09,22.6 284.7,22.6 285.76,23.65 288.46,23.65 289.52,22.6 296.23,22.6 ; v2(327.16,32.85) 326.72,32.42 326.72,30.48 325.61,29.37 323.18,29.37 322.73,29.82 315.97,29.82 315.61,29.46 314.84,29.46 312.71,27.32 312.71,26.18 311.47,24.94 310.75,24.94 309.65,23.84 302.05,23.84 302.01,23.8 301.05,24.76
  IN3 w0.102: v2(208.85,20.3) 208.85,20.3 208.85,20.96 208.97,21.09 209.71,21.09 209.81,21.19 209.81,22.22 210.18,22.58 210.8,22.58 211.16,22.94 211.66,22.94 212.37,22.23 213.28,22.23 213.46,22.41 214.96,22.41 216.34,21.02 217.64,21.02 217.82,21.2 219.83,21.2 219.91,21.12 220.45,21.12 220.48,21.09 222.98,21.09 223.14,20.93 223.14,20.93 224.27,19.81 226.38,19.81 227.01,19.18 230.95,19.18 231.56,18.57 235.12,18.57 236.86,20.31 236.86,20.73 242.37,26.24 246.08,26.24 247.89,28.06 248.09,28.06 249.56,29.52 260.15,29.52 260.16,29.53 263.37,29.53 265.41,27.49 v2(265.41,26.77)
  BOTTOM w0.107: JSSD1.69 327.11,32.91 v2(327.16,32.85)
  BOTTOM w0.122: UH1.AM46 209.09,19.37 209.14,19.43 209.14,19.66 208.85,19.96 208.85,20.3 v2(208.85,20.3)
SATA_PRX_C_DTX_N0: length 11.1
  BOTTOM w0.107: JHDD.1 113.42,12.27 113.6,12.44 113.6,12.67 113.32,12.94 112.59,12.94 111.78,12.13 v4(105.29,12.13) 105.04,12.13 104.85,12.32 104.85,12.84 CH229.1
SATA_PRX_C_DTX_P0: length 11
  BOTTOM w0.107: JHDD.2 113.92,12.27 113.8,12.39 113.8,12.75 113.41,13.15 112.51,13.15 111.7,12.34 105.61,12.34 105.58,12.36 105.16,12.36 105.05,12.47 105.05,12.86 CH230.1
SATA_PRX_DTX_N0: length 96.7
  IN3 w0.127: v2(106.46,15.23) 106.5,15.2 106.5,14.53 106.75,14.28 109.79,14.28 114.46,18.95 135.65,18.95 136.44,19.74 183.9,19.74 184.11,19.94 185.76,19.94 186.09,19.61 189.31,19.61 190.16,18.76 193.28,18.76 193.56,18.48 194.52,18.48 195.33,19.29 v2(195.33,19.36)
  BOTTOM w0.089: UH1.C45 195.26,19.43 v2(195.33,19.36)
  BOTTOM w0.107: v2(106.46,15.23) 106.69,15.01 106.69,14.91 106.38,14.6 105.3,14.6 104.87,14.17 104.87,13.83 CH229.2
SATA_PRX_DTX_P0: length 96.7
  IN3 w0.127: v2(107.07,15.23) 107.06,15.23 106.72,14.89 106.72,14.62 106.84,14.5 109.7,14.5 114.37,19.17 135.56,19.17 136.35,19.96 183.81,19.96 184.02,20.16 185.85,20.16 186.18,19.83 189.4,19.83 190.25,18.98 193.36,18.98 193.36,18.97 193.37,18.97 193.65,18.7 194.43,18.7 194.85,19.11 194.85,19.29 194.72,19.42 v2(194.32,19.42)
  BOTTOM w0.089: UH1.C46 194.69,19.12 194.69,19.2 194.57,19.32 194.57,19.36 194.48,19.45 194.35,19.45 v2(194.32,19.42)
  BOTTOM w0.107: CH230.2 105.07,13.77 105.07,14.09 105.38,14.4 106.46,14.4 106.89,14.83 106.89,15.05 v2(107.07,15.23)
SATA_PTX_C_DRX_N0: length 98.4
  IN3 w0.127: v2(107.28,17.13) 107.32,17.09 107.32,16.66 107.64,16.35 110.66,16.35 114.21,19.9 135.42,19.9 136.06,20.54 183.6,20.54 184.14,21.07 186.32,21.07 188.03,22.78 188.26,23.01 v2(188.26,25.07)
  BOTTOM w0.107: JHDD.4 114.92,12.4 115.06,12.54 115.06,13.13 112.13,16.06 107.57,16.06 107.28,16.35 v2(107.28,17.13) ; CH227.1 188.13,24.63 188.13,24.95 v2(188.26,25.07)
SATA_PTX_C_DRX_P0: length 98.5
  IN3 w0.127: v2(187.68,25.1) 187.84,24.92 187.84,24.9 188.03,24.71 188.03,23.09 187.73,22.8 186.23,21.29 184.05,21.29 183.51,20.76 135.97,20.76 135.33,20.12 114.12,20.12 110.57,16.56 107.73,16.56 107.54,16.75 107.54,16.81 107.7,16.96 107.7,16.97 v2(107.86,17.13)
  BOTTOM w0.107: v2(107.86,17.13) 107.86,17.13 107.48,16.76 107.48,16.44 107.66,16.26 112.21,16.26 115.26,13.21 115.26,12.5 115.42,12.34 JHDD.5 ; v2(187.68,25.1) 187.76,25.1 187.85,25 187.85,24.9 187.93,24.83 187.93,24.74 187.93,24.74 187.93,24.58 187.82,24.48 CH228.1
SATA_PTX_DRX_N0: length 8.5
  BOTTOM w0.089: 193.33,23.11 193.58,22.86 193.68,22.86 193.75,22.92 193.75,22.98 193.81,23.04 193.94,23.04 194.12,22.86 194.3,22.86 194.41,22.96 194.41,23.04 194.32,23.13 UH1.B38
  BOTTOM w0.107: CH227.2 188.25,23.93 188.06,23.93 187.95,23.82 187.95,23.54 188.07,23.42 188.45,23.42 188.94,23.91 189.77,23.91 190.7,22.98 v4(191.07,22.98) 192.06,22.98 192.2,23.11 192.48,23.11 192.6,23.23 192.92,23.23 193.04,23.11 193.33,23.11
SATA_PTX_DRX_P0: length 8.6
  BOTTOM w0.089: UH1.C38 194.75,23.03 194.58,22.88 194.37,22.68 193.49,22.68 193.27,22.91
  BOTTOM w0.107: CH228.2 187.71,23.77 187.71,23.44 187.94,23.22 188.54,23.22 188.99,23.68 v4(189.37,23.68) 189.71,23.68 190.64,22.75 191.33,22.75 191.36,22.78 192.15,22.78 192.28,22.91 193.27,22.91 193.27,22.91
SCL_CHG: length 2.8
  TOP w0.102: v1(53.84,21.93) PR721.2
  TOP w0.203: PR721.2 54.04,22.92 54.75,23.63 PU700.12
SD_RCOMP_1P8: length 4.3
  TOP w0.089: v2(214.79,39.37) 215.15,39.37 v1(215.35,39.56) 215.53,39.74 216.32,39.74 217.01,40.44 RH214.1
  BOTTOM w0.122: UH1.BE5 v2(214.79,39.37)
SD_RCOMP_3P3: length 7.3
  TOP w0.089: RH215.1 217.34,40.62 216.66,40.62 v1(216.58,40.54) 216.01,39.97 214.61,39.97 214.43,39.79 214.43,39.22 214.66,38.98 214.86,38.98 214.89,39.01 215.6,39.01 v2(215.91,39.32)
  BOTTOM w0.089: UH1.BE4 215.91,39.44 v2(215.91,39.32)
SDA_CHG: length 1.7
  TOP w0.203: PR720.2 54.3,23.81 54.53,24.03 PU700.11
SENSE_VCCIO: length 3.2
  BOTTOM w0.102: v1(124.06,122.49) 123.71,122.85 PR5012.1
  BOTTOM w0.254: PR5012.1 123.71,123.41 PR5014.2 124.68,123.46 PR5017.1
SERIRQ: length 125.4
  TOP w0.089: RH111.1 214.79,26.46 v1(214.41,26.84) 214.22,27.03 v2(214.22,27.33)
  TOP w0.102: v2(301.81,17.33) 302.23,17.75 302.23,19.84 302.56,20.16 302.82,20.16 303.23,20.57 303.23,22.34 304.74,23.85 UE5.3
  IN2 w0.089: v2(214.22,27.33) 214.75,27.33 214.99,27.09 215.25,27.09 215.31,27.03 217.34,27.03 217.54,27.23 217.84,27.23 218.05,27.01 218.05,26.81 218.49,26.36 218.92,26.36 219.13,26.57 219.13,26.76 219.18,26.81
  IN2 w0.102: v2(301.81,17.33) 301.81,17.18 300.45,15.82 298.75,15.82 298.42,16.16 297.93,16.16 297.31,15.54 296.61,15.54 295.82,16.32 293.74,16.32 293.35,16.72 292.83,17.24 280.63,17.24 277.11,20.76 276.4,20.76 276.04,21.11 275.77,21.38 274.08,21.38 270.85,24.6 269.76,24.6 268.56,23.4 266.34,23.4 265.81,23.92 265.81,24.3 265.81,24.85 265.24,25.43 261.56,25.43 260.6,24.46 260.59,24.46 260.18,24.05 258.1,24.05 255.9,26.25 248.35,26.25 248.27,26.18 248.27,26.18 247.87,25.78 247.72,25.63 247.72,21.48 247.72,21.48 247.72,21.36 247.76,21.32 247.76,20.85 247.57,20.66 247.57,18.7 247.47,18.6 247.47,18.55 247.23,18.32 245.73,18.32 245.58,18.16 237.1,18.16 237.03,18.09 236.03,17.09 230.38,17.09 227.91,19.56 226.72,20.75 226.72,21.62 224.84,23.5 224.84,24.89 222.5,27.23 219.6,27.23 219.18,26.81
  BOTTOM w0.089: v2(214.22,27.33) 214.22,27.27 214.32,27.17 214.32,26.42 214.33,26.42 214.33,26.12 213.98,25.77 213.94,25.77 212.68,24.51 UH1.AW35
SLEEVE: length 10.7
  IN1 w1.016: 28.62,32.76 28.62,28.58 31.48,25.73 31.48,24.54 30.55,23.61
  vias: v1(28.53,22.48) v2(27.09,32.91) v2(27.69,32.91) v2(29.28,23.61) v2(29.28,22.98)
SLEEVE_R: length 33.1
  TOP w0.102: v2(30.23,22.79) v1(30.23,22.23)
  IN3 w1.016: 20.38,20.82 20.38,21.96 20.93,22.51 22.24,22.51 22.31,22.44 23.15,22.44 24.58,21.01 29.25,21.01 ; 17.09,17.64 17.09,6.98 14.65,4.54 8.99,4.54 8.27,5.26 JACK1.3
  vias: v2(17.73,18.86) v2(17.73,18.28) v2(20.2,19.92) v2(20.79,19.9) v2(30.87,22.79)
SLP_S3: length 78.9
  TOP w0.114: QE1.3 323.92,42.85 323.23,42.16 v2(323.23,42.1) ; RE15.2 290.82,29.09 v1(290.82,27.61) 290.82,26.74 293.11,24.46 293.53,24.46 294.47,23.52 294.47,21.03 294.85,20.65 294.85,18.09 v2(294.61,17.85) ; UE1.12 319.3,10.33 319.5,10.13 v2(319.79,10.13)
  IN1 w0.081: v2(313.51,17.45) 313.22,17.74 312.52,17.74 311.22,16.44 306.97,16.44 306.12,17.29 304.3,17.29 303.68,16.66 300.72,16.66 299.8,17.58 299.14,17.58 299.07,17.65 298.36,17.65 298.29,17.58 294.88,17.58 v2(294.61,17.85)
  IN3 w0.127: v2(313.51,17.45) 313.57,17.39 313.8,17.39 313.93,17.53 314.16,17.53 314.33,17.71 314.33,17.96 316.87,20.5 316.87,26.09 317.98,27.2 317.98,32.2 323.16,37.38 323.16,39.24 322.78,39.62 322.78,41.65 v2(323.23,42.1)
  BOTTOM w0.114: v2(313.51,17.45) 313.64,17.58 314.38,17.58 314.96,17.01 314.96,10.8 315.63,10.13 v2(319.79,10.13)
SLP_S5: length 53.9
  TOP w0.114: UE1.11 318.79,10.26 319.39,9.67 320.1,9.67 320.43,10 v2(320.43,10.13) ; RE16.2 322.91,47.41 322.91,47.06 QE4.3 322.64,46.78 321.98,46.12 v2(321.98,45.98)
  IN3 w0.127: v2(313.61,16.76) 313.56,16.76 312.76,17.56 312.76,18.68 313.7,19.62 314.75,19.62 315.98,20.86 315.98,26.06 315.81,26.24 315.81,27.11 316.19,27.49 316.19,27.87 315.24,28.83 315.24,29.91 317.09,31.77 317.09,32.57 321.6,37.08 321.6,39.02 322.39,39.81 322.39,43.26 322.56,43.44 322.56,43.79 321.98,44.37 v2(321.98,45.98)
  BOTTOM w0.114: v2(313.61,16.76) 313.76,16.76 314.7,15.81 314.7,10.67 315.67,9.71 320.05,9.71 320.43,10.09 v2(320.43,10.13)
SM_PG_CTRL: length 53.1
  TOP w0.102: 102.46,47.53 100.28,49.71 98.56,49.71 v2(98.12,49.27)
  TOP w0.127: 102.46,47.53 103.76,47.53 109.52,53.29 109.52,56.73 109.48,56.77 109.48,59.36 116.34,66.22 116.34,75.95 117.04,76.64 v1(122.59,76.64) RH525.2 124.85,77.2 124.85,77.98 124.28,78.55 UC2.4
  BOTTOM w0.254: v2(98.12,49.27) 96.97,49.27 96.85,49.14 PR211.2
SMBALERT#: length 6.8
  TOP w0.089: v2(214.64,30.6) 214.45,30.41 213.43,30.41 v1(213.3,30.54) 213.13,30.71 212.67,30.71 211.3,29.33 211.28,29.33 210.77,28.82 RH95.2
  BOTTOM w0.089: v2(214.64,30.6) 214.89,30.6 215.13,30.36 215.22,30.36 215.39,30.19 215.39,29.99 215.37,29.97 UH1.BE25
SML0CLK: length 208.8
  IN1 w0.081: v2(166.64,156.94) 166.61,156.94 166.61,156.95 166.33,157.22 166.33,157.45 166.41,157.53 167.14,157.53 169.66,155.02 182.75,155.02 183.11,154.66 184.85,154.66 185.48,154.03 186,154.03 193.48,146.55 193.48,137.01 192.69,136.22 191.76,136.22 188.65,133.11 188.65,124.92 186.84,123.11 186.84,115.88 184.22,113.26 184.22,97.55 187.33,94.43 187.33,89.76 185.11,87.53 185.11,75.15 185.13,75.13 185.13,72.08 185.06,72.01 185.06,68.96 185.63,68.39 185.63,68.2 185.63,67.7 189.42,63.92 189.42,62.66 189.02,62.27 189.02,56.73 189.27,56.48 189.27,53.99 188.23,52.96 188.23,44.5 191.38,41.35 192.28,41.35 192.45,41.18 193.1,41.18 193.1,41.18 193.23,41.18 193.61,40.8 193.61,39.37 193.61,39.37 193.61,39.31 193.71,39.21 193.72,39.21 195.07,37.86 195.72,37.86 196.39,37.18 196.39,36.99 196.63,36.75 196.63,35.73 197.83,34.53 197.83,33.94 198.62,33.15 198.62,32.99 198.87,32.73 198.87,31.64 199.54,30.98 200.25,30.98 200.54,30.69 201.63,30.69 201.94,30.99 201.94,32.35 202.26,32.67 206.23,32.67 207.8,31.11 207.91,31.11 208.32,30.69 208.32,26.23 208.5,26.05 211.52,26.05 212.74,24.83 214.37,24.83 215.4,23.81 215.4,23.8 215.5,23.7 215.55,23.7 215.55,23.7 215.57,23.7
  IN1 w0.089: v2(217.37,29.34) 217.37,29.27 217.63,29.01 217.75,29.01 217.99,28.77 217.99,28.31 217.8,28.12 216.69,28.12 216.48,27.91 216.48,27.42 217.01,26.9 217.07,26.9 217.42,26.55 217.42,24.64 217.46,24.6 217.46,24.04 217.12,23.7 215.57,23.7
  BOTTOM w0.089: 219.18,31.16 219.17,31.16 219.12,31.11 219.1,31.11 219.09,31.09 219.01,31.09 218.93,31.01 218.87,31.01 218.08,30.23 218.08,29.35 217.87,29.14 217.57,29.14 v2(217.37,29.34) 217.37,29.34 217.23,29.2 217.05,29.2 217,29.24 216.58,29.24 216.51,29.18 216.09,29.18 215.87,29.39 UH1.BF25
  BOTTOM w0.114: v2(166.64,156.94) 166.3,157.28 166.3,158.47 166.05,158.73 165.45,158.73 165.34,158.84 UM4.11 ; 219.18,31.16 219.27,31.16 219.41,31.3 219.41,31.69 219.67,31.94 219.85,31.94 RH501.2
SML0DATA: length 209.2
  IN1 w0.081: 215.57,23.88 214.44,25 212.81,25 211.59,26.22 208.57,26.22 208.49,26.3 208.49,30.76 207.98,31.28 207.87,31.28 206.3,32.84 202.19,32.84 201.77,32.42 201.77,31.06 201.56,30.86 200.61,30.86 200.32,31.15 199.61,31.15 199.04,31.72 199.04,32.81 198.79,33.06 198.79,33.22 198,34.01 198,34.6 196.8,35.8 196.8,36.82 196.56,37.06 196.56,37.25 195.79,38.03 195.14,38.03 193.79,39.39 193.79,40.88 193.27,41.39 193.09,41.39 193.09,41.39 192.53,41.39 192.36,41.56 191.46,41.56 188.44,44.58 188.44,52.87 189.48,53.91 189.48,56.56 189.23,56.81 189.23,62.18 189.62,62.58 189.62,64.01 185.84,67.79 185.84,68.11 185.84,68.11 185.84,68.47 185.27,69.05 185.27,71.92 185.34,72 185.34,75.21 185.32,75.24 185.32,87.44 187.54,89.67 187.54,94.52 184.43,97.64 184.43,113.17 187.05,115.8 187.05,123.02 188.86,124.83 188.86,133.02 191.84,136.01 192.77,136.01 193.68,136.92 193.68,146.64 186.09,154.24 185.56,154.24 184.93,154.87 183.19,154.87 182.84,155.23 169.74,155.23 167.23,157.74 166.33,157.74 166.12,157.54 166.12,157.02 v2(166.05,156.94)
  IN1 w0.089: v2(217.37,28.76) 217.45,28.83 217.68,28.83 217.81,28.7 217.81,28.39 217.72,28.3 216.62,28.3 216.3,27.98 216.3,27.35 216.93,26.72 217,26.72 217.24,26.47 217.24,24.57 217.29,24.52 217.29,24.11 217.05,23.88 215.57,23.88
  BOTTOM w0.089: UH1.BE24 215.13,29.6 215.1,29.57 215.1,29.3 215.24,29.16 215.85,29.16 216.01,29 216.58,29 216.65,29.07 216.93,29.07 216.97,29.02 217.1,29.02 v2(217.37,28.76) 217.58,28.96 217.95,28.96 218.26,29.28 218.26,30.15 218.94,30.84 219,30.84 219.08,30.92 219.18,30.92
  BOTTOM w0.114: v2(166.05,156.94) 166.06,156.95 166.06,158.37 165.95,158.49 165.49,158.49 165.34,158.33 UM4.10 ; 219.18,30.92 219.37,30.92 219.66,31.2 219.66,31.59 219.77,31.7 219.96,31.7 RH502.2
SML1CLK: length 50.3
  IN2 w0.089: v2(219.09,30.47) 218.89,30.28 218.64,30.28 218.24,30.68 218.23,30.68 218.02,30.89 218.02,30.89 218,30.91 218,30.93 217.31,31.62 217.29,31.62 217.29,31.63 216.31,31.63 214.91,30.24 213.73,30.24 213.05,30.92 212.55,30.92 211.29,29.66 210.84,29.66 210.32,29.14 209.11,29.14 208.68,29.57 207.39,29.57 207.02,29.2 207.02,26.72 206.62,26.33 201.28,26.33 200.22,27.38 199.95,27.38 196.24,31.09 193.8,31.09 193.38,30.67 193.38,29.82 193.27,29.71 193.17,29.71 v2(192.98,29.9)
  BOTTOM w0.089: v2(219.09,30.47) 218.89,30.28 218.7,30.28 218.47,30.05 218.47,28.9 217.87,28.29 216.02,28.29 215.94,28.21 UH1.BF27
  BOTTOM w0.114: v2(192.98,29.9) 192.98,29.81 192.84,29.66 192.46,29.66 192.11,30.01 192.11,30.52 190.69,31.94 190.69,33.11 190.1,33.7 188.68,33.7 188.22,33.24 188.22,32.75 188.1,32.63 187.89,32.59 187.56,32.92 187.45,32.96 QH5.6 ; RH460.2 219.92,30.28 219.29,30.28 v2(219.09,30.47)
SML1DATA: length 50.7
  IN2 w0.089: v2(192.98,29.31) 193.2,29.53 193.34,29.53 193.56,29.75 193.56,30.6 193.87,30.92 196.16,30.92 199.88,27.2 200.15,27.2 201.2,26.15 206.7,26.15 207.2,26.65 207.2,29.13 207.46,29.39 208.61,29.39 209.04,28.96 210.39,28.96 210.92,29.48 211.36,29.48 212.62,30.74 212.98,30.74 213.65,30.06 214.99,30.06 216.38,31.45 217.21,31.45 217.22,31.44 217.24,31.44 217.83,30.85 217.83,30.84 217.84,30.82 217.84,30.82 218.16,30.5 218.16,30.5 218.56,30.1 218.89,30.1 v2(219.08,29.9)
  BOTTOM w0.089: 219.18,29.99 v2(219.08,29.9) 218.89,30.1 218.78,30.1 218.65,29.98 218.65,28.82 217.93,28.1 216.14,28.1 215.98,27.94 215.61,27.94 215.34,28.21 UH1.BE27
  BOTTOM w0.114: RH461.2 219.88,30.04 219.22,30.04 219.18,29.99 ; v2(192.98,29.31) 192.84,29.46 192.38,29.46 191.91,29.93 191.91,30.38 190.45,31.84 190.45,33.01 190,33.46 188.78,33.46 188.46,33.14 188.46,32.65 188.29,32.47 188.23,32.38 188.27,32.15 QH5.3
SNB_1.0VS_VGAP: length 1
  BOTTOM w0.102: PC802.1 v1(247.8,48.11)
SNB_1.2V: length 1.8
  TOP w0.102: PR202.2 v1(99.39,37.39)
SNB_3V: length 0.9
  TOP w0.102: 43.29,31.32 43.13,31.32 v1(42.6,30.8)
SNB_5V: length 1.7
  TOP w0.102: PR111.2 42.35,33.9 v1(42.35,32.57)
SNB_+1.8VGS: length 1
  BOTTOM w0.254: PC806.1 234.25,45.65 PR809.2
SNB_+1VALWP: length 2.1
  BOTTOM w0.102: v1(259.47,21.73) 258.05,20.31 PR305.2
SNB_VCCIO: length 3.9
  BOTTOM w0.102: v1(119.9,110.33) 119.48,109.91 PC591.1
  BOTTOM w0.508: PC591.1 118.37,109.98 PR5009.2
SNUB_CHG: length 2.3
  TOP w0.102: v1(66.44,19.84) 66.35,19.84 64.8,21.39
SPEAKER_SEL: length 376.4
  TOP w0.102: v2(43.32,17.39) v1(43.32,16.49) ; UE10.2 316.76,56.96 v2(316.49,56.7)
  IN3 w0.102: v2(312.62,8.63) 312.62,9.13 315.06,11.57 321.42,11.57 321.53,11.46 322.56,11.46 323.1,11.99 323.1,13.26 323.99,14.15 325.45,14.15 326.25,14.95 331.16,14.95 335.91,19.7 335.91,47.73 334.37,49.27 320.4,49.27 316.49,53.17 v2(316.49,56.7)
  IN6 w0.102: v2(43.32,17.39) 43.8,17.87 48.88,17.87 50.14,16.61 54.77,16.61 57.74,13.64 103.78,13.64 109.17,8.25 138.44,8.25 139.45,7.23 172.28,7.23 174.87,9.82 174.87,10.61 177.03,12.78 182.44,12.78 186.01,9.21 186.92,9.21 188.1,8.03 189.09,8.03 189.36,7.76 189.63,7.49 192.51,7.49 193.69,6.32 203.12,6.32 203.38,6.05 230.37,6.05 230.63,6.32 230.75,6.44 256.08,6.44 258.03,8.38 258.03,9.28 260.59,11.84 272.15,11.84 272.49,12.18 279.88,12.18 282.39,9.67 294.31,9.67 297.48,12.84 301.27,12.84 304.9,9.21 312.04,9.21 v2(312.62,8.63)
  BOTTOM w0.102: JSPK.5 47.18,17.21 47.03,17.36
  BOTTOM w0.107: v2(43.32,17.39) 43.95,18.02 46.36,18.02 47.03,17.36
SPI_CLK: length 252.9
  TOP w0.114: v2(322.23,13.87) 321.94,13.58 UE1.15
  IN1 w0.081: v2(245.94,16.18) 246.01,16.18 246.01,16.19 246.58,16.75 250.96,16.75 251.58,17.38 254.99,17.38 255.78,18.16 258.87,18.16 259.74,17.29 259.74,16.91 259.74,16.9 259.74,16.46 260.69,15.52 264.72,15.52 265.31,16.1 271.51,16.1 271.66,16.24 275.54,16.24 277.06,17.77 278.82,17.77 281.99,20.94 297.55,20.94 298.38,21.77 303.34,21.77 304.05,22.48 309.33,22.48 310.01,23.16 v2(312.75,23.16)
  IN4 w0.127: v2(225.56,19.04) 225.94,19.04 226.53,18.46 235.43,18.46 236.43,17.45 240.09,17.45 242.06,15.48 245.75,15.48 245.94,15.68 v2(245.94,16.18)
  IN6 w0.081: v2(225.56,19.04) 225.56,18.91 225.06,18.41 222.46,18.41 222.41,18.37 222.41,18.37 222.29,18.25 219.33,18.25 219.26,18.18 219.18,18.18 219.18,18.17 ; 191.87,26.95 190.69,26.95 190.03,27.61 190.03,28.26 189.26,29.02 187.12,29.02 186.35,28.25 184.48,28.25 182.1,25.87 116.78,25.87 114.52,28.14 108.05,28.14 107.3,28.88 104.4,28.88 103.7,29.58 100.77,29.58 v2(100.46,29.27)
  IN6 w0.089: 219.18,18.17 219.13,18.13 218.79,18.13 218.58,18.34 217.12,18.34 216.26,17.48 214.47,17.48 213.93,18.02 212.16,18.02 211.15,17.01 209.43,17.01 207.21,19.23 207.21,21.96 206.7,22.47 206.05,22.47 206.05,22.47 205.81,22.47 205.57,22.71 205.42,22.71 203.67,22.71 203.58,22.8 203.58,23.44 202.38,24.65 201.91,24.65 200.34,26.22 199.84,26.22 198.8,27.26 197.01,27.26 196.74,27 196.69,27 196.64,26.95 191.87,26.95
  BOTTOM w0.114: v2(100.46,29.27) 100.14,28.95 100.12,28.95 RE22.1 99.32,27.26 ; v2(312.75,23.16) 313.42,22.49 313.42,20.98 316.11,18.29 316.11,14.02 316.55,13.58 321.94,13.58 v2(322.23,13.87)
