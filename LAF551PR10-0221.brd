# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5VS_TP_LED: length 116.9
  TOP w0.508: R147.1 v2(110.04,27.49) ; R154.1 v2(117.74,24.97) ; R150.1 115.95,25.91 115.51,25.48 v2(115.13,25.48) 115.13,23.85 114.56,23.28 111.98,23.28 R144.1 R145.1 ; R146.1 v2(112.49,25.35)
  TOP w1.016: 201.56,9.39 200.73,10.21 200.73,11.67 v3(199.84,12.56) 197.43,12.56
  IN1 w0.508: v2(110.04,27.49) 110.04,25.99 110.68,25.35 v2(112.49,25.35) 112.87,25.73 114.88,25.73 v2(115.13,25.48) 115.64,24.97 v2(117.74,24.97) 117.74,25.33 118.44,26.03 125.55,26.03 128.41,28.88 173.95,28.88 178.25,24.58 178.25,20.74 184.04,14.96 184.82,14.96 185.37,15.5 186.67,15.5 187.98,14.18 188.32,14.18 v2(188.86,13.64)
  IN3 w0.508: v2(188.86,13.64) 189.18,13.33 190.89,13.33 191.83,12.39 196.02,12.39 196.22,12.18
  vias: v2(196.8,11.74) v2(197.38,11.74)
+AVDD09: length 4.4
  TOP w0.203: UU2.46 19.57,49.33 19.69,49.2 v2(19.69,49.08) ; v2(17.9,49.19) 17.9,49.24 17.97,49.31 UU2.42 ; UU2.1 21.54,50.94 22.01,50.47 22.04,50.47
  TOP w0.508: 22.04,50.47 22.86,49.66 22.86,49.39 v2(22.84,49.39)
  vias: v1(18.04,48.49) v2(22.03,56.82) v2(22.61,56.82)
+AVDDH: length 16.8
  TOP w0.203: v2(275.95,161.27) 276.65,161.27 v1(276.77,161.15)
  TOP w0.508: v2(275.95,161.27) 275.44,161.27 CL6.1 275.34,162.26 CL5.1
  IN6 w0.508: v2(267.04,160.84) 267.44,160.43 274.86,160.43 275.7,161.27 v2(275.95,161.27)
  BOTTOM w0.203: UL1.22 268.85,162.04 268.27,161.46 CL7.1 ; v2(275.95,161.27) 275.96,161.28 275.96,161.56 275.49,162.04 UL1.9
  BOTTOM w0.508: v2(267.04,160.84) 267.38,161.18 CL7.1
+AVDDL: length 10.6
  TOP w0.203: v2(275.98,163.11) 276,163.08 276.91,163.08 v1(277.05,163.22)
  TOP w0.508: v2(271,159.62) 271.02,159.59 CL25.1 ; v2(275.98,163.11) 275.94,163.15 CL18.1 275.34,163.15 CL19.1 ; v2(273.4,158.85) 273.43,158.88 CL24.1
  BOTTOM w0.203: UL1.13 v2(273.4,158.85) ; v2(271.71,167.06) 271.71,166.84 271.8,166.76 UL1.34 ; UL1.6 275.56,163.24 275.68,163.12 275.97,163.12 v2(275.98,163.11) ; UL1.31 v2(270.6,167.02) ; UL1.19 v2(271,159.62)
+DVDD09: length 13.8
  TOP w0.203: v2(14.3,51.36) 14.67,51.74 UU2.34 ; UU2.4 21.77,52.14 21.98,51.93 v2(22.17,51.93)
  IN2 w0.254: v2(22.17,51.93) 21.47,51.93 20.2,50.66 17.15,50.66 16.46,51.36 v2(14.3,51.36)
  BOTTOM w0.102: v1(16.42,48.83) 16.24,49.01 16.24,49.69 15.42,50.5 LU17.1
  BOTTOM w0.457: v2(22.17,51.93) 21.74,51.93 21.48,52.19 CU89.1
+DVDDL: length 3.6
  TOP w0.508: v2(273.36,167.1) 273.38,167.09 CL43.1 CL44.1
  BOTTOM w0.102: v2(273.36,167.1) 273.36,167.17 v1(273.87,167.68)
  BOTTOM w0.203: v2(273.36,167.1) 273.36,166.91 273,166.54 UL1.37
+PVDD: length 11.4
  TOP w0.203: UA4.48 33.45,7.23 v2(33.04,6.82) ; CA54.1 37.99,6.77 ; UA4.37 30.04,11.01 29.6,11.46 ; v2(39.57,8.83) 39.71,8.83 v3(40.26,8.28) ; UA4.51 34.65,7.05 v2(34.86,6.85)
  TOP w0.381: 29.6,11.46 29.61,11.47 29.61,11.86
  TOP w0.508: v2(27.12,11.74) 27.19,11.74 27.31,11.86 27.47,11.86 CA62.1 CA63.1 29.33,12.14 29.61,11.86 ; v2(38.3,7.42) 38.3,6.91 CA54.1
  BOTTOM w0.508: CA52.1 38.3,8.56 38.57,8.83 v2(39.57,8.83) ; v2(27.12,11.74) 28.27,11.74 CA61.1
  vias: v2(31,7.36)
+VCC_CORE: length 64.9
  TOP w0.254: PR597.1 175.7,135.12 v2(175.81,135.23) ; v2(167.45,136.33) 167.42,136.35 166.66,136.35 166.09,135.79 PR579.1 ; PR559.1 v2(151.48,138.55) 153.34,138.55 156.88,135 159.04,135 PR569.1 159.22,135.23 v2(159.22,136.02)
  IN1 w0.254: v2(130.31,135) 130.51,135.21 142.27,135.21 142.82,135.75 143.68,135.75 146.14,138.2 148.62,138.2 148.83,138 150.94,138 v2(151.48,138.55)
  BOTTOM w0.203: v2(167.22,103.32) 167.27,103.26 UC1.K13 ; v2(167.22,103.32) 167.33,103.42 UC1.K14 ; v2(167.22,103.32) 167.1,103.2 UC1.L13 ; v2(163.47,103.52) 163.79,103.2 UC1.P13 ; v2(163.47,103.52) 163.79,103.85 UC1.P14 ; v2(163.47,103.52) 163.14,103.2 UC1.R13 ; UC1.AA13 158.3,103.2 v2(157.98,103.52) ; UC1.N13 164.67,103.2 v2(164.36,103.51) 164.7,103.85 UC1.N14 ; UC1.AD14 156.7,103.85 v2(157.03,103.52) 156.7,103.2 UC1.AD13 ; v2(157.98,103.52) 157.65,103.2 UC1.AC13 ; v2(157.98,103.52) 157.65,103.85 UC1.AC14 ; UC1.L14 166.57,103.85 v2(166.25,103.53) ; UC1.AE13 155.86,103.2 v2(156.17,103.51) 155.83,103.85 UC1.AE14 ; UC1.V13 UC1.V14 161.32,103.85 v2(161.66,104.18) ; v2(159.83,104.18) 160.16,103.85 UC1.W14 UC1.W13
  BOTTOM w0.254: v2(151.48,138.55) 151.02,138.09 PL501.2 ; PR521.1 128.81,137.04 129.12,136.73 130.01,136.73 130.31,136.43 v2(130.31,135) ; UC1.N38 164.54,122.35 v2(164.47,122.35) ; v2(159.22,136.02) 159.22,137.04 159.52,137.34 PL502.2 ; 176.93,133.19 176.93,135.09 176.75,135.27 175.86,135.27 v2(175.81,135.23) ; v2(167.45,136.33) 167.45,137.09 167.19,137.34 PL503.2
  vias: v2(146.64,105.8) v2(147.02,107.87) v2(147.02,106.6) v2(147.25,105.21) v2(147.28,109.17) v2(147.27,105.84) v2(147.61,113.24) v2(147.74,115.17) v2(147.76,114.56) v2(147.94,104.17) v2(148.06,137.12) v2(148.05,136.5) v2(148.05,135.87) v2(148.05,135.23) v2(148.04,111.86) v2(148.07,110.42) v2(148.19,113.24) v2(148.64,137.12) v2(148.63,136.5) v2(148.63,135.87) v2(148.63,135.23) v2(148.73,121.69) v2(148.73,120.38) v2(148.73,117.78) v2(148.83,103.52) v2(149.08,105.84) v2(149.39,107.87) v2(149.39,106.6) v2(149.51,122.34) v2(149.51,121.04) v2(149.51,119.73) v2(149.51,118.43) v2(149.5,117.8) v2(149.69,105.84) v2(149.75,103.52) v2(149.79,104.18) v2(149.88,112.14) v2(149.88,110.81) v2(149.88,109.54) v2(150.17,114.01) v2(150.3,122.34) v2(150.3,120.38) v2(150.3,117.78) v2(150.8,114.01) v2(151.09,121.69) v2(151.09,121.04) v2(151.09,119.73) v2(151.09,118.43) v2(151.46,105.84) v2(151.82,107.81) v2(151.82,106.54) v2(151.88,120.38) v2(151.88,119.08) v2(151.88,117.78) v2(152.18,105.62) v2(152.18,105.03) v2(152.18,104.42) v2(152.66,119.73) v2(152.66,118.43) v2(152.66,117.14) v2(152.61,115.18) v2(152.74,109.58) v2(152.74,109.02) v2(153.13,136.57) v2(153.27,115.65) v2(153.3,109.27) v2(153.32,108.61) v2(153.77,136.57) v2(153.93,114.89) v2(153.93,114.33) v2(153.93,113.64) v2(153.93,112.88) v2(154.77,115.56) v2(154.82,133.85) v2(154.82,132.83) v2(154.8,111.56) v2(155.03,121.69) v2(155.03,120.38) v2(155.04,117.8) v2(155.02,110.29) v2(155.02,105.56) v2(155.14,133.34) v2(155.27,132.45) v2(155.21,122.92) v2(155.21,109.14) v2(155.21,107.94) v2(155.3,104.27) v2(155.4,115.56) v2(155.41,111.56) v2(155.52,123.48) v2(155.65,110.29) v2(155.65,105.56) v2(155.71,133.85) v2(155.71,132.83) v2(155.74,110.98) v2(155.85,122.92) v2(155.81,122.34) v2(155.81,121.04) v2(155.81,119.73) v2(155.79,106.96) v2(156.03,133.34) v2(156.07,111.56) v2(156.16,132.45) v2(156.15,123.48) v2(156.23,110.29) v2(156.48,122.92) v2(156.6,133.85) v2(156.6,132.83) v2(156.6,121.69) v2(156.6,120.38) v2(156.6,119.08) v2(156.6,117.78) v2(156.75,107.14) v2(156.79,124.69) v2(156.79,123.48) v2(156.86,110.29) v2(156.92,133.34) v2(157.04,132.45) v2(157.12,125.21) v2(157.12,124.13) v2(157.12,122.92) v2(157.18,115.56) v2(157.42,124.69) v2(157.42,123.48) v2(157.39,119.73) v2(157.39,118.43) v2(157.39,117.14) v2(157.43,105.46) v2(157.49,133.85) v2(157.49,132.83) v2(157.56,109.14) v2(157.56,107.94) v2(157.75,125.21) v2(157.75,124.13) v2(157.75,122.92) v2(157.81,133.34) v2(157.81,115.56) v2(157.93,132.45) v2(158.06,124.69) v2(158.06,123.48) v2(158.07,105.46) v2(158.05,104.42) v2(158.18,121.69) v2(158.18,120.38) v2(158.18,117.78) v2(158.38,133.85) v2(158.38,132.83) v2(158.39,125.21) v2(158.39,124.13) v2(158.39,122.92) v2(158.64,110.29) v2(158.7,133.34) v2(158.69,124.69) v2(158.69,123.48) v2(158.82,132.45) v2(158.96,122.34) v2(158.96,121.04) v2(158.96,119.73) v2(158.96,118.43) v2(159.02,125.21) v2(159.02,124.13) v2(159.02,122.92) v2(159.15,112.19) v2(159.33,124.69) v2(159.33,123.48) v2(159.27,110.29) v2(159.66,125.21) v2(159.66,124.13) v2(159.66,122.92) v2(159.59,115.56) v2(159.75,120.38) v2(159.76,119.07) v2(159.75,117.78) v2(159.73,117.14) v2(159.77,133.4) v2(159.85,110.29) v2(159.85,105.46) v2(159.96,124.69) v2(159.96,123.48) v2(159.91,109.14) v2(159.91,107.94) v2(160.16,133.91) v2(160.16,112.19) v2(160.22,132.83) v2(160.22,131.94) v2(160.23,115.56) v2(160.29,125.21) v2(160.29,124.13) v2(160.29,122.92) v2(160.54,122.34) v2(160.54,121.04) v2(160.54,119.73) v2(160.48,110.29) v2(160.48,105.46) v2(160.66,133.4) v2(160.6,124.69) v2(160.6,123.48) v2(160.71,106.99) v2(160.93,125.21) v2(160.93,124.13) v2(160.93,122.92) v2(161.04,133.91) v2(161.11,132.83) v2(161.11,131.94) v2(161.23,124.69) v2(161.23,123.48) v2(161.32,122.34) v2(161.32,121.69) v2(161.32,120.38) v2(161.32,119.08) v2(161.32,117.78) v2(161.55,133.4) v2(161.56,125.21) v2(161.56,124.13) v2(161.56,122.92) v2(161.87,124.69) v2(161.87,123.48) v2(161.93,133.91) v2(162,132.83) v2(162,131.94) v2(162,115.56) v2(162.13,125.34) v2(162.11,121.04) v2(162.11,119.73) v2(162.11,118.43) v2(162.11,117.14) v2(162.25,124.07) v2(162.2,122.92) v2(162.26,110.29) v2(162.26,109.14) v2(162.26,107.94) v2(162.23,105.46) v2(162.44,133.4) v2(162.44,124.81) v2(162.5,123.48) v2(162.55,104.2) v2(162.64,115.56) v2(162.59,107.01) v2(162.82,133.91) v2(162.83,122.92) v2(162.87,105.46) v2(162.89,132.83) v2(162.89,131.94) v2(162.89,131.05) v2(162.89,124.38) v2(162.9,122.34) v2(162.9,121.69) v2(162.9,120.38) v2(162.9,117.78) v2(162.89,110.29) v2(163.2,123.86) v2(163.33,133.4) v2(163.39,122.8) v2(163.45,104.19) v2(163.65,123.43) v2(163.66,120.4) v2(163.71,133.91) v2(163.69,121.04) v2(163.69,119.73) v2(163.68,119.06) v2(163.69,118.43) v2(163.7,117.76) v2(163.78,132.83) v2(163.78,131.94) v2(163.78,131.05) v2(163.79,109.53) v2(163.79,108.94) v2(163.79,108.36) v2(164.03,122.8) v2(164.22,133.4) v2(164.22,123.37) v2(164.46,118.44) v2(164.49,121.04) v2(164.47,120.38) v2(164.5,117.78) v2(164.6,133.91) v2(164.66,132.83) v2(164.66,131.94) v2(164.66,131.05) v2(164.61,105.46) v2(164.92,133.4) v2(165.24,105.46) v2(165.3,133.91) v2(165.36,132.83) v2(165.36,131.94) v2(165.36,131.05) v2(165.54,108.46) v2(165.81,133.4) v2(165.81,106.29) v2(165.94,107.68) v2(166.19,133.91) v2(166.25,132.83) v2(166.25,131.94) v2(166.25,131.05) v2(166.7,133.4) v2(167.08,133.91) v2(167.14,132.83) v2(167.14,131.94) v2(167.14,131.05) v2(167.59,133.4) v2(167.97,133.91) v2(168.03,132.83) v2(168.03,131.94) v2(168.03,131.05) v2(168.47,133.4) v2(168.86,133.91) v2(168.92,132.83) v2(168.92,131.94) v2(168.92,131.05) v2(169.36,133.4) v2(169.74,133.91) v2(169.81,132.83) v2(169.81,131.94) v2(169.81,131.05) v2(170.19,133.4) v2(170.57,133.91) v2(170.63,132.83) v2(170.63,131.94) v2(170.63,131.05) v2(171.08,133.4) v2(171.46,133.91) v2(171.52,132.83) v2(171.52,131.94) v2(171.52,131.05) v2(171.97,133.4) v2(172.35,133.91) v2(172.41,132.83) v2(172.41,131.94) v2(172.41,131.05) v2(172.86,133.4) v2(173.24,133.91) v2(173.3,132.83) v2(173.3,131.94) v2(173.3,131.05) v2(173.74,133.4) v2(174.13,133.91) v2(174.19,132.83) v2(174.19,131.94) v2(174.19,131.05) v2(174.81,133.66) v2(174.8,132.98) v2(174.8,132.34) v2(174.82,127.78) v2(174.89,131.64) v2(174.89,130.99) v2(175.52,131.64) v2(176.16,131.64) v2(176.79,131.64) v2(177.43,131.64) v2(178.06,131.64) v2(178.7,131.64) v2(179.17,133.99) v2(179.17,133.36) v2(179.17,132.72) v3(166.51,129.23)
+VCCGT: length 19.3
  TOP w0.254: v2(143.95,138.76) 143.32,138.76 PR588.1
  TOP w0.508: v2(121.34,134.29) 121.09,134.29 120.58,134.8 PR526.2
  IN1 w0.508: v2(121.34,134.29) 121.73,134.29 121.75,134.27 122.08,134.27 127.39,128.96 133.51,128.96
  BOTTOM w0.254: PL505.2 v2(143.95,138.76)
  BOTTOM w0.508: RH203.2 151.4,123.68 v2(151.38,123.66)
  vias: v2(133.42,125.77) v2(133.42,125.18) v2(133.71,124.64) v2(133.82,120.54) v2(133.9,123.93) v2(134,125.77) v2(134,125.18) v2(134.29,124.64) v2(134.48,123.93) v2(134.59,125.77) v2(134.59,125.18) v2(134.88,124.64) v2(135.07,123.93) v2(135.17,125.77) v2(135.17,125.18) v2(135.29,106.16) v2(135.29,105.36) v2(135.46,124.64) v2(135.65,123.93) v2(135.75,125.77) v2(135.75,125.18) v2(135.92,114.04) v2(135.95,112.47) v2(135.91,111.66) v2(135.91,110.9) v2(135.91,110.13) v2(135.92,109.3) v2(135.92,106.18) v2(136.05,124.64) v2(136.24,123.93) v2(136.39,123.37) v2(136.67,125.83) v2(136.67,125.25) v2(136.57,114.82) v2(136.57,105.38) v2(136.96,124.7) v2(136.92,122.36) v2(137.03,123.37) v2(137.15,123.99) v2(137.25,125.83) v2(137.25,125.25) v2(137.36,122.8) v2(137.41,114.86) v2(137.44,114.01) v2(137.42,111.74) v2(137.46,109.72) v2(137.4,106.16) v2(137.41,105.3) v2(137.54,124.7) v2(137.66,123.37) v2(137.61,108.14) v2(137.73,123.99) v2(137.7,121.69) v2(137.7,120.38) v2(137.7,119.73) v2(137.7,117.78) v2(137.84,125.83) v2(137.84,125.25) v2(138.13,124.7) v2(138.18,113.53) v2(138.18,108.96) v2(138.32,123.99) v2(138.3,123.37) v2(138.42,125.83) v2(138.42,125.25) v2(138.49,119.73) v2(138.49,118.43) v2(138.49,117.14) v2(138.49,115.14) v2(138.71,124.7) v2(138.71,112.13) v2(138.76,107.69) v2(138.76,106.86) v2(138.9,123.99) v2(138.93,123.37) v2(139,125.83) v2(139,125.25) v2(139.14,109.53) v2(139.14,105.8) v2(139.3,124.7) v2(139.28,121.69) v2(139.28,120.38) v2(139.28,117.78) v2(139.49,123.99) v2(139.57,123.37) v2(139.69,104.17) v2(139.84,105.8) v2(140.06,122.34) v2(140.06,121.04) v2(140.06,119.73) v2(140.06,118.43) v2(140.07,122.92) v2(140.16,107.81) v2(140.16,106.54) v2(140.27,115.14) v2(140.34,114.04) v2(140.28,112.89) v2(140.28,111.43) v2(140.39,123.43) v2(140.6,104.19) v2(140.61,103.52) v2(140.71,122.92) v2(140.85,120.38) v2(140.85,119.08) v2(140.85,117.78) v2(140.85,117.14) v2(140.95,115.12) v2(141.03,123.43) v2(140.97,112.13) v2(141.34,122.92) v2(141.49,109.53) v2(141.52,104.16) v2(141.66,123.43) v2(141.64,122.34) v2(141.64,121.04) v2(141.7,106.08) v2(141.8,108.96) v2(141.8,108.26) v2(141.8,107.56) v2(141.8,106.86) v2(141.98,122.92) v2(142.26,105.8) v2(142.3,123.43) v2(142.43,121.69) v2(142.43,120.38) v2(142.43,119.08) v2(142.43,117.78) v2(142.44,108.77) v2(142.45,107.87) v2(142.44,107.24) v2(142.45,106.6) v2(142.4,104.18) v2(142.42,103.57) v2(142.57,113.02) v2(142.57,111.62) v2(142.57,110.8) v2(142.61,122.92) v2(142.77,115.14) v2(142.93,123.43) v2(143.12,135.1) v2(143.08,124.04) v2(143.25,122.92) v2(143.21,119.73) v2(143.21,118.43) v2(143.21,117.14) v2(143.33,113.02) v2(143.33,110.8) v2(143.42,115.15) v2(143.4,111.62) v2(143.57,123.43) v2(143.67,124.04) v2(143.7,135.1) v2(143.78,109.53) v2(143.88,122.92) v2(144.03,134.53) v2(144,121.69) v2(144,120.38) v2(144,117.78) v2(143.98,107.95) v2(143.98,106.68) v2(144.25,124.04) v2(144.2,123.43) v2(144.29,135.1) v2(144.35,133.97) v2(144.52,122.92) v2(144.62,134.53) v2(144.83,124.04) v2(144.84,123.43) v2(144.79,122.34) v2(144.79,121.04) v2(144.79,119.73) v2(144.79,118.43) v2(144.85,113.21) v2(144.85,112.58) v2(144.85,111.81) v2(144.85,110.99) v2(144.86,105.8) v2(144.87,135.1) v2(144.94,133.97) v2(145.15,122.92) v2(145.2,134.53) v2(145.23,115.15) v2(145.18,104.17) v2(145.18,103.52) v2(145.46,135.1) v2(145.42,124.04) v2(145.52,133.97) v2(145.47,123.43) v2(145.49,110.8) v2(145.49,109.97) v2(145.49,108.89) v2(145.58,120.38) v2(145.58,119.08) v2(145.58,117.78) v2(145.59,117.15) v2(145.79,134.53) v2(145.79,122.92) v2(145.86,115.15) v2(145.84,111.52) v2(146,124.04) v2(146.1,136.5) v2(146.1,135.87) v2(146.1,135.23) v2(146.1,133.97) v2(146.11,123.42) v2(146.08,109.32) v2(146.36,122.34) v2(146.36,121.04) v2(146.38,137.06) v2(146.37,134.53) v2(146.42,122.92) v2(146.59,125.38) v2(146.59,124.68) v2(146.59,124.04) v2(146.69,136.5) v2(146.69,135.87) v2(146.69,135.23) v2(146.69,133.97) v2(146.77,123.4) v2(146.97,137.06) v2(146.96,134.53) v2(147.06,122.91) v2(147.15,121.69) v2(147.15,120.38) v2(147.15,119.08) v2(147.15,117.78) v2(147.17,125.38) v2(147.17,124.68) v2(147.17,124.04) v2(147.27,136.5) v2(147.27,135.87) v2(147.27,135.23) v2(147.27,133.97) v2(147.41,123.4) v2(147.54,134.51) v2(147.76,124.68) v2(147.76,124.04) v2(147.72,122.9) v2(147.86,133.95) v2(148.05,123.4) v2(148.34,124.04) v2(148.37,122.9) v2(148.73,123.5) v2(149.04,122.86) v2(149.42,123.37) v3(141.96,130.23)
+VCCIO: length 5.1
  BOTTOM w0.203: UC1.AG12 154.19,102.87 v2(154.32,102.9)
  BOTTOM w0.508: RC2.1 171.33,91.34 v2(171.56,91.34) ; RC30.2 175.14,121.07 v2(175.14,119.02)
  vias: v2(124.14,100.94) v2(124.75,100.97) v2(124.8,101.59) v2(125.43,101.68) v2(125.48,102.28) v2(126.08,102.34) v2(167.28,114.26) v2(168.47,91.05) v2(168.76,108.79) v2(168.76,106.36) v2(168.92,90.61) v2(169.36,90.16) v2(169.42,108) v3(169.44,109.41)
+VCCIOP: length 19.7
  TOP w0.508: v2(125.26,125.17) 124.04,123.94 124.04,121.67 122.75,120.39 v1(122.75,119.5) 122.75,115.95 121.95,115.15 121.95,109.44 v2(122.75,108.64)
  BOTTOM w0.508: PR5014.1 124.62,125.15 PC818.1 125.26,125.17 v2(125.26,125.17)
+VCCRTCEXT: length 0.5
  BOTTOM w0.254: UH1.BF47 UH1.BG47
+VCCSA: length 45.1
  TOP w0.508: PR514.1 126.81,132.46 v2(126.78,132.44)
  IN2 w0.508: 166.18,125.02 166.18,125.43 164.73,126.88 141.59,126.88 v2(140.56,125.85)
  IN3 w0.508: v2(126.78,132.44) 126.93,132.44 131.76,127.61 138.21,127.61 139.05,126.77 139.58,126.77 140.51,125.85 v2(140.56,125.85)
  BOTTOM w0.508: RH201.2 173.7,125.2 v2(174.07,124.83)
  vias: v2(165.57,110.77) v2(165.58,113.13) v2(165.58,112.56) v2(165.85,114.48) v2(166.06,121.02) v2(166.05,120.38) v2(166.06,119.75) v2(166.05,119.08) v2(166.06,118.42) v2(166.05,117.78) v2(166.06,117.15) v2(166.07,124.43) v2(166.13,123.81) v2(166.13,123.18) v2(166.67,124.42) v2(166.84,121.04) v2(166.87,119.74) v2(166.84,118.43) v2(166.84,117.78) v2(167.62,118.43) v2(180.5,129.78) v2(180.5,129.15) v2(180.78,131.03) v2(180.78,130.39) v2(181.14,129.78) v2(181.14,129.15) v2(181.42,131.03) v2(181.42,130.39) v2(181.77,129.78) v2(181.77,129.15) v2(182.05,131.03) v2(182.05,130.39) v2(182.41,129.78) v2(182.41,129.15) v2(182.69,131.03) v2(182.69,130.39) v2(183.07,129.8) v2(183.32,131.03) v2(183.32,130.39) v2(183.87,130.72) v3(181.87,131.97)
+VCCST: length 96.5
  TOP w0.381: RH164.1 174.26,100.45 v2(173.63,99.81)
  TOP w0.508: 168.24,116.31 168.19,116.31 167.94,116.56 RH163.1
  IN2 w0.508: v2(125.54,121.91) 126.12,121.91 127.57,120.46 127.57,117.47 128.08,116.96 v2(128.34,116.96)
  IN3 w0.508: v2(125.54,121.91) 125.54,122.93 122.89,125.58 122.89,129.28 119.8,132.38 119.8,133.58 120.25,134.04 120.25,135.25 121.68,136.68 v2(121.68,137.13)
  IN4 w0.508: v2(167.35,115.07) 167.35,115.57 166.58,116.34 165.62,116.34 165.11,116.84 165.11,123.43 164.6,123.94 164.43,123.94 162.42,125.95 156.58,125.95 155.96,125.33 155.96,124.85 155.35,124.23 149.48,124.23 147.1,126.61 132.79,126.61 132.28,126.1 129.49,126.1 127.64,124.25 127.64,117.39 128.08,116.96 v2(128.34,116.96)
  BOTTOM w0.203: v2(168.82,116.63) 168.79,116.63 UC1.H30 ; UC1.H28 UC1.J28 v2(167.35,115.07)
  BOTTOM w0.508: PC502.2 122.18,138.41 122.15,138.37 122.15,137.62 121.66,137.13 ; RH151.1 RH152.1 126.46,121.57 126.46,121.57 126.08,121.57 125.74,121.91 v2(125.54,121.91) ; 121.66,137.13 v2(121.68,137.13) ; 121.66,137.13 121.45,136.92 PR504.1 121.52,136.45 122.24,136.45 PR505.2 PR506.1 PR507.1 ; v2(128.34,116.96) 128.62,116.68 RH156.1
  vias: v2(172.99,94.29) v2(173.41,93.93) v2(173.82,93.52) v2(174.2,93.13) v2(174.73,92.77) v3(175.85,84.45)
+VCCSTG: length 99.3
  TOP w0.203: v3(173.19,115.09) 172.5,115.78 CH105.1
  TOP w0.254: CH105.1 172.5,117.72 v2(172.01,118.21)
  TOP w1.016: 178.25,99.94 178.7,99.5 178.7,97.04 176.55,94.9 176.55,90.1 181.1,85.55
  IN3 w0.254: v2(168.38,117.77) 169.42,117.77 170.29,118.65 171.57,118.65 v2(172.01,118.21)
  IN4 w0.508: v2(127.59,115.69) 127.59,116.5 v2(126.12,117.97) 125.93,117.97 125.91,117.99 125.86,117.99 125.42,118.43 125.42,120.04 127.01,121.63 127.01,124.51 129.23,126.74 132.02,126.74 132.59,127.31 147.3,127.31 149.78,124.83 154.85,124.83 155.33,125.31 155.33,125.59 156.66,126.93 159.7,126.93 161.73,128.96 167.71,128.96 171.01,125.66 171.97,125.66 172.47,125.15 172.47,120.09 171.84,119.45 171.32,119.45 169.58,117.72 169.07,117.72 169.02,117.77 v2(168.38,117.77)
  BOTTOM w0.203: v2(168.38,117.77) 168.38,117.73 UC1.G30
  BOTTOM w0.254: UC1.H29 168.43,116.2 v2(168.8,115.83)
  BOTTOM w0.508: RH165.1 126.59,117.63 126.25,117.97 v2(126.12,117.97)
  vias: v2(176.6,99.94) v2(177.24,99.94)
+VDD09:
  vias: v1(22.78,55.97) v2(14.93,48.56) v2(15.52,48.56) v2(21.98,56.18) v2(22.01,55.59)
+VDD18: length 10.1
  TOP w0.203: UU2.5 v2(22.07,52.54) ; UU2.39 v2(16.77,49.27) ; 14.42,53.31 14.45,53.34 UU2.30
  TOP w0.254: 14.42,53.31 14.34,53.31 v2(14.3,53.27) ; CU85.1 21.03,49.33 20.37,49.99 UU2.48 ; v2(18.27,57.11) 18.27,57.1 18.37,57 UU2.18
  TOP w0.457: CU85.1 21.47,48.5 v2(21.71,48.75)
  IN2 w0.508: v2(16.77,49.27) 16.5,49.54 14.98,49.54 14.12,48.68 v2(14.12,48.58)
  BOTTOM w0.381: v2(14.12,48.58) 14.17,48.63 RU32.1
  vias: v1(15.01,52.8) v2(31.7,49.97) v2(32.29,49.97)
+VDD_TOUCH: length 0.9
  BOTTOM w0.203: v1(168.26,172.2) 167.75,172.71 v2(167.59,172.71)
  vias: v2(167.59,173.35) v2(167.86,183.77) v2(167.85,183.12)
+VDDA: length 40.5
  TOP w0.254: UE1.9 317.79,11.93 318.05,12.18 320.94,12.18 321.64,11.48 321.66,11.48 v1(322.18,10.96) 322.42,10.71 v2(322.78,10.71)
  TOP w0.508: v2(316.29,29.26) 316.29,28.82 CE169.1 315.84,28.37 LE4.2 ; CE7.1 v2(322.78,10.71)
  BOTTOM w0.508: v2(322.78,10.71) 322.29,10.71 321.22,11.78 319.52,11.78 318.41,10.66 316.05,10.66 315.42,11.29 315.42,18 312.72,20.7 312.72,22.12 312.14,22.69 312.14,23.52 312.91,24.29 312.91,27.33 314.84,29.26 v2(316.29,29.26)
+VDDCT_L:
  vias: v1(253.08,157.57) v2(248.67,159.31) v2(249.31,159.31) v2(256.68,159.38) v2(256.68,158.68)
GND: length 8719.9
  TOP w0.089: v1(130.77,111.73) 131.08,112.04 v2(131.33,112.04)
  TOP w0.102: v2(181.59,172.33) 181.59,172.17 181.9,171.86 UT1.A14 UT1.B14 ; UT1.B18 UT1.A18 v2(183.74,172.33) ; UT1.B20 UT1.A20 184.66,172.28 184.77,172.39 v2(184.79,172.39) ; v2(182.62,172.34) 182.62,172.12 182.82,171.91 UT1.A16 UT1.B16
  TOP w0.152: v2(186.6,170.1) 186.3,169.8
  TOP w0.178: v2(181.82,160.83) 181.9,160.91 UT1.AC14 UT1.AB14 ; UT1.AB22 UT1.AC22 185.58,161.43 v2(185.97,161.04) ; UT1.AA22 UT1.AA23 186.31,162.44 v2(186.48,162.27) ; UT1.AB2 UT1.AB1 175.71,161.98 175.56,161.83 175.56,161.28 175.34,161.06 v2(175.29,161.06) ; v2(180.98,172.18) UT1.A12 UT1.B12 ; UT1.B22 UT1.A22 185.58,171.78 v2(186,172.2) ; UT1.E22 UT1.E23 186.3,169.8 ; UT1.W22 UT1.W23 ; UT1.AB16 UT1.AC16 182.82,160.9 v2(182.89,160.84) ; v2(179.14,172.27) UT1.A8 UT1.B8 ; UT1.R22 UT1.R23 186.04,165.2 186.45,165.2 v2(186.54,165.11) ; UT1.AC6 UT1.AB6 ; UT1.T1 UT1.T2 ; v2(180.78,160.83) 180.78,160.85 180.79,160.86 180.79,161.03 180.98,161.21 UT1.AC12 UT1.AB12 ; UT1.AB20 UT1.AC20 184.66,161.12 185.07,160.71 v2(185.07,160.46) ; UT1.G22 UT1.G23 186.94,168.88 v2(187.07,169.02) ; UT1.J22 UT1.J23 186.68,167.96 v2(186.76,168.05) ; UT1.N23 UT1.N22 ; UT1.P2 UT1.P1 175.68,165.66 175.5,165.84 v2(175.46,165.84) ; UT1.AC8 UT1.AB8 ; v2(183.84,160.85) 183.74,160.95 UT1.AC18 UT1.AB18 ; UT1.H2 UT1.H1 ; v2(175.4,167.21) 175.69,167.5 UT1.K1 UT1.K2 ; UT1.B10 UT1.A10 180.06,172.11 v2(179.97,172.2) ; UT1.M2 UT1.M1 ; v2(175.38,160.48) 175.92,161.02 UT1.AC1 UT1.AC2 ; UT1.AB10 UT1.AC10 180.06,161.23 179.77,160.94 v2(179.77,160.8) ; v2(186.57,167.03) 186.56,167.04 UT1.L23 UT1.L22 ; UT1.C22 UT1.C23 186.09,170.72 186.42,171.05 186.42,171.68 186.7,171.96 187.28,171.96 187.69,171.55 187.69,170.77 187.33,170.41 ; UT1.U23 UT1.U22 ; UT1.B6 UT1.A6
  TOP w0.2: v2(247.67,97.25) 247.02,97.25 246.72,97.55
  TOP w0.203: v2(29.53,10.25) 30.47,10.25 UA4.39 ; v2(301.19,23.74) 301.54,24.09 UE5.11 ; v2(296.88,24.26) 296.34,24.8 UE5.24 ; UE5.113 306.21,18.01 305.94,18.29 305.94,18.46 v2(305.93,18.47) ; UT1.E4 176.75,170.17 176.75,170.62 176.94,170.81 177.4,170.81 UT1.D5 ; UT1.AB10 180.06,162.3 UT1.Y9 ; 187.33,170.41 187.11,170.19 186.68,170.19 v2(186.6,170.1) ; UA4.4 38.36,10.21 38.74,10.6 v2(39.06,10.6) ; UU2.49 19.97,51.34 UU2.2 ; UE5.94 304.74,8.95 305.02,8.66 v2(305.02,8.55) ; UT1.Y9 179.57,162.79 179.57,163.23 UT1.W9 179.56,163.45 179.56,163.86 UT1.V9 ; UT1.Y9 179.14,162.14 UT1.AB8 178.82,162.3 178.49,162.3 178.22,162.03 UT1.AB6 ; v2(19.52,57.08) 19.57,57.02 UU2.15 ; UU2.43 18.37,49.26 v2(18.49,49.14) ; v2(117.47,155.43) 117.47,155.67 JPCMC.19 ; UE5.35 290.17,23.21 v2(290.06,23.1)
  TOP w0.229: v2(194.72,175.92) DT7.2 ; v2(197.28,175.92) DT6.2
  TOP w0.25: 246.72,103.55 v2(247.67,103.55)
  TOP w0.254: v2(190,178.81) 189.81,179 188.82,179 188.18,178.36 DT14.2 ; JUSBC2.A1 v2(8.37,64.73) ; CG236.2 225.42,112.51 225.18,112.75 225.18,113.03 224.97,113.24 v2(224.97,113.65) ; UE10.12 320.04,60.81 v2(320.3,61.08) ; v2(324.56,21.66) 324.56,21.83 324.88,22.16 JIO.22 ; v2(168.42,118.43) 169.43,117.42 CH106.2 ; v2(10.17,61.47) 10.85,61.47 DU28.2 ; v2(307.43,33.37) 307.43,33.6 308.22,34.39 UE8.7 ; v2(190.41,9.9) 190.41,10.2 191.05,10.85 192.99,10.85 193.39,10.44 UT5.5 ; DT13.2 194.7,178.04 194.34,178.4 194.28,178.4 v2(194.26,178.43) ; v2(192.88,174.59) 192.25,175.22 191.95,175.22 191.65,175.52 DT11.2 ; 201.24,35.8 201.24,35.84 200.52,36.56 200.52,36.97 200.31,37.18 200.31,37.61 200.68,37.97 v2(200.68,38.03) ; 201.24,35.8 202.02,36.58 v2(202.51,36.58) 202.51,37.13 v2(202.32,37.32) 202.02,37.61 201.91,37.61 201.65,37.87 201.65,37.98 201.55,38.09 201.55,38.39 201.39,38.55 201.39,39.18 v2(201.75,39.54) ; 201.24,35.8 v2(201.24,35.74) ; v2(261.12,86.23) 262.42,86.23 262.71,85.94 262.71,80.71 259.53,77.54 v2(259.53,76.13) ; 169.9,165.19 RT41.2 ; 169.9,165.19 169.96,165.13 170.48,165.13 v2(170.51,165.15) ; 169.9,165.19 RT35.2 ; JIO.10 324.88,16.16 324.62,16.41 v2(324.62,16.65) ; v2(174,117.59) 173.74,117.59 173.08,116.93 CH105.2 ; JEDP.12 v2(157.12,181.17) ; DT12.2 v2(196.9,178.62) ; DU26.2 10.15,59.18 v2(9.59,59.18) ; UE8.23 v2(305.72,41.46) ; v2(189.35,20.25) 189.6,20.5 UE4.18 ; JEDP.6 v2(154.12,181.17) ; v2(324.59,18) 324.93,17.66 JIO.13 ; v2(150.72,181.17) JEDP.41 ; UE1.8 317.3,11.82 316.94,12.18 316.11,12.18 v2(316.05,12.25) 314.46,12.25 313.63,13.08 UE1.47 ; v2(11.69,63.15) 11.31,63.53 DU25.2 ; v2(133.98,108.53) 133.84,108.39 133.84,107.6 RH186.2 ; JEDP.29 v2(165.62,183.61) ; UE3.7 230.51,158.35 230.75,158.6 v2(230.75,158.91) ; v2(172.35,163.88) 172.37,163.91 RT34.2 ; v2(184.51,20.59) 184.52,20.59 184.61,20.5 UE4.7 ; DU27.2 9.63,57.74 v2(9.6,57.77) ; RH592.1 174.06,116.17 v2(174.06,115.29) ; UG16.6 195.25,110.58 194.99,110.32 194.99,109.96 195.29,109.66 RG101.2 ; UE4.23 191.08,22.99 191.33,23.25 v2(191.33,23.42) ; JEDP.15 v2(158.62,183.06) ; DU23.2 11.27,67.07 11.29,67.08 v2(11.29,67.21) ; v2(9.92,64.96) 9.94,64.98 DU24.2 10.94,64.98 11.25,65.29 DU22.2 ; v2(227.85,164.58) 227.85,164.1 228.01,163.94 UE3.23 ; JEDP.9 v2(155.62,181.17) ; v2(324.65,23.66) JIO.25 ; UE1.23 321.83,17.58 322.08,17.33 v2(322.08,16.88) ; v2(262.74,61.91) 262.77,61.87 CG125.2 ; UE3.18 230.51,162.43 230.75,162.18 v2(230.75,161.9) ; RU2.1 20.12,45.36 UU1.14 ; UE1.35 314.3,18.34 313.95,17.99 v2(313.91,17.99) ; v2(332.28,45.57) 332.54,45.83 UE6.12 ; UG16.3 195.05,112.08 194.32,112.8 v2(193.98,112.8) ; JEDP.30 166.12,183.44 v2(166.26,183.58) ; DU29.2 11.67,60.02 v2(11.88,59.81) ; RU30.2 v2(13.34,52.63) ; v2(324.62,25.16) 324.63,25.16 JIO.28 ; UE8.18 v2(308.22,41.39) ; v2(314.54,58.39) 314.63,58.39 315.06,58.81 UE10.23 ; UU2.21 v2(17.17,57.06) ; JUSBC2.A12 7.79,59.22 ; JEDP.3 v2(152.62,181.17)
  TOP w0.279: JUSBC2.B1 5.78,59.48 5.56,59.26 5.56,59.26 5.56,59.06 v2(5.66,58.97) ; 7.79,59.22 8.24,59.22 v2(8.44,59.03)
  TOP w0.3: v2(233.32,97.55) 233.34,97.53 234.7,97.53 v2(234.72,97.55) v2(235.42,97.55) ; v2(240.32,103.25) 239.67,103.25 239.65,103.27 238.94,103.27 v2(238.92,103.25) v2(238.22,103.25) ; v2(244.52,104.65) v2(245.22,104.65) ; v2(244.52,97.55) v2(245.22,97.55) 246.72,97.55 ; v2(244.52,101.83) 244.57,101.85 v2(245.22,101.85) ; v2(231.92,97.55) 231.83,97.64 230.61,97.64 v2(230.52,97.55) ; v2(231.92,98.95) v2(233.32,98.95) v2(234.72,98.95) v2(235.42,98.95) ; v2(244.52,96.15) v2(245.22,96.15) ; v2(231.92,96.15) 231.83,96.06 230.61,96.06 v2(230.52,96.15) ; v2(235.42,96.15) v2(234.72,96.15) 234.59,96.02 233.45,96.02 v2(233.32,96.15) ; v2(245.22,103.25) v2(244.52,103.25) ; v2(240.32,104.65) v2(238.92,104.65) v2(238.22,104.65) ; v2(228.42,97.55) v2(229.12,97.55) ; v2(228.42,96.15) v2(229.12,96.15) ; v2(244.52,94.75) v2(245.22,94.75) 245.29,94.75 245.59,95.05 245.86,95.05 245.86,94.21 245.87,94.2 245.87,93.27 CG233.2 ; v2(228.42,101.05) v2(229.12,101.05) ; v2(238.92,93.35) v2(238.22,93.35) ; v2(244.52,93.35) v2(245.22,93.35) ; 246.01,101.21 246.01,100.45 ; v2(234.72,101.85) v2(235.42,101.85) ; v2(243.12,104.65) 243.04,104.73 241.8,104.73 v2(241.72,104.65) ; 223.39,112 v2(223.22,112) ; v2(244.52,98.95) v2(245.22,98.95) ; v2(228.42,94.75) v2(229.12,94.75) ; v2(238.92,101.85) v2(238.22,101.85) ; v2(229.12,93.35) v2(228.42,93.35)
  TOP w0.305: RE523.2 230.55,22.43 230.27,22.71 QE52.4 ; v2(280.95,100.36) 280.95,100.86 CG106.2 ; v2(237.47,113.05) 237.26,112.84 CG23.2 ; v2(272.95,118.76) 272.95,119.19 273.25,119.5 RG105.2 ; v2(226.19,67.51) 226.81,67.51 CG152.2 ; v2(222.5,80.2) 222.37,80.07 CG275.2 ; v2(257.99,63.51) 257.89,63.41 CG139.2 ; v2(237.99,58.71) 238.44,59.16 RG129.2 ; v2(237.19,66.71) 237.35,66.87 CG173.2 ; v2(226.19,58.71) 226.21,58.73 CG184.2 ; v2(228.42,104.65) v2(229.12,104.65) 229.21,104.74 PC6340.2 230.43,104.74 v2(230.52,104.65) 230.81,104.36 PC6306.2 231.63,104.36 v2(231.92,104.65) 232.21,104.36 PC6349.2 233.03,104.36 v2(233.32,104.65) 233.61,104.36 PC6356.2 234.43,104.36 v2(234.72,104.65) v2(235.42,104.65) 235.69,104.65 PC6377.2 236.55,104.65 v2(236.82,104.65) ; RE512.2 230.55,25.67 230.27,25.95 QE49.4 ; C6.2 179.33,83.61 179.28,83.56 U19.5 ; v2(274.55,91.76) 274.53,91.78 CG90.2 ; CG150.2 233.98,53.9 v2(233.99,53.91) ; v2(243.12,106.05) 243.77,106.7 PC6321.2 ; v2(228.42,101.05) 227.82,101.05 PC6331.2 ; v2(230.52,96.15) 230.39,96.28 PC6341.2 229.25,96.28 v2(229.12,96.15) ; v2(276.15,90.16) 276.14,90.17 RG54.2 ; v2(244.47,114.45) 244.05,114.45 CG40.2 243.87,114.27 v2(243.87,113.65) ; CG174.2 242.13,58.86 v2(241.99,58.71) ; RG127.2 245.55,61.6 v2(245.44,61.71) ; v2(253.34,107.68) 253.35,107.67 PC6354.2 ; v2(230.52,97.55) 230.32,97.35 PC6343.2 229.32,97.35 v2(229.12,97.55) ; PC6390.2 240.08,101.85 v2(238.92,101.85) ; PC6390.2 240.06,100.35 v2(238.87,100.35) ; PC6390.2 241.61,101.9 v2(243.12,101.9) 243.33,101.69 PC6316.2 244.39,101.69 v2(244.52,101.83) ; v2(238.92,98.95) 239.33,98.95 PC6326.2 239.89,98.95 v2(240.32,98.95) 240.66,98.95 PC6325.2 241.23,98.95 v2(241.72,98.95) 242.12,98.95 PC6367.2 242.84,98.67 v2(243.12,98.95) 243.4,99.23 PC6338.2 244.24,99.23 v2(244.52,98.95) ; v2(245.22,98.95) 245.46,99.19 PC6328.2 246.01,100.45 ; PC6319.2 230.48,101.81 v2(230.52,101.85) v2(231.92,101.85) v2(233.32,101.85) v2(234.72,101.85) ; v2(233.79,65.91) 233.41,65.54 CG175.2 ; v2(199.94,102.63) 199.96,102.65 199.96,102.65 ; RG118.2 278.27,76.56 v2(278.55,76.56) ; RG68.2 255.16,92.31 v2(255.12,92.35) ; v2(236.82,106.05) 236.55,106.05 PC6414.2 235.69,106.05 v2(235.42,106.05) v2(234.72,106.05) 234.62,106.15 PC6311.2 233.42,106.15 v2(233.32,106.05) 233.22,106.15 PC6310.2 232.02,106.15 v2(231.92,106.05) 231.82,106.15 PC6305.2 230.62,106.15 v2(230.52,106.05) ; PC6355.2 248.4,107.94 v2(248.83,107.51) ; v2(224.97,110.15) 225.67,110.15 CG11.2 ; v2(238.92,93.35) 238.94,93.37 PC6334.2 ; PC6391.2 231.83,94.75 v2(230.52,94.75) ; PC6391.2 232.27,93.35 v2(230.52,93.35) 230.33,93.54 PC6342.2 229.31,93.54 v2(229.12,93.35) ; PC6391.2 233.23,93.35 v2(234.72,93.35) v2(235.42,93.35) 235.6,93.35 PC6361.2 236.64,93.35 v2(236.82,93.35) ; PC6391.2 233.67,94.75 v2(234.72,94.75) v2(235.42,94.75) 235.75,94.42 PC6411.2 236.48,94.42 v2(236.82,94.75) ; v2(222.99,62.71) 222.48,62.71 RG128.2 ; RG131.2 233.79,61.57 v2(233.79,61.66) ; v2(229.12,106.05) v2(228.42,106.05) ; CG367.2 222.23,63.44 CG176.2 222.3,63.51 v2(222.99,63.51) ; QE51.4 230.27,29.19 230.55,28.91 RE519.2 ; RG69.2 253.87,93.35 v2(253.47,92.95) ; 184.62,69.76 184.24,69.38 US1.13 ; 184.62,69.76 v2(184.66,69.76) ; 184.62,69.76 184.74,69.65 US1.12 ; v2(228.42,96.15) 228.37,96.1 PC6345.2 ; v2(252.17,82.95) 252.13,82.99 CG194.2 ; PC6347.2 245.56,106.39 v2(245.22,106.05) ; CG105.2 278.55,93 v2(278.55,92.56) 278.51,92.52 CG91.2 ; v2(236.82,96.15) 236.61,95.94 PC6410.2 235.63,95.94 v2(235.42,96.15) ; v2(185.74,69.75) US1.10 ; v2(273.75,110.76) 274.25,111.26 CG99.2 ; QG505.4 193.88,109.14 193.44,109.58 193.44,109.59 RH589.1 ; v2(311.35,60.06) 311.27,60.14 311.27,60.99 UG27.3 ; v2(274.55,96.56) 274.89,96.22 RG106.2 ; CG269.2 270.01,115.02 v2(270.55,115.56) ; v2(251.59,61.11) 251.61,61.13 RG56.2 ; v2(243.59,61.11) 243.58,61.11 RG57.2 ; RG130.2 225.46,61.98 v2(225.39,61.91) ; v2(194.26,178.43) 194.26,179.26 CT96.2 ; 245.86,95.05 245.86,95.9 PC6300.2 245.61,96.15 v2(245.22,96.15) ; v2(243.12,107.45) 243.22,107.55 PC6317.2 ; v2(29.53,10.25) 29.38,10.25 29.15,10.48 28.32,10.48 27.87,10.02 CA66.1 ; PC6329.2 245.5,104.37 v2(245.22,104.65) ; v2(244.17,111.25) 244.54,111.62 245.17,111.62 PC6371.2 ; v2(245.19,57.11) 245.23,57.06 CG158.2 ; CG57.2 246.71,103.56 246.72,103.55 246.05,103.55 PC6304.2 245.48,103.51 v2(245.22,103.25) ; PC6371.2 245.21,112.35 v2(244.57,112.35) ; PC6371.2 245.87,112.32 v2(245.87,113.05) ; v2(234.72,107.45) v2(235.42,107.45) 235.5,107.45 PC6408.2 236.74,107.45 v2(236.82,107.45) ; v2(244.52,104.65) 243.92,104.05 PC6339.2 ; v2(236.82,97.55) 236.67,97.4 PC6362.2 235.57,97.4 v2(235.42,97.55) ; v2(241.19,54.71) 240.78,54.3 CG151.2 ; 246.01,101.21 245.37,101.85 v2(245.22,101.85) ; PC6353.2 227.9,95.27 v2(228.42,94.75) ; CG169.2 222.41,66.71 v2(222.99,66.71) ; v2(238.22,97.55) v2(238.92,97.55) 238.98,97.55 PC6313.2 240.24,97.55 v2(240.32,97.55) 240.32,97.54 PC6333.2 241.58,97.55 v2(241.72,97.55) 241.77,97.55 PC6301.2 243.04,97.55 v2(243.12,97.55) 243.63,97.55 PC6315.2 243.98,97.55 v2(244.52,97.55) ; v2(240.32,93.35) 240.36,93.39 PC6322.2 241.68,93.39 v2(241.72,93.35) 241.76,93.39 PC6346.2 243.08,93.39 v2(243.12,93.35) 243.55,93.35 PC6314.2 244.05,93.35 v2(244.52,93.35) ; 217.76,161.46 CG246.2 ; QE53.4 230.27,32.42 230.55,32.15 RE527.2 ; CG189.2 271.34,88.56 v2(271.35,88.56) ; 223.39,112 223.74,111.65 CG230.2 ; RG119.2 261.49,60.28 v2(261.49,59.71) ; v2(236.52,82.05) 236.52,82.05 CG272.2 ; v2(233.79,67.51) 233.59,67.31 CG156.2 ; v2(186.31,65.16) 186.24,65.24 US1.5 ; v2(280.15,106.91) 280.09,106.86 CG89.2 ; v2(228.42,103.25) v2(229.12,103.25) 229.52,103.65 PC6336.2 230.12,103.65 v2(230.52,103.25) 230.78,103.51 PC6307.2 231.66,103.51 v2(231.92,103.25) 232.18,103.51 PC6348.2 233.06,103.51 v2(233.32,103.25) 233.58,103.51 PC6351.2 234.46,103.51 v2(234.72,103.25) v2(235.42,103.25) 235.81,103.25 PC6413.2 236.43,103.25 v2(236.82,103.25) ; v2(245.19,64.31) 245.21,64.33 CG154.2 ; v2(235.42,98.95) 235.51,98.86 PC6412.2 236.73,98.86 v2(236.82,98.95) ; RG117.2 257.5,59.17 v2(257.04,58.71) ; RG23.1 243.66,116.18 v2(244.05,116.57) ; v2(251.57,110.25) 251.57,110.98 PC6372.2 251.82,112 v2(252.27,111.55) ; v2(235.42,101.85) 235.81,101.85 PC6376.2 236.43,101.85 v2(236.82,101.85) ; v2(246.19,117.12) 245.9,117.12 PC6359.2 245.45,116.6 v2(246.37,116.6) ; v2(246.57,114.45) 247.24,114.45 PC6370.2 247.24,113.75 v2(246.67,113.75) ; v2(274.55,80.56) 274.32,80.33 RG55.2 ; CG267.2 270.58,91.79 v2(270.55,91.76) ; v2(274.55,110.76) 274.59,110.8 275.21,110.8 RG107.2 ; v2(249.39,53.91) 249.15,54.14 CG137.2 ; CG167.2 222.17,54.73 v2(222.19,54.71) ; v2(248.07,115.73) 248.67,116.32 PC6360.2 249.11,115.68 248.58,115.15 v2(248.07,115.15) ; v2(228.42,107.45) v2(229.12,107.45) 229.2,107.37 230.44,107.37 v2(230.52,107.45) ; v2(245.19,65.91) 245.33,65.76 CG157.2 ; v2(244.52,94.75) 244.48,94.71 PC6337.2 243.16,94.71 v2(243.12,94.75) 242.71,95.16 PC6368.2 242.13,95.16 v2(241.72,94.75) 241.31,95.16 PC6364.2 240.73,95.16 v2(240.32,94.75) 239.91,95.16 PC6312.2 239.34,95.16 238.93,94.75 v2(238.92,94.75) v2(238.22,94.75) ; RG109.2 277.55,107.36 v2(277.6,107.31) ; US1.16 183.28,66.93 182.97,67.23 v2(182.97,67.35) 183.05,67.43 US1.15 ; v2(233.99,57.11) 233.51,57.59 CG185.2 ; C10.2 182.84,83.75 183.3,83.75 183.6,83.44 U20.5 ; v2(228.42,97.55) 227.85,98.12 CG237.2 228.26,99.11 v2(228.42,98.95) v2(229.12,98.95) 229.27,99.1 PC6320.2 230.32,99.1 v2(230.52,98.9) ; RG120.2 276.16,71.21 v2(275.6,71.21) 275.46,71.35 v2(275.46,72.37) ; v2(228.42,93.35) 228.32,93.35 227.8,92.83 226.93,93.69 CG58.2 ; PC6366.2 254.9,107.3 v2(255.15,107.05) ; v2(255.81,106.38) 255.79,106.4 PC6352.2
  TOP w0.356: CG303.2 222.76,110.16 v2(222.77,110.15) ; CG307.2 220.48,111.84 v2(220.22,112.1) 220.06,112.26 CG34.2 ; UG25.3 278.55,147.49 278.91,147.13 v2(278.91,146.68) ; v2(186.25,160.53) 186.59,160.19 CT56.2 ; v2(192.23,102.25) 192.19,102.29 RG24.2 ; RT37.2 170.1,167.29 v2(170.57,167.76) 171.01,168.2 RT17.2 ; RV8.2 RV1.2 ; v2(190.17,104.87) RG150.2 ; CG18.2 224.17,105 v2(224.17,105.25) ; v2(166.96,126.34) 166.87,126.34 166.68,126.15 PC1161.2 PC1099.2 ; v2(232.82,31.6) 232.82,31.58 232.8,31.56 232.8,30.71 RE504.2 ; v2(171.76,160.58) 171.92,160.43 RT38.2 RT11.2 ; RE509.2 v2(233.05,28.07) ; CG483.2 281.45,145.33 282.16,146.04 v2(282.16,146.37) ; PC1162.2 164.99,124.84 v2(164.66,124.51) ; v2(278.91,142.9) 278.52,143.29 UG29.3 ; v2(176.79,158.42) 176.84,158.47 RT18.2 ; RG151.2 193.84,112.8 v2(193.98,112.8) ; RE497.2 v2(233.05,34.55) ; CV23.2 v2(243.66,162.86) ; CT113.2 203.84,167.63 v2(204.35,167.12)
  TOP w0.381: v2(229.35,116.57) 229.33,116.59 RG38.2 ; v2(24.89,39.96) 24.91,39.93 25.49,39.93 26.3,39.12 CA259.2 ; v2(30.3,49.98) 30.3,49.38 30.32,49.36 CU76.2 ; QE46.4 233.78,33.72 233.5,34 RE497.2 ; Q7.4 319.89,45.68 v2(319.99,45.77) ; CA256.2 v2(34.49,3.25) ; v2(237.02,28.25) 237.02,28.59 236.74,28.87 RE501.2 236.43,28.91 236.16,29.19 QE47.1 ; v2(241.95,116.57) 241.87,116.49 CG308.2 ; v2(281.48,163.16) 281.45,163.13 CG479.2 ; v2(236.12,101.08) 236.12,100.26 PC6409.2 ; v2(211.61,43.31) 212.34,42.57 RH168.2 ; CA11.2 37.54,29.65 36.59,28.69 v2(36.52,28.69) ; QE48.4 233.78,27.25 233.5,27.52 RE509.2 ; v2(190.17,104.87) 190.19,104.87 190.41,104.65 190.41,104.09 189.5,103.18 UG24.4 ; RG37.2 231.55,117.22 v2(231.45,117.12) ; CH182.2 215.64,37.79 v2(216.42,37.01) ; CA59.2 36.01,18.17 35.82,18.36 v2(35.82,18.79) ; v2(157.56,109.72) 158,109.72 PC1020.2 ; v2(123.37,63.01) 123.4,62.97 CD75.2 ; v2(309.01,61.37) 308.52,60.87 UG23.4 ; v2(274.85,149.32) 275.18,148.99 CG480.2 ; CG305.2 223.82,106.95 223.57,107.2 v2(223.57,107.45) ; CU29.2 21.87,37.39 UU5.3 ; v2(224.6,60.27) 224.6,60.26 CG373.2 ; v2(197.98,102.5) 197.81,102.5 197.42,102.9 CG459.2 ; QE5.4 286.31,25.09 286.37,25.15 v2(286.37,25.24) ; v2(230.83,25.07) RE512.2 ; v2(193.33,17.68) 193.81,17.2 CH187.2 ; RG53.2 276.06,117.07 276.08,117.09 ; QV97.1 219.58,158.92 218.75,158.1 218.75,157.14 219.07,156.82 219.67,156.82 219.95,157.1 v2(219.95,157.38) ; PC1029.2 139.53,110.1 v2(139.14,110.1) ; v2(103.62,56.32) 103.68,56.38 104.89,56.38 PQ202.1 ; v2(207.78,27.46) 207.57,27.26 CH188.2 ; CH107.2 168.56,114.48 168.78,114.27 ; CT102.2 196.21,169.93 v2(195.03,169.93) ; CH176.2 214.84,34.83 v2(214.81,34.8) 214.79,34.78 RH28.2 RH22.2 ; v2(157.56,108.51) 158,108.51 PC1021.2 ; CG309.2 243.89,115.19 v2(244.42,115.73) ; v2(230.83,28.31) RE519.2 ; UC2.3 124.28,80.52 124.09,80.33 v2(123.71,80.33) ; v2(182.97,73.49) 182.29,72.81 QG512.3 ; v2(302.21,51.22) PR6435.1 ; v2(214.77,111.69) 214.9,111.82 UG30.1 ; PC1104.2 162.31,103.15 PC1097.2 162.45,102.83 162.45,102.36 v2(162.55,102.26) ; RA79.2 RA78.2 v2(31.56,18.66) ; QE48.1 235.85,25.74 v2(236.44,25.14) ; v2(301.13,61.59) 301.13,61.25 PC6441.1 301.4,60.94 PR6420.2 ; PC1023.2 154.77,108.51 v2(155.21,108.51) ; v2(313.42,61.64) 313.81,61.64 313.91,61.53 CG476.2 ; v2(270.52,35.96) 270.52,35.86 270.9,35.47 RE641.2 271.22,35.52 QE57.1 ; v2(216.87,21.4) CH174.2 217.23,20.69 217.41,20.88 217.68,20.88 217.97,21.16 RH11.2 ; v2(233.49,24.91) 233.23,24.66 RE508.2 ; v2(187.43,99.87) 188.16,99.87 UG24.1 ; RH184.2 132.4,113.96 v2(131.76,113.96) ; v2(237.05,31.55) 237.05,31.83 RE496.2 236.43,32.15 236.16,32.42 QE46.1 ; v2(221.78,163.53) 222.22,163.98 UX1.3 ; CG301.2 239.45,112.93 v2(239.57,113.05) ; v2(159.91,108.51) 159.46,108.51 PC1024.2 ; v2(165.3,102.23) 164.61,102.92 PC1134.2 ; QE47.4 233.92,30.46 RE504.2 ; v2(143.35,100.35) 143.26,100.27 CH124.2 ; v2(199.13,165.33) 198.68,165.33 198.45,165.09 RT83.1 ; CH201.2 220.96,37.96 220.96,37.24 v2(221.09,37.11) ; v2(169.17,162.87) 169.39,162.65 RV8.2 ; PC6427.1 297.95,56.65 v2(298.01,56.58) ; RU25.2 v2(295.26,66.64) ; PQ9.4 117.52,80.92 PR29.2 117.23,81.46 117.61,81.84 v2(117.91,81.84) ; v2(37.09,4.05) 37.09,3.79 RA74.2 ; v2(199.23,165.9) 199.16,165.98 CT101.2 ; v2(319.03,51.24) PR9.1 ; v2(203.64,167.06) 203.57,167 CT112.2 ; v2(224.67,164.2) 223.97,164.2 RG25.2 ; UG28.3 v2(281.59,158.85) ; v2(212.79,39.54) 212,40.33 RH9.2 ; PC1025.2 159.46,109.72 v2(159.91,109.72) ; CH192.2 206.16,26.09 206.74,25.5 CH231.2 207.49,25.5 v2(207.63,25.37) ; CC37.2 CC36.2 171.29,102.23 171.83,102.23 172.01,102.05 v2(172.01,101.67) ; PC1026.2 162.7,109.72 v2(162.26,109.72) ; v2(304.94,51.22) PR6434.1 ; PC6350.2 232.36,91.51 v2(231.92,91.95) ; v2(308.81,54.85) PR6404.1 ; PC6426.1 297.88,58.31 v2(297.92,58.35) ; RT62.2 198.26,161.83 197.87,161.44 v2(197.67,161.44) ; CH118.2 144.22,102.86 v2(144.27,102.91) ; PC1022.2 154.77,109.72 v2(155.21,109.72) ; CG4.2 235.96,112.35 v2(236.17,112.35) ; PC6357.2 PC6323.2 ; PC6369.2 PC6335.2 ; CG56.2 243.51,90.53 PC6302.2 242.45,89.93 v2(242.07,89.55) ; v2(208.05,39.06) 207.22,39.89 RH14.2 ; PC1207.2 165.12,125.27 PC1162.2 ; v2(141.49,110.1) 141.88,110.1 PC1028.2 ; v2(213.12,34.09) 212.74,33.71 CH233.2 ; v2(278.44,154.55) 278.37,154.47 UG26.3 ; v2(217.04,113.08) 216.62,113.5 UG30.4 ; C4.2 v2(178.49,75.35) ; CG311.2 245.82,115.15 v2(246.13,115.47) ; v2(228.1,119.62) 228.16,119.56 CG49.2 CG47.2 ; v2(37.28,18.79) 37.28,18.72 36.9,18.34 CA58.2 ; v2(230.83,31.55) RE527.2 ; RT47.2 RT4.2 173.51,166.89 173.54,166.92 v2(173.54,166.98) ; v2(162.26,108.51) 162.7,108.51 PC1027.2 ; v2(222.83,22.79) 223.06,22.56 RE515.2 223.5,22.56 ; CH180.2 203.49,25.82 v2(203.94,25.36) ; CG478.2 v2(277.36,158.28) ; RE638.2 272.64,38.3 QE57.4 272.52,37.87 272.13,37.49 v2(269.38,37.49) ; CH190.2 203.86,22.99 v2(203.94,23.07) ; CG13.2 243.15,112.49 243.71,113.05 v2(243.77,113.05) ; UG23.1 v2(309.81,61.96) ; v2(199.83,165.83) 199.83,166.08 199.74,166.17 RT125.2 ; v2(143.78,110.1) 144.22,110.1 PC1031.2 ; RE523.2 v2(230.83,21.77)
  TOP w0.4: 276.08,117.09 v2(276.15,117.16)
  TOP w0.406: UG22.3 216.84,158.11 217.24,157.7 v2(217.24,157.4) ; v2(17.8,40.29) DU2.3 ; C2518.2 129.52,101.24 v2(130.18,101.24)
  TOP w0.432: QE49.1 228.02,27.59 v2(227.52,28.09) ; v2(228.99,33.71) 228.23,33.71 228.21,33.72 QE53.1 ; v2(227.58,24.72) 227.72,24.59 227.72,24.18 227.9,24.01 QE52.1 ; QE1.4 323.97,40.81 323.75,40.58 v2(323.41,40.58) ; QG503.4 189.42,113.43 188.32,113.43 188.31,113.42 v2(188.29,113.42) ; QG502.1 212.03,158.01 211.44,157.41 211.44,156.8 v2(211.44,156.8) ; QE4.1 323.94,47.03 v2(323.6,47.36) ; v2(191.59,111.5) 191.33,111.75 QG503.1 ; Q7.1 321.19,47.12 v2(320.79,47.53) ; v2(205.69,174.43) 205.71,174.45 QE22.1 ; v2(188,107.45) 188.03,107.45 188.03,107.42 188.46,107.42 188.89,106.99 QG504.1 ; QE21.1 200.77,175.14 v2(200.77,174.35) ; Q34.1 107.74,24.6 v2(108.09,24.95) ; v2(113.17,25.01) 112.88,24.73 Q28.1 ; v2(119.52,26.91) Q29.4 ; v2(192.51,107.81) 192.58,107.73 QG505.1 ; QE51.1 228.02,30.75 227.45,31.31 v2(227.44,31.31) ; QE1.1 325.27,43.12 324.84,43.55 v2(324.74,43.55) ; v2(225.94,25.07) QE50.1 ; v2(327.87,41.9) 327.87,42.21 327.75,42.33 Q9.1 ; v2(203.56,174.41) 203.24,174.74 QE13.1 ; v2(327.16,47.36) 326.91,47.36 326.48,46.93 QE3.1 ; Q28.4 v2(114.18,26.91) ; v2(118.35,24.95) 118.35,24.67 118.22,24.54 Q29.1 ; v2(320.93,40.31) 321.24,40.63 Q8.4 ; Q34.4 109.04,26.5 109.29,26.75 v2(109.29,26.98) ; Q8.1 323.28,42.85 v2(323.35,42.92) ; QE3.4 324.93,45.14 v2(324.56,45.14) ; v2(322.64,45.71) QE4.4 ; QE50.4 224.56,22.56 223.5,22.56 ; v2(327.29,41.91) 327.04,41.91 326.45,41.31 Q9.4 ; QG504.4 v2(190.19,107.92)
  TOP w0.457: PC6203.2 221.7,156.35 v2(221.7,157.38) ; CH173.2 CH80.2 212.75,16.37 212.68,16.44 212.68,16.62 v2(212.58,16.73) ; v2(217.18,17.58) 217.13,17.58 216.75,17.96 RH90.1 ; CE79.2 145.9,168.22 v2(146.55,168.22) ; CD73.2 140.92,56.12 141.18,56.39 v2(141.73,56.39) ; v2(24.86,38.98) 24.86,38.93 24.41,38.47 22.32,38.47 21.87,38.01 CU29.2 ; v2(237.63,166.93) 236.92,167.64 JLOGO.16 ; JWDB.6 206.23,13.67 205.45,14.45 v2(205.45,15.46)
  TOP w0.508: v2(162.92,47.75) 163.21,48.04 CD20.2 ; PR306.2 244.12,16.4 v2(244.53,15.99) ; PR6413.1 309.85,56.89 v2(309.65,56.7) ; CG422.2 272.14,95.74 CG340.2 272.2,96.52 v2(272.15,96.56) ; PD1.1 v2(321.89,51.03) ; v2(219.11,58.71) 219.23,58.59 CG369.2 ; v2(241.82,45.33) 241.82,45.14 241.97,44.99 241.97,44.17 241.47,43.67 PC803.2 ; PR216.2 v2(104.02,52.99) 103.37,52.99 PC217.2 ; CD81.2 166.4,50.12 v2(166.31,50.22) ; v2(204.8,109.78) 204.34,110.24 RG90.1 ; v2(128.34,159.5) 127.79,159.5 RC348.2 RC35.2 ; v2(128.15,153.48) 127.86,153.19 CM29.2 ; CD23.2 140.48,41.94 v2(140,42.43) ; v2(192.23,99.85) 192.19,99.89 CG389.2 191.3,99.85 CG470.2 ; RH209.2 CD18.2 RH211.2 153.91,55.37 v2(153.48,55.79) ; CD29.2 155.35,41.87 v2(155.54,42.06) ; CG347.2 257.1,54.63 v2(257.19,54.71) ; v2(145.62,59.92) 145.14,59.92 144.09,60.97 CD6.2 ; CG213.2 201.01,75.24 v2(201.03,75.25) ; RG161.2 200.05,71.78 v2(200.03,71.8) ; v2(183.27,84.45) 182.77,84.45 C10.2 ; v2(196.23,76.05) 196.01,76.27 CG402.2 ; CD19.2 134.07,50.39 v2(134.09,50.41) ; v2(197.03,76.05) 197.05,76.08 CG192.2 ; v2(193.03,98.25) 193.01,98.24 CG396.2 193.05,97.53 CG461.2 193.04,96.6 CG469.2 ; CD92.2 CD91.2 137.75,50.65 v2(137.42,50.32) ; RH199.2 220.47,37.11 v2(221.09,37.11) ; CA23.2 33.98,25.59 v2(34.5,25.07) ; v2(324.52,8.39) 324.54,8.39 324.54,8.31 323.06,6.82 YE1.2 ; CH125.2 156.95,102.37 v2(157.06,102.26) ; v2(176.71,56.49) 177.03,56.49 177.5,56.96 RD29.2 ; v2(27.4,10.6) 27.44,10.6 27.44,10.91 CA62.2 CA63.2 ; v2(150.91,59.28) 150.65,59.28 150.01,59.92 CD5.2 ; v2(201.03,99.05) 201.04,99.04 CG211.2 CG463.2 201.01,97.5 CG464.2 ; v2(259.59,60.31) 259.65,60.25 CG439.2 ; CE63.1 315.4,55.69 v2(315.67,55.43) ; CE62.2 v2(312.91,58.4) ; v2(257.44,159.69) CL38.1 CL39.2 ; CL15.2 v2(267.65,171.17) ; DA7.1 v2(47.59,13.34) ; CE42.2 305.53,6.96 v2(305.94,7.37) ; v2(305.57,31.09) RE162.2 ; CG460.2 193.77,103.58 CG215.2 193.8,102.93 v2(193.83,102.9) ; RA77.2 CA60.2 35.12,18.72 v2(35.19,18.79) ; v2(192.23,73.65) 192.22,73.66 CG214.2 191.39,74.4 CG405.2 ; RA80.2 26.49,16.88 v2(26.3,16.69) ; CN25.2 v2(318.19,38.76) ; v2(276.49,101.31) 276.32,101.48 CG313.2 ; v2(117.52,52.31) 117.03,52.8 CD83.2 ; CG346.2 249.38,57.12 v2(249.39,57.11) ; CD82.2 167.62,50.11 v2(167.53,50.2) ; v2(16.79,31.72) RA1.2 ; CE59.2 310.69,21.26 v2(310.65,21.31) CE38.2 ; CH186.2 215.17,17.55 215.57,17.96 RH90.1 ; 180.86,52.57 v2(181.54,52.57) ; v2(301,45.58) 300.72,45.3 CM13.2 ; v2(332.28,49.77) 332.86,49.19 C617.2 C618.2 ; C6.2 179.33,84.47 v2(179.85,84.99) ; CG474.2 RG88.1 199.65,113.62 v2(199.35,113.92) ; CS7.2 181.67,69.12 182.03,69.48 v2(182.71,69.48) ; v2(31,34.98) 30.74,35.23 RA6.2 ; CG90.2 274.54,92.46 ; 274.54,92.46 CG412.2 ; 274.54,92.46 275.09,92.46 275.38,92.75 CG423.2 ; v2(323.16,21.94) 322.63,21.4 CU45.2 ; CM21.2 165.49,163.73 v2(165.74,163.48) ; v2(253.99,54.71) 254.16,54.54 CG349.2 ; CE170.2 311.97,27.66 v2(311.48,27.17) 311.34,27.03 308.75,27.03 308.53,27.25 308.53,27.38 308.3,27.61 RE5.2 ; v2(237.19,63.51) 237.22,63.48 CG153.2 237.83,63.47 CG378.2 ; CG472.2 199.67,94.3 CG204.2 200.98,94.3 v2(201.03,94.25) ; v2(190.41,9.9) 190.79,9.52 CT117.2 ; v2(309.83,47.3) RM31.2 ; PC6428.2 v2(284.83,53.88) ; RE658.2 288.22,23.16 QE5.1 289.1,23.18 RE650.2 289.98,23.02 v2(290.06,23.1) ; v2(249.39,57.91) 249.34,57.95 CG345.2 ; PC587.2 v2(185.3,136.2) ; JTOBII.7 154.06,168.85 v2(154.21,169) 154.56,168.65 JTOBII.1 154.56,166.56 153.93,165.93 CE81.2 ; CG438.2 257.92,62.64 v2(257.99,62.71) ; CU48.2 316.4,26.22 v2(316.86,26.67) CU16.2 ; v2(254.01,58.71) 254.33,59.03 CG351.2 CG428.2 ; v2(187.27,27.49) 187.03,27.24 RE37.2 ; v2(296.5,29.1) 296.98,28.62 CE29.2 ; YU1.4 v2(13.05,50.24) ; v2(304.66,28.74) 304.55,28.62 CE41.2 CE30.2 ; v2(321.32,20.06) 320.48,20.06 318.58,21.96 CU11.2 ; v2(277.65,152.15) 277.47,152.33 PQ8203.1 ; PC6416.2 303.52,48.74 v2(303.52,48.19) ; v2(274.84,25.17) 275,25.01 C620.2 C627.2 ; v2(253.19,53.11) 253.13,53.06 CG430.2 253.13,51.59 CG440.2 ; CL32.1 CL35.2 v2(249.94,159.63) ; CL36.1 CL37.2 v2(255.85,159.67) ; v2(221.04,162.08) 221.43,161.69 221.89,161.69 RX4.2 ; CG135.2 249.96,65.88 v2(249.99,65.91) ; CG458.2 201.7,94.38 v2(201.83,94.25) ; v2(72.14,9.37) 71.97,9.2 PQ4.3 ; RG93.1 202.98,110.42 v2(203.27,110.71) ; v2(148.8,54.11) 150.01,54.11 CD71.2 ; v2(217.24,157.4) 217.02,157.17 CG489.2 ; v2(111.01,64.7) 109.72,65.98 JFAN1.5 ; v2(227.95,45.4) 227.49,44.94 U18.2 ; v2(236.55,41.91) 236.61,41.98 236.66,41.98 237.17,42.49 PR813.1 ; RG163.2 197.61,78.67 v2(197.03,79.25) ; v2(197.83,83.25) 197.74,83.16 RG162.2 ; v2(174.49,183.16) CV14.2 ; RA16.2 30.23,24.63 v2(29.79,25.08) ; CU7.2 v2(18.55,42.22) ; DK3.1 141.7,3.46 v2(142.06,3.1) ; v2(147.25,165.83) 147.72,166.3 UE12.2 ; PC720.1 52.97,26.47 PC718.1 v2(52.19,26.49) ; v2(270.55,80.56) 270.48,80.49 CG356.2 ; v2(269.75,99.76) 269.54,99.97 CG343.2 CG416.2 ; JEDP.43 148.52,178.09 v2(148.15,177.73) ; CE24.2 RE31.2 224.09,159.44 223.47,158.81 v2(223.47,158.61) ; RG101.2 196,109.66 v2(196.43,109.22) ; CU17.2 v2(320.3,27.49) 320.16,27.63 RE645.1 ; v2(100.27,72.13) JFAN1.6 ; v2(269.15,90.16) 268.75,90.56 CG411.2 268.73,91.02 CG410.2 ; v2(167.91,99.56) 167.9,99.55 CH126.2 ; v2(182.4,48.9) CD30.2 ; CE28.2 289.87,9.01 v2(289.43,8.56) 288.96,9.03 RE66.1 ; C2522.2 228.9,43.01 v2(229.62,42.28) ; v2(237.99,54.71) 238.05,54.65 CG379.2 ; PR520.2 v2(128.81,135.06) ; v2(144.06,42.13) 143.59,41.66 CD26.2 ; v2(272.95,83.76) 273.03,83.85 CG354.2 ; v2(106.63,59.18) 106.63,60.06 107.58,61.01 CF4.2 ; v2(193.03,79.25) 192.91,79.14 CG198.2 ; v2(253.44,118.8) PC6369.2 ; CE56.2 326.29,43.87 QE1.1 ; CU51.2 8.16,53.85 7.6,53.29 7.26,53.29 H9.1 ; CG425.2 270.47,95.77 CG341.2 270.46,96.47 v2(270.55,96.56) ; v2(205.03,75.25) 205.27,75.49 CG404.2 ; v2(271.35,118.76) 271.43,118.85 CG328.2 ; CG395.2 202,102.68 v2(202.23,102.45) ; PC119.2 54.93,32.79 PC118.2 53.94,32.77 53.94,32.14 v2(53.73,31.93) ; QL3.3 268.66,161.1 268.17,161.6 CL31.2 ; v2(154.81,47.74) 154.4,48.14 CD25.2 ; v2(220.58,34.48) 220.95,34.12 RH135.1 ; JTOBII.5 157.76,168.22 158.38,168.84 v2(158.38,169.64) ; DK1.1 145.46,3.6 v2(145.96,3.1) ; v2(86.56,37.86) PC216.2 PC208.2 ; v2(253.19,66.71) 253.22,66.74 CG124.2 CG432.2 ; PD2.1 83.4,13.82 83.7,13.52 85.54,13.52 v3(85.68,13.38) 86.05,13.01 v2(86.05,11.67) ; RH497.1 131.1,158.74 v2(131.86,157.98) ; PC6323.2 v2(253.06,121.4) ; v2(138.63,2.72) 138.63,2.72 138.6,2.7 137.74,2.7 DK2.1 ; C29.2 R180.2 208.37,7.74 v2(208.99,8.35) 208.71,8.63 C2509.2 ; CA254.2 38.46,5.93 39.02,6.49 39.02,6.72 CA54.2 39.26,6.77 v2(39.95,6.09) 39.95,7.41 39.44,7.92 CA53.2 ; CG407.2 204.02,71.85 v2(204.23,72.05) ; CG342.2 271.32,99.79 v2(271.35,99.76) ; CG317.2 226.77,64.75 226.33,64.31 v2(226.19,64.31) ; CG467.2 203.84,104.35 CG190.2 203.84,102.47 v2(203.83,102.45) ; CH104.2 167.52,113.18 v2(167.16,113.54) ; v2(332.62,7.17) 329.29,7.17 328.47,7.99 JIO.33 ; CV375.2 v2(169.25,183.62) ; 168.78,114.27 168.8,114.25 v2(169.42,114.25) ; RE42.2 RE44.2 226.55,155.43 v2(226.83,155.71) ; v2(130.16,60.49) 130.13,60.52 CD78.2 ; PC532.2 126.12,149.33 126.26,149.47 v2(126.87,149.47) 126.87,148.89 PC530.1 ; JFAN2.5 v2(293.72,81.89) ; v2(286.84,26.28) CE31.1 ; v2(220.61,15.18) 220.61,15.23 220.75,15.37 RH88.1 ; CH195.2 134.57,117.28 v2(134.62,117.22) ; v2(217.39,53.91) 217.39,53.79 216.76,53.17 CG370.2 CG366.2 ; CH197.2 126.15,76.77 v2(126.3,76.92) ; v2(49.54,8.18) 49.54,8.94 49.14,9.34 DA8.1 ; v2(161.39,166.69) 162.34,166.69 DV2.1 ; v2(235.59,60.31) 235.59,60.3 CG381.2 ; CG350.2 256.92,56.65 v2(256.99,56.71) ; PR500.1 v2(126.81,134.6) ; CE45.2 299.61,29.91 300.27,29.25 300.27,28.98 300.36,28.9 CE34.2 300.49,28.77 300.62,28.64 CE36.2 301.25,28.88 v2(301.63,29.26) 302.03,29.66 RE662.2 ; CG403.2 198.46,81.49 v2(198.63,81.65) ; RT108.2 v2(319.92,54.52) ; CA57.2 v2(27.63,7.74) ; PR6065.1 PR6064.1 280.56,140.42 280.21,140.78 279.21,140.78 v2(278.86,140.44) ; v2(32.63,39.8) CA9.2 31.96,40.64 CA10.2 ; PR33.1 120.51,78.46 120.12,78.85 PQ9.1 119.32,79.62 118.56,78.86 v2(117.91,78.86) ; PC588.1 180.81,146.26 181.39,145.67 ; CU28.2 30.62,43.98 v2(30.62,43.62) ; RG106.2 274.74,95.77 CG335.2 ; YE1.4 320.6,9.07 321.11,9.58 321.32,9.58 321.34,9.6 321.38,9.6 321.74,9.96 321.74,10 321.76,10.02 v2(321.76,10.15) ; JTOBII.8 159.86,169.12 v2(158.87,170.11) ; CG89.2 280.07,106.12 CG333.2 ; v2(270.55,110.76) 270.44,110.87 CG325.2 CG332.2 ; v2(225.12,116.55) 225.57,116.09 CG238.2 ; 194.9,184.05 CT94.1 ; RA76.2 30.16,3.75 29.98,3.93 CA257.2 29.4,4.23 v2(29.28,4.12) ; v2(174.26,180.46) 174.22,180.43 JEDP.44 ; v2(324.61,26.6) 325.07,27.06 JIO.32 ; PR6066.1 PR6067.1 280.56,136.69 v2(280.44,136.57) ; CH103.2 167.62,107.99 v2(167.21,107.58) ; v2(182.95,22.22) RE30.2 RE29.2 ; PC13.1 293.21,8.25 v2(293.67,8.72) 294.14,8.25 PR26.1 ; CS5.2 v2(125.48,10.4) ; v2(152.85,59.54) 152.99,59.54 153.5,60.04 153.5,60.91 CD70.2 ; v2(205.03,94.25) 205.03,94.39 205.38,94.75 CG199.2 205.39,95.06 CG398.2 ; CD27.2 182.11,49.98 182.38,49.71 v2(182.38,49.72) ; RG108.2 275.33,99.78 v2(275.35,99.76) ; RE75.2 CE44.2 v2(293.11,28.9) ; CG452.2 221.41,56.71 CG457.2 222.02,56.7 v2(222.04,56.71) ; v2(240.17,15.89) 240.17,16.44 240.67,16.95 PR308.2 PC300.2 ; v2(270.15,106.71) 270.04,106.6 CG326.2 ; CG455.2 221.31,67.05 CG169.2 ; CH120.2 173.2,100.89 v2(173.55,101.24) ; CG361.2 271.65,72.26 v2(271.75,72.36) ; RG58.2 219.81,61.92 CG365.2 219.8,62.51 CG170.2 218.38,62.51 v2(218.19,62.71) ; CG414.2 277.55,102.61 CG336.2 CG338.2 v2(277.55,100.06) ; CM100.2 v2(318.58,45.7) ; CG363.2 272.31,75.92 v2(272.15,75.76) ; v2(198.18,71.8) 198.05,71.68 CG408.2 ; v2(76.65,11.23) 76.14,10.72 PQ8.3 ; CL29.2 CL28.2 v2(262.72,159.3) ; CM14.2 v2(315.54,45.24) ; v2(232.82,56.98) 232.43,57.36 CG376.2 ; v2(142.31,164.33) 142.68,164.7 CE82.2 ; CE40.1 310.13,15.7 v2(310.71,15.7) ; RA9.2 36.6,28.35 36.52,28.43 v2(36.52,28.69) ; v2(126.49,14.16) CS16.2 ; v2(31.28,38.59) CA7.2 ; PR303.1 241.82,22.61 241.82,22.72 v2(242.13,23.03) ; v2(332.05,39.98) 331.92,40.11 CE55.1 ; CT88.2 v2(194.69,167.1) ; CG487.2 191.74,111.34 v2(191.59,111.5) 191.59,110.59 192.21,109.97 RH589.1 ; v2(258.64,53.2) 258.76,53.09 CG348.2 258.77,52.37 CG426.2 ; v2(280.15,111.56) 280.18,111.6 CG330.2 ; v2(276.95,98.16) 277.08,98.16 277.59,97.65 CG413.2 277.59,96.61 CG421.2 ; v2(271.75,106.71) 271.75,105.9 272.37,105.27 CG314.2 ; v2(130.57,118.38) 130.49,118.38 129.98,117.87 CH194.2 ; CG91.2 277.34,92.75 CG424.2 ; CT115.2 186.95,8.94 186.95,11.67 187.06,11.79 187.06,11.85 v2(187.17,11.96) ; CD85.2 147.77,46.47 v2(147.01,45.71) ; C622.2 v2(332.75,51.04) ; v2(266.52,33.59) 266.52,31.13 266.1,30.71 PC8210.2 ; v2(64.69,15.88) 65.13,16.32 PC11.2 ; RU2.1 19.41,45.75 v2(19.06,45.39) ; v2(302.65,45.46) 302.65,44.93 CM10.2 ; CG359.2 CG138.2 270.57,75.78 v2(270.55,75.76) ; v2(172.02,180.62) JEDP.42 ; CD79.2 119.53,60.8 v2(119.86,60.47) ; 180.86,53.84 v2(181.74,53.84) ; CL22.2 272.96,168.71 v2(273.49,168.18) ; CG471.2 CG393.2 CG195.2 199.96,102.65 ; JIO.31 v2(324.59,10.76) 324.46,10.76 323.59,11.62 CE7.2 ; v2(257.99,65.11) 257.92,65.18 CG352.2 ; CE1.2 323.37,18.15 v2(323.37,17.26) ; CG449.2 221.38,58.47 CG443.2 221.91,58.44 v2(222.04,58.31) ; CG191.2 197.06,98.29 v2(197.03,98.25) 196.8,98.02 CG394.2 ; v2(155.34,38.68) 155.35,38.69 RH212.2 RH210.2 ; v2(205.83,72.05) 205.83,72.05 CG210.2 205.81,71.35 CG401.2 ; v2(153.41,102.86) 152.8,102.86 CH122.2 ; RG116.2 v2(274.32,86.14) ; CG400.2 191.54,81.59 CG202.2 192.22,81.65 v2(192.23,81.65) ; RE37.2 187.97,26.77 CE25.2 ; RE37.2 RE27.2 ; v2(288.44,74.54) 288.69,74.79 CF5.2 ; v2(281.08,163.72) 280.73,164.07 CG481.2 ; v2(27,7.67) 27,7.42 CA55.2 ; v2(256.17,53.2) 256.29,53.08 CG436.2 256.29,51.57 CG437.2 ; DV4.1 167.05,165.69 166.79,165.43 166.79,165.33 v2(166.69,165.23) ; v2(198.18,90.8) 197.8,91.18 RG157.2 ; CG384.2 195.28,105.95 195.88,105.35 v2(195.89,105.35) 195.9,105.36 CG475.2 ; v2(330.02,31.74) 330.45,32.18 C621.2 C623.2 ; v2(199.43,100.65) 199.46,100.63 RG453.2 ; v2(191.58,79.62) 191.51,79.62 190.57,78.68 CG187.2 CG186.2 ; RE83.2 310.08,25.69 v2(310.08,24.84) 310.08,24.85 CE32.1 ; v2(134.61,54.83) 134.69,54.83 CD76.2 ; v2(193.83,71.4) 193.73,71.31 CG197.2 CG399.2 ; RL3.2 v2(275.99,160.51) ; CG364.2 217.38,52.34 v2(217.37,52.33) ; RD30.2 155.66,50.34 v2(155.65,50.35) ; C2520.2 183.18,78.12 v2(182.95,78.35) C7.2 ; CG371.2 CG372.2 214.7,53.33 214.99,53.62 v2(214.99,53.91) ; CA8.2 32.2,37.38 v2(31.71,36.88) ; v2(182.4,51.19) CD28.2 ; v2(243.4,10.09) C640.2 C639.2 ; PC6440.2 278.81,51.14 v2(279.15,51.49) ; v2(280.55,95.61) 280.73,95.43 CG415.2 ; JWDB.4 203.09,14.21 v2(202.89,14.41) ; PC6444.2 v2(279.92,67.62) ; CG482.2 278.7,162.84 v2(278.82,162.84) ; CU26.2 16.68,36.33 JUSB1.4 ; PC12.2 v2(68.88,7.64) ; v2(226.79,54.71) 226.95,54.55 CG447.2 CG442.2 CG444.2 ; CH102.2 169.37,105.57 v2(169.41,105.61) ; RU3.1 v2(18.97,43.08) ; v2(169.46,52.22) 168.49,53.19 CD74.2 ; CL12.2 268.32,168.82 v2(267.9,168.41) 268.37,167.94 CL13.2 ; CU85.2 22.42,48.9 v2(21.99,49.34) ; v2(277.4,68.89) PC6375.2 ; C625.2 C628.2 v2(273.94,23.1) ; v2(267.62,170.06) 268.22,170.06 CL14.2 ; CG216.2 195.72,70.98 195.43,71.27 v2(195.43,71.4) ; CG420.2 268.54,98.77 v2(269.15,98.16) 268.63,97.64 CG417.2 ; JFAN1.4 103.12,66.09 103.63,66.6 v2(105.1,66.6) ; CG429.2 250.06,55.44 v2(249.99,55.51) ; v2(224.11,120.99) 224.25,120.84 224.25,119.47 CG239.2 ; v2(157.36,42.22) 157.36,42.15 158.01,41.51 CD80.2 ; v2(310.63,17.62) CE27.2 ; v2(13.34,52.63) 12.7,52.63 12.47,52.86 CU52.2 ; CE80.2 143.87,168.29 v2(144.19,167.97) ; v2(27.06,14.21) 27.43,14.21 RA82.2 ; RA4.2 25.54,16.69 v2(25.6,16.63) ; QE2.3 310.45,8.22 v2(310.84,8.61) 311.62,9.39 CE6.2 ; v2(226.49,59.71) 226.57,59.79 CG456.2 ; CG327.2 278.41,111.71 v2(278.55,111.56) ; v2(175.73,39.5) 175.62,39.39 175.62,38.06 176.04,37.63 RD38.2 RD39.2 ; v2(195.43,79.25) 195.6,79.08 CG206.2 ; CG427.2 262.49,54.6 CG344.2 261.91,54.59 v2(261.79,54.71) ; CG434.2 262.48,56.39 CG141.2 261.84,56.37 v2(261.79,56.31) ; QU1.3 v2(295.19,64.14) ; CM31.2 127.38,154.7 v2(127.96,154.11) ; CD7.2 139.47,60.52 v3(138.34,60.52) v2(137.53,60.52) ; CG418.2 273.17,87.77 CG337.2 273.19,88.33 v2(272.95,88.56) ; CG468.2 191.35,91.99 CG217.2 191.4,91.88 v2(192.23,91.05) ; v2(279.19,150.41) 279.19,150.72 PQ8203.4 ; CG462.2 CG193.2 205.03,98.29 v2(205.03,99.05) ; RG94.1 203.09,113.08 RG91.1 203.7,113.4 204.21,113.91 v2(204.67,113.91) ; v2(165.29,100.87) 165.3,100.87 CH127.2 ; CE43.2 310.6,19.53 v2(310.7,19.63) ; CU46.2 314.3,26.2 v2(314.29,26.19) ; C268.2 225.26,48.07 v2(225.56,48.38) ; v2(281.75,71.91) 281.85,71.81 CG358.2 ; RG557.2 v2(311.35,60.06) ; v2(280.15,71.91) 280.11,71.87 CG140.2 ; CG267.2 270.58,93.48 CG419.2 ; JLOGO.15 235.92,166.99 v2(236.17,166.74) ; v2(278.55,95.61) 278.06,95.12 CG339.2 ; v2(186.58,12.38) 186.57,12.38 186.57,12.37 186.19,11.99 186.19,10.01 CT114.2 ; v2(286.08,12.88) LE2.1 ; CG156.2 233.09,67.29 CG375.2 ; v2(21.94,34.88) 22.34,34.88 CA260.2 ; PC8218.2 243.32,39.65 v2(243.25,39.73) ; v2(272.15,80.62) 272.15,80.06 CG357.2 ; CS1.2 v2(127.45,9.77) ; CG451.2 CG450.2 223.27,51.44 CG454.2 223.31,51.5 CG448.2 223.31,52.99 v2(223.19,53.11) ; v2(181.15,62.9) 181.08,62.9 180.61,62.43 CD3.2 CD4.2 ; v2(197.03,95.2) 197.61,95.78 RG159.2 197.62,95.82 CG473.2 ; v2(233.97,53.11) 234.18,52.9 CG377.2 ; CG106.2 CG334.2 ; PC6445.2 280.69,68.89 v2(281.45,68.13) ; v2(247.91,159.52) CL33.2 CL34.1 ; CG406.2 CG196.2 202.65,72.03 v2(202.63,72.05) ; v2(172.01,100.1) 172.26,99.85 C8.2 ; v2(63.45,47.25) 63.45,47.55 PR116.2 ; v2(27.05,14.86) RA81.2 ; PC716.1 56.54,17.71 PC721.2 v2(56.52,17) ; PC308.2 247.6,17.9 247.09,17.39 v2(247.09,17.33) ; v2(172.01,103.25) 172.07,103.19 CH193.2 ; C2.2 195.73,11.69 v2(195.72,11.67) ; v2(163.37,60.6) 164.09,61.32 CD2.2 ; CG362.2 274.62,75.84 v2(274.55,75.76) ; DA5.1 v2(22.45,18.91) ; v2(142.15,45.26) 142.26,45.37 142.26,47.48 141.55,48.19 140.66,48.19 ; RH215.2 219.46,41.39 220.8,42.73 ; v2(137.41,52.31) 137.43,52.33 CD69.2 ; v2(193.03,76.05) 193.04,76.06 CG212.2 ; CL27.2 v2(242.07,170.92) ; v2(315.1,8.5) SW1.1 ; v2(249.99,64.31) 249.82,64.14 CG433.2 249.32,64.15 CG441.2 ; CG374.2 232.13,61.22 232.64,61.73 v2(232.64,61.91) 232.45,62.09 CG318.2 ; v2(303.79,33.14) 303.49,32.84 QE58.3 ; CG453.2 219.44,53.98 219.67,54.21 CG171.2 219.1,54.6 v2(218.99,54.71) ; PD3.1 v2(78.5,9.39) ; CE2.2 318.13,6.4 v2(317.64,6.4) ; PR578.2 PR562.2 PR560.2 PR580.2 v2(124.34,149.46) ; CD21.2 v2(135.26,42.73) ; v2(115.58,39.52) 114.79,40.3 CD22.2 ; v2(150.41,45.55) 150.2,45.77 CD24.2 ; CG435.2 CG353.2 253.32,62.58 v2(253.19,62.71) ; v2(106.89,54.35) PQ202.4 106.94,55.24 107.23,55.24 107.31,55.32 107.48,55.32 107.7,55.54 PC218.2 107.91,55.53 PR217.2 ; CH226.2 217.74,14.97 v2(217.94,15.18) ; CG331.2 CG329.2 274.71,115.4 v2(274.55,115.56) ; CG431.2 257.48,67.06 257.83,66.71 v2(257.99,66.71) ; CG188.2 206.83,73.25 v2(206.43,73.65) ; v2(277.4,67.62) PC6374.2 ; v2(30.15,30.24) 30.84,29.54 CA261.2 ; v2(217.8,161.5) 217.76,161.46 217.76,160.72 QV97.4 ; v2(318.65,53.41) 317.98,53.41 PQ2.3 ; CD8.2 139.47,54.62 139.22,54.86 139.22,55.71 139.7,56.18 v2(139.85,56.18) ; v2(235.69,160.01) 235.69,160.21 235.37,160.54 QV3.3 ; v2(317.64,8.94) CE8.2 CE5.2 ; v2(276.95,74.16) 277,74.11 CG360.2 ; JFAN2.6 v2(284.27,86.21) ; CG316.2 v2(273.68,67.78) ; v2(199.43,73.65) 199.44,73.66 200.08,73.66 RG450.2 ; 139.26,48.19 139.26,47.44 139.11,47.29 v2(139.11,46.36) ; v2(203.43,94.25) 203.54,94.37 CG201.2 203.53,94.94 CG397.2 ; CE51.2 CE60.2 310.65,10.4 v2(310.66,10.39) ; CG446.2 227.5,56.32 CG445.2 226.82,56.34 v2(226.79,56.31) ; v2(158.12,52.35) 158.12,52.4 157.94,52.58 CD77.2 ; v2(178.49,77.71) 178.48,77.71 177.92,78.26 C2521.2 ; CG205.2 195,95.23 v2(195.03,95.2) ; RG95.1 221.95,115.61 221.82,115.75 v2(221.47,115.75) ; v2(126.09,135.56) 126.09,136.17 PR512.1 ; CM15.2 v2(315.73,40.45) ; CG355.2 269.74,83.77 v2(269.75,83.76) ; CH119.2 150.97,102.9 v2(151.58,102.9) ; v2(156.23,39.55) RD40.2 ; v2(35.75,49.05) 35.75,49.56 CU78.2 CU91.2 ; v2(60.74,18.88) 60.65,18.88 60.14,19.38 PR711.2 ; v2(278.55,114.66) 278.49,114.72 CG324.2 ; CD72.2 152.17,54.43 152.88,55.15 152.88,55.21 v2(153.01,55.33) ; JFAN2.4 287.12,80.23 v2(287.27,80.38) ; v2(242.29,10.6) 242.29,10.18 241.63,9.52 C638.2 ; v2(194.79,9.69) 194.79,8.59 194.78,8.58 CT118.2 194.78,7.17 195.17,6.77 200.4,6.77 200.91,7.28 C2508.2 ; v2(328.47,30.38) JIO.34 ; PC112.2 v2(63.05,50.25) ; v2(193.03,95.05) 193.04,95.06 CG200.2 ; v2(150.49,42.12) 150.95,41.66 CD86.2 ; v2(172.34,60.51) 172.54,60.51 173.12,61.09 CD1.2 ; CE169.2 317.08,28.7 v2(317.08,29.26) ; v2(119.19,136.2) 118.83,135.84 PR532.2 ; CD10.2 180.81,64.72 v2(181.17,65.08) ; CD9.2 180.48,63.51 181.1,64.12 181.1,64.13 v2(181.17,64.13) 181.3,64.25 CS2.2 ; v2(237.99,57.11) 238.02,57.14 CG380.2 ; PR700.1 v2(62.84,33.64) ; RH214.2 219.47,40.44 219.77,40.14 220.55,40.14 v2(220.55,40.12) ; v2(36.22,25.48) 35.82,25.89 CA85.2 ; CS6.2 v2(126.37,10.4) ; CM12.2 v2(301.8,45.87) ; PR28.1 v2(77.37,11.23) ; v2(197.38,168.06) 197.57,168.06 197.84,168.33 198.26,168.33 ; v2(182.4,48.01) CD31.2 ; CE46.2 v2(296.36,6.83) ; YU1.2 v2(11.35,50.19) ; RA7.2 v2(17.24,3.6)
  GND1 w0.203: JCDRA.48 146.17,182.55 ; JCDRA.48 144.17,185.67 ; JCDRA.48 144.17,184.11 ; JCDRA.48 144.17,182.55 ; JCDRA.48 145.17,185.67 ; JCDRA.48 146.17,184.11 ; JCDRA.48 146.17,185.67 ; JCDRA.48 145.17,182.55 ; H10.1 28.07,57.73 ; H10.1 28.07,53.87 ; H10.1 26.65,54.38 ; H10.1 29.49,54.38 ; H10.1 26.14,55.8 ; H10.1 26.65,57.22 ; H10.1 29.49,57.22 ; H10.1 30,55.8 ; 179.43,92.1 H3.1 ; H3.1 183.3,90.47 ; H3.1 183.3,93.73 ; H3.1 180.04,90.47 ; H3.1 180.04,93.73 ; H3.1 181.67,89.86 ; H3.1 183.91,92.1 ; H3.1 181.67,94.34 ; JUSB1.7 15.05,40.46 ; JUSB1.7 14.46,39.11 ; JUSB1.7 15.81,39.7 ; JUSB1.7 15.64,39.11 ; JUSB1.7 14.46,40.29 ; JUSB1.7 15.64,40.29 ; JUSB1.7 15.05,38.94 ; JUSB1.7 14.29,39.7 ; JUSBC2.1 8.08,65.64 ; JUSBC2.1 8.08,67.2 ; JUSBC2.1 5.62,66.42 ; JUSBC2.1 6.85,67.2 ; JUSBC2.1 5.62,67.2 ; JUSBC2.1 8.08,66.42 ; JUSBC2.1 5.62,65.64 ; 5.63,65.19 JUSBC2.5 ; JUSBC2.5 6.35,65.19 ; JUSBC2.5 6.35,67.2 ; JUSBC2.5 7.07,67.2 ; JUSBC2.5 7.07,65.19 ; JUSBC2.5 5.63,66.1 ; JUSBC2.5 5.63,67.2 ; H12.1 277.59,173.82 ; H12.1 276.17,170.47 ; H12.1 274.75,173.82 ; H12.1 278.1,172.4 ; H12.1 276.17,174.33 ; H12.1 274.75,170.98 ; H12.1 274.24,172.4 ; H12.1 277.59,170.98 ; JHDMI.22 224.8,174.4 ; JHDMI.22 223.87,173.12 ; JHDMI.22 222.94,174.4 ; JHDMI.22 223.87,175.68 ; JHDMI.22 222.94,175.68 ; JHDMI.22 224.8,173.12 ; JHDMI.22 222.94,173.12 ; JHDMI.22 224.8,175.68 ; 228.8,173.45 JDP.24 ; JDP.24 229.57,172.14 ; JDP.24 229.57,174.76 ; JDP.24 230.35,173.45 ; JDP.24 230.35,172.14 ; JDP.24 228.8,174.76 ; JDP.24 228.8,172.14 ; H7.1 269.07,154.64 ; H7.1 266.73,152.3 ; H7.1 269.07,149.96 ; H7.1 271.41,152.3 ; H7.1 270.77,150.6 ; H7.1 270.77,154 ; H7.1 267.37,150.6 ; H7.1 267.37,154 ; H23.1 270.45,8.3 ; H23.1 267.97,10.54 ; H23.1 270.45,6.06 ; H23.1 265.49,6.06 ; H23.1 265.49,8.3 ; H23.1 265.49,10.54 ; H23.1 267.97,6.06 ; H23.1 270.45,10.54 ; 177.67,182.55 JCDRA.50 ; JCDRA.50 177.67,185.67 ; JCDRA.50 176.67,185.67 ; JCDRA.50 178.67,185.67 ; JCDRA.50 176.67,184.11 ; JCDRA.50 178.67,182.55 ; JCDRA.50 176.67,182.55 ; JCDRA.50 178.67,184.11 ; 261.82,181.74 JLAN.14 ; JLAN.14 262.74,178.23 ; JLAN.14 263.65,181.74 ; JLAN.14 261.82,179.99 ; JLAN.14 263.65,178.23 ; JLAN.14 263.65,179.99 ; JLAN.14 261.82,178.23 ; JLAN.14 262.74,181.74 ; 13.21,46.96 JUSB1.12 ; JUSB1.12 13.21,45.24 ; JUSB1.12 16.71,45.24 ; JUSB1.12 13.21,46.1 ; JUSB1.12 16.71,46.1 ; JUSB1.12 14.96,46.96 ; JUSB1.12 16.71,46.96 ; JUSB1.12 14.96,45.24 ; 228.8,178.45 JDP.23 ; JDP.23 228.8,179.76 ; JDP.23 230.35,177.14 ; JDP.23 230.35,178.45 ; JDP.23 230.35,179.76 ; JDP.23 229.57,177.14 ; JDP.23 228.8,177.14 ; JDP.23 229.57,179.76 ; JCDRA.49 177.67,181.07 ; JCDRA.49 176.67,181.07 ; JCDRA.49 176.67,179.51 ; JCDRA.49 176.67,177.95 ; JCDRA.49 178.67,179.51 ; JCDRA.49 178.67,177.95 ; JCDRA.49 177.67,177.95 ; JCDRA.49 178.67,181.07 ; JHDMI.2 213.08,175.01 ; JHDMI.2 212.62,175.13 ; JHDMI.2 212.16,174.09 ; JHDMI.2 213.08,174.09 ; JHDMI.2 212.16,175.01 ; JHDMI.2 212.04,174.55 ; JHDMI.2 212.62,173.97 ; 0.38,67.25 JUSBC2.2 ; JUSBC2.2 3.22,65.59 ; JUSBC2.2 1.8,67.25 ; JUSBC2.2 0.38,66.42 ; JUSBC2.2 3.22,66.42 ; JUSBC2.2 0.38,65.59 ; JUSBC2.2 3.22,67.25 ; JUSBC2.2 1.8,65.59 ; 100.14,8.3 H18.1 ; H18.1 102.07,6.37 ; H18.1 100.65,6.88 ; H18.1 100.65,9.72 ; H18.1 103.49,9.72 ; H18.1 103.49,6.88 ; H18.1 102.07,10.23 ; H18.1 104,8.3 ; 196.27,181.73 JUSBC1.3 ; JUSBC1.3 196.27,179.27 ; JUSBC1.3 197.82,181.73 ; JUSBC1.3 197.04,179.27 ; JUSBC1.3 197.82,179.27 ; JUSBC1.3 197.82,180.5 ; JUSBC1.3 197.04,181.73 ; JUSBC2.6 7.07,57 ; JUSBC2.6 5.63,57 ; JUSBC2.6 5.63,58.11 ; JUSBC2.6 6.35,57 ; JUSBC2.6 5.63,59.01 ; JUSBC2.6 7.07,59.01 ; JUSBC2.6 6.35,59.01 ; 200.8,180.48 H14.1 ; H14.1 200.29,181.9 ; H14.1 204.15,181.9 ; H14.1 202.22,183.83 ; H14.1 200.8,183.32 ; H14.1 202.22,179.97 ; H14.1 203.64,183.32 ; H14.1 203.64,180.48 ; 213.66,176.56 JHDMI.5 ; JHDMI.5 214.12,175.52 ; JHDMI.5 214.58,175.64 ; JHDMI.5 213.66,175.64 ; JHDMI.5 214.58,176.56 ; JHDMI.5 214.12,176.68 ; 207.47,181.32 JHDMI.21 ; JHDMI.21 206.54,183.88 ; JHDMI.21 207.47,183.88 ; JHDMI.21 208.4,181.32 ; JHDMI.21 206.54,182.6 ; JHDMI.21 208.4,182.6 ; JHDMI.21 208.4,183.88 ; JHDMI.21 206.54,181.32 ; H13.1 199.57,156.33 ; H13.1 199.57,151.27 ; H13.1 201.81,153.8 ; H13.1 201.81,151.27 ; H13.1 197.33,151.27 ; H13.1 197.33,156.33 ; H13.1 197.33,153.8 ; H13.1 201.81,156.33 ; 215.62,173.97 JHDMI.8 ; JHDMI.8 215.16,174.09 ; JHDMI.8 215.16,175.01 ; JHDMI.8 216.08,175.01 ; JHDMI.8 216.08,174.09 ; JHDMI.8 215.62,175.13 ; H1.1 147.31,157.4 ; H1.1 146.67,159.1 ; H1.1 146.67,155.7 ; H1.1 144.97,155.06 ; H1.1 143.27,159.1 ; H1.1 144.97,159.74 ; H1.1 143.27,155.7 ; H1.1 142.63,157.4 ; JDP.1 232.37,176.07 ; JDP.1 232.37,174.91 ; JDP.1 232.84,175.03 ; JDP.1 232.84,175.95 ; JDP.1 231.91,175.03 ; JDP.1 231.79,175.49 ; JDP.1 231.91,175.95 ; H4.1 206.77,52 ; H4.1 207.41,50.3 ; H4.1 205.07,47.96 ; H4.1 203.37,48.6 ; H4.1 206.77,48.6 ; H4.1 205.07,52.64 ; H4.1 202.73,50.3 ; H4.1 203.37,52 ; JHDMI.20 209.37,175.68 ; JHDMI.20 208.44,174.4 ; JHDMI.20 210.3,173.12 ; JHDMI.20 208.44,173.12 ; JHDMI.20 208.44,175.68 ; JHDMI.20 210.3,174.4 ; JHDMI.20 209.37,173.12 ; JHDMI.20 210.3,175.68 ; 240.57,172.14 JDP.22 ; JDP.22 241.35,173.45 ; JDP.22 239.8,173.45 ; JDP.22 240.57,174.76 ; JDP.22 241.35,172.14 ; JDP.22 241.35,174.76 ; JDP.22 239.8,172.14 ; H21.1 263.49,9.72 ; H21.1 263.49,6.88 ; H21.1 262.07,6.37 ; H21.1 262.07,10.23 ; H21.1 260.14,8.3 ; H21.1 260.65,9.72 ; H21.1 264,8.3 ; H21.1 260.65,6.88 ; JCDRA.47 146.17,179.51 ; JCDRA.47 146.17,181.07 ; JCDRA.47 146.17,177.95 ; JCDRA.47 145.17,177.95 ; JCDRA.47 144.17,179.51 ; JCDRA.47 144.17,177.95 ; JCDRA.47 145.17,181.07 ; JCDRA.47 144.17,181.07 ; JHDMI.17 220.58,176.56 ; JHDMI.17 220.58,175.64 ; JHDMI.17 220.12,176.68 ; JHDMI.17 220.12,175.52 ; JHDMI.17 219.66,176.56 ; JHDMI.17 219.66,175.64 ; 239.8,177.14 JDP.21 ; JDP.21 240.57,179.76 ; JDP.21 241.35,178.45 ; JDP.21 239.8,179.76 ; JDP.21 239.8,178.45 ; JDP.21 241.35,177.14 ; JDP.21 241.35,179.76 ; JDP.21 240.57,177.14 ; 274.37,43.6 H5.1 ; H5.1 278.41,45.3 ; H5.1 274.37,47 ; H5.1 273.73,45.3 ; H5.1 276.07,42.96 ; H5.1 277.77,47 ; H5.1 276.07,47.64 ; H5.1 277.77,43.6 ; 4.69,30.94 JUSB1.13 ; JUSB1.13 4.69,31.8 ; JUSB1.13 7.71,31.8 ; JUSB1.13 6.2,30.94 ; JUSB1.13 7.71,30.94 ; 181.8,180.48 H15.1 ; H15.1 184.64,183.32 ; H15.1 181.29,181.9 ; H15.1 184.64,180.48 ; H15.1 183.22,183.83 ; H15.1 185.15,181.9 ; H15.1 183.22,179.97 ; H15.1 181.8,183.32 ; 6.57,50.67 H9.1 ; H9.1 8.5,52.6 ; H9.1 5.15,54.02 ; H9.1 5.15,51.18 ; H9.1 6.57,54.53 ; H9.1 4.64,52.6 ; H9.1 7.99,54.02 ; H9.1 7.99,51.18 ; 196.45,55.98 H22.1 ; H22.1 199.8,57.4 ; H22.1 199.29,55.98 ; H22.1 197.87,55.47 ; H22.1 196.45,58.82 ; H22.1 199.29,58.82 ; H22.1 197.87,59.33 ; H22.1 195.94,57.4 ; JUSBC2.3 8.08,57.78 ; JUSBC2.3 8.08,58.56 ; JUSBC2.3 6.85,57 ; JUSBC2.3 8.08,57 ; JUSBC2.3 5.62,58.56 ; JUSBC2.3 5.62,57.78 ; JUSBC2.3 5.62,57 ; JUSB1.14 6.2,48.46 ; JUSB1.14 7.71,48.46 ; JUSB1.14 4.69,47.6 ; JUSB1.14 7.71,47.6 ; JUSB1.14 4.69,48.46 ; JUSBC2.4 3.22,56.95 ; JUSBC2.4 3.22,58.61 ; JUSBC2.4 3.22,57.78 ; JUSBC2.4 0.38,57.78 ; JUSBC2.4 1.8,56.95 ; JUSBC2.4 0.38,56.95 ; JUSBC2.4 0.38,58.61 ; JUSBC2.4 1.8,58.61 ; 119.77,155.88 JPCMC.36 ; JPCMC.36 117.97,156.56 ; JPCMC.36 117.97,160.16 ; JPCMC.36 121.57,156.56 ; JPCMC.36 122.25,158.36 ; JPCMC.36 119.77,160.84 ; 224.84,183.85 JHDMI.23 ; JHDMI.23 225.77,185.13 ; JHDMI.23 226.7,185.13 ; JHDMI.23 226.7,183.85 ; JHDMI.23 224.84,182.57 ; JHDMI.23 225.77,182.57 ; JHDMI.23 224.84,185.13 ; JHDMI.23 226.7,182.57 ; H19.1 92.87,60.63 ; H19.1 94.8,58.7 ; H19.1 90.94,58.7 ; H19.1 91.45,57.28 ; H19.1 91.45,60.12 ; H19.1 94.29,57.28 ; H19.1 92.87,56.77 ; H19.1 94.29,60.12 ; H8.1 6.49,73.02 ; H8.1 3.65,73.02 ; H8.1 5.07,69.67 ; H8.1 3.65,70.18 ; H8.1 3.14,71.6 ; H8.1 5.07,73.53 ; H8.1 6.49,70.18 ; H8.1 7,71.6 ; 187.62,180.28 JUSBC1.5 ; JUSBC1.5 189.63,180.28 ; JUSBC1.5 189.63,181.72 ; JUSBC1.5 187.62,181.72 ; JUSBC1.5 189.63,181 ; JUSBC1.5 188.73,181.72 ; JUSBC1.5 187.62,181 ; H17.1 146.5,173.3 ; H17.1 145.99,171.88 ; H17.1 144.57,175.23 ; H17.1 144.57,171.37 ; H17.1 143.15,174.72 ; H17.1 143.15,171.88 ; H17.1 142.64,173.3 ; H17.1 145.99,174.72 ; 216.66,175.64 JHDMI.11 ; JHDMI.11 217.58,176.56 ; JHDMI.11 217.12,175.52 ; JHDMI.11 217.58,175.64 ; JHDMI.11 216.66,176.56 ; JHDMI.11 217.12,176.68 ; JDP.7 234.54,174.75 ; JDP.7 233.61,174.75 ; JDP.7 234.07,173.71 ; JDP.7 234.54,173.83 ; JDP.7 233.61,173.83 ; JDP.7 234.07,174.87 ; JDP.7 234.66,174.29 ; H2.1 124.37,94.4 ; H2.1 120.33,92.7 ; H2.1 124.37,91 ; H2.1 120.97,91 ; H2.1 125.01,92.7 ; H2.1 122.67,90.36 ; H2.1 120.97,94.4 ; H2.1 122.67,95.04 ; JLAN.16 244.6,181.74 ; JLAN.16 242.77,179.99 ; JLAN.16 244.6,178.23 ; JLAN.16 243.69,181.74 ; JLAN.16 243.69,178.23 ; JLAN.16 242.77,181.74 ; JLAN.16 244.6,179.99 ; JLAN.16 242.77,178.23 ; 235.61,173.83 JDP.13 ; JDP.13 236.54,174.75 ; JDP.13 235.49,174.29 ; JDP.13 236.54,173.83 ; JDP.13 236.07,174.87 ; JDP.13 236.07,173.71 ; JDP.13 235.61,174.75 ; 197.04,184.13 JUSBC1.4 ; JUSBC1.4 197.04,186.97 ; JUSBC1.4 196.21,186.97 ; JUSBC1.4 197.87,185.55 ; JUSBC1.4 196.21,185.55 ; JUSBC1.4 197.87,186.97 ; JUSBC1.4 196.21,184.13 ; JUSBC1.4 197.87,184.13 ; H16.1 23.49,7.42 ; H16.1 20.65,7.42 ; H16.1 24,6 ; H16.1 22.07,4.07 ; H16.1 20.65,4.58 ; H16.1 20.14,6 ; H16.1 22.07,7.93 ; H16.1 23.49,4.58 ; 187.62,181.73 JUSBC1.1 ; JUSBC1.1 188.4,179.27 ; JUSBC1.1 187.62,179.27 ; JUSBC1.1 189.18,181.73 ; JUSBC1.1 189.18,179.27 ; JUSBC1.1 188.4,181.73 ; JUSBC1.1 187.62,180.5 ; H20.1 299.29,76.63 ; H20.1 297.87,76.12 ; H20.1 295.94,78.05 ; H20.1 299.29,79.47 ; H20.1 297.87,79.98 ; H20.1 299.8,78.05 ; H20.1 296.45,79.47 ; H20.1 296.45,76.63 ; JDP.19 237.77,176.07 ; JDP.19 237.31,175.03 ; JDP.19 238.24,175.03 ; JDP.19 237.31,175.95 ; JDP.19 238.36,175.49 ; JDP.19 238.24,175.95 ; JDP.19 237.77,174.91 ; JUSBC1.6 197.82,181 ; JUSBC1.6 195.81,181.72 ; JUSBC1.6 195.81,180.28 ; JUSBC1.6 197.82,180.28 ; JUSBC1.6 197.82,181.72 ; JUSBC1.6 196.72,181.72 ; JUSBC1.6 195.81,181 ; JUSB1.4 17.14,35.61 ; JUSB1.4 15.96,36.79 ; JUSB1.4 16.55,36.96 ; JUSB1.4 15.79,36.2 ; JUSB1.4 17.14,36.79 ; JUSB1.4 15.96,35.61 ; JUSB1.4 17.31,36.2 ; JUSB1.4 16.55,35.44 ; JUSB1.11 14.96,34.16 ; JUSB1.11 13.21,34.16 ; JUSB1.11 14.96,32.44 ; JUSB1.11 13.21,32.44 ; JUSB1.11 13.21,33.3 ; JUSB1.11 16.71,34.16 ; JUSB1.11 16.71,32.44 ; JUSB1.11 16.71,33.3 ; H11.1 22.07,15.54 ; H11.1 22.07,11.06 ; H11.1 23.7,11.67 ; H11.1 20.44,14.93 ; H11.1 23.7,14.93 ; H11.1 24.31,13.3 ; H11.1 20.44,11.67 ; H11.1 19.83,13.3 ; 187.57,184.13 JUSBC1.2 ; JUSBC1.2 188.4,186.97 ; JUSBC1.2 188.4,184.13 ; JUSBC1.2 189.23,185.55 ; JUSBC1.2 187.57,186.97 ; JUSBC1.2 189.23,186.97 ; JUSBC1.2 187.57,185.55 ; JUSBC1.2 189.23,184.13 ; H6.1 179.67,10.23 ; H6.1 181.6,8.3 ; H6.1 181.09,9.72 ; H6.1 177.74,8.3 ; H6.1 181.09,6.88 ; H6.1 178.25,6.88 ; H6.1 179.67,6.37 ; H6.1 178.25,9.72
  IN1 w0.1: 239.97,85.58 239.97,85.92 239.97,85.92
  IN1 w0.127: 250.77,99.35 251.17,99.35 v2(251.47,99.65)
  IN1 w0.15: v2(250.24,105.85) 250.43,105.65 251.17,105.65 v2(251.47,105.35) ; v2(236.07,87.15) 235.77,86.85 235.77,85.93 v2(235.5,85.66) ; v2(237.79,83.88) 237.9,83.98 237.9,84.91 v2(238.04,85.05) 237.57,85.52 v2(237.57,85.75) ; 239.97,85.58 240.12,85.43 v2(240.12,85.2) 240.12,84.7 v2(239.67,84.25) 239.67,83.89 v2(239.87,83.69) ; 250.77,99.35 250.55,99.35 250.26,99.65 v2(250.07,99.65) ; 223.77,88.85 224.04,88.58 v2(224.04,88.38) ; 223.77,88.85 UG9.K8 v2(224.17,89.15) ; 223.77,88.85 223.07,88.85 v2(222.77,89.15) UG9.K6 221.74,88.85 v2(221.54,88.65) 220.52,88.65 v2(220.4,88.76) ; v2(222.5,80.2) 222.5,80.26 v2(223.12,80.87) 223.24,81 223.24,81.98 v2(222.92,82.3) 223.19,82.57 223.19,83.35 v2(222.88,83.66) 222.88,83.7 v2(223.46,84.28) 222.93,84.81 v2(222.93,85.07) 223.4,85.53 v2(223.43,85.53) ; v2(238.07,86.59) 237.87,86.8 237.87,86.88 237.87,86.88 237.87,87.22 237.87,87.22 237.87,87.36 238.05,87.54 v2(238.05,87.91) 238.01,87.91 237.87,88.05 v2(237.87,89.55) ; v2(248.55,87) 248.41,87.14 248.41,87.96 v2(248.49,88.04) ; v2(251.99,101.33) 251.87,101.45 250.89,101.45 v2(250.74,101.3) 250.29,101.75 v2(250.07,101.75) ; v2(242.37,88.55) 242.39,88.53 v2(242.39,87.77) 242.24,87.63 v2(242.24,86.93) 242.47,86.7 v2(242.47,86.35) 241.91,85.79 v2(241.91,85.61) 242.35,85.17 v2(242.35,85.05) ; v2(239.68,86.37) 239.97,86.08 239.97,85.92
  IN1 w0.2: v2(246.5,85.58) 246.14,85.58 v2(245.97,85.75) ; v2(252.02,93.25) 252.02,93.2 v2(251.57,92.75)
  IN1 w0.25: v2(282.55,95.76) 283.21,96.42 v2(283.47,96.42) ; v2(237.57,85.75) 238.07,86.25 v2(238.07,86.59) ; v2(248.74,99.65) 248.74,98.98 v2(248.77,98.95) 249.1,98.95 v2(249.32,99.17) 249.59,99.17 v2(250.07,99.65) ; v2(249.67,87.77) 249.91,87.77 250.15,87.53 250.15,87.03 v2(250.74,86.44) 250.74,86.29 v2(250.14,85.7) ; v2(248.06,85.7) 248.11,85.75 v2(248.77,85.75) 248.67,85.85 v2(248.67,86.35) 248.55,86.47 v2(248.55,87) ; v2(235.5,85.66) v2(235.97,85.19) 235.97,84.9 v2(235.43,84.36) 235.43,83.99 v2(235.62,83.8)
  IN1 w0.254: 260.99,75.62 259.72,75.62 259.53,75.81 v2(259.53,76.13)
  IN1 w0.3: v2(248.49,88.04) 248.62,88.17 249.27,88.17 v2(249.67,87.77) ; v2(235.46,88.48) 235.47,88.47 v2(235.47,87.75) v2(236.07,87.15)
  IN1 w0.381: v2(251.47,99.05) v2(251.47,99.65)
  IN1 w0.508: v2(247.02,49.8) 247.02,50.05 248.39,51.43 263.98,51.43 268.15,55.59 268.15,71.2 263.72,75.62 260.99,75.62
  GND2 w0.203: JUSBC2.3 8.08,58.56 ; JUSBC2.3 5.62,57.78 ; JUSBC2.3 5.62,57 ; JUSBC2.3 8.08,57 ; JUSBC2.3 5.62,58.56 ; JUSBC2.3 8.08,57.78 ; JUSBC2.3 6.85,57 ; 15.79,36.2 JUSB1.4 ; JUSB1.4 16.55,35.44 ; JUSB1.4 17.14,36.79 ; JUSB1.4 15.96,36.79 ; JUSB1.4 15.96,35.61 ; JUSB1.4 17.14,35.61 ; JUSB1.4 17.31,36.2 ; JUSB1.4 16.55,36.96 ; 117.97,160.16 JPCMC.36 ; JPCMC.36 121.57,156.56 ; JPCMC.36 122.25,158.36 ; JPCMC.36 117.97,156.56 ; JPCMC.36 119.77,155.88 ; JPCMC.36 119.77,160.84 ; 1.8,56.95 JUSBC2.4 ; JUSBC2.4 0.38,57.78 ; JUSBC2.4 1.8,58.61 ; JUSBC2.4 3.22,58.61 ; JUSBC2.4 0.38,56.95 ; JUSBC2.4 3.22,57.78 ; JUSBC2.4 0.38,58.61 ; JUSBC2.4 3.22,56.95 ; JCDRA.49 177.67,181.07 ; JCDRA.49 176.67,179.51 ; JCDRA.49 176.67,181.07 ; JCDRA.49 178.67,177.95 ; JCDRA.49 178.67,181.07 ; JCDRA.49 178.67,179.51 ; JCDRA.49 177.67,177.95 ; JCDRA.49 176.67,177.95 ; 219.66,175.64 JHDMI.17 ; JHDMI.17 220.12,176.68 ; JHDMI.17 220.58,175.64 ; JHDMI.17 220.12,175.52 ; JHDMI.17 220.58,176.56 ; JHDMI.17 219.66,176.56 ; 179.43,92.1 H3.1 ; H3.1 181.67,89.86 ; H3.1 183.3,93.73 ; H3.1 180.04,90.47 ; H3.1 183.91,92.1 ; H3.1 180.04,93.73 ; H3.1 181.67,94.34 ; H3.1 183.3,90.47 ; H16.1 23.49,7.42 ; H16.1 20.14,6 ; H16.1 23.49,4.58 ; H16.1 20.65,7.42 ; H16.1 20.65,4.58 ; H16.1 22.07,4.07 ; H16.1 24,6 ; H16.1 22.07,7.93 ; H2.1 125.01,92.7 ; H2.1 120.97,94.4 ; H2.1 120.33,92.7 ; H2.1 120.97,91 ; H2.1 122.67,90.36 ; H2.1 124.37,91 ; H2.1 124.37,94.4 ; H2.1 122.67,95.04 ; JUSB1.14 7.71,47.6 ; JUSB1.14 7.71,48.46 ; JUSB1.14 6.2,48.46 ; JUSB1.14 4.69,48.46 ; JUSB1.14 4.69,47.6 ; 195.81,181 JUSBC1.6 ; JUSBC1.6 195.81,181.72 ; JUSBC1.6 197.82,181 ; JUSBC1.6 196.72,181.72 ; JUSBC1.6 195.81,180.28 ; JUSBC1.6 197.82,181.72 ; JUSBC1.6 197.82,180.28 ; 26.65,54.38 H10.1 ; H10.1 30,55.8 ; H10.1 28.07,53.87 ; H10.1 26.65,57.22 ; H10.1 26.14,55.8 ; H10.1 29.49,54.38 ; H10.1 29.49,57.22 ; H10.1 28.07,57.73 ; 296.45,76.63 H20.1 ; H20.1 296.45,79.47 ; H20.1 295.94,78.05 ; H20.1 299.29,76.63 ; H20.1 299.8,78.05 ; H20.1 299.29,79.47 ; H20.1 297.87,79.98 ; H20.1 297.87,76.12 ; 91.45,60.12 H19.1 ; H19.1 92.87,60.63 ; H19.1 94.29,60.12 ; H19.1 91.45,57.28 ; H19.1 90.94,58.7 ; H19.1 94.29,57.28 ; H19.1 92.87,56.77 ; H19.1 94.8,58.7 ; JCDRA.47 145.17,181.07 ; JCDRA.47 146.17,177.95 ; JCDRA.47 144.17,177.95 ; JCDRA.47 144.17,179.51 ; JCDRA.47 146.17,179.51 ; JCDRA.47 145.17,177.95 ; JCDRA.47 146.17,181.07 ; JCDRA.47 144.17,181.07 ; 243.69,178.23 JLAN.16 ; JLAN.16 243.69,181.74 ; JLAN.16 242.77,181.74 ; JLAN.16 244.6,181.74 ; JLAN.16 242.77,179.99 ; JLAN.16 242.77,178.23 ; JLAN.16 244.6,178.23 ; JLAN.16 244.6,179.99 ; H13.1 201.81,151.27 ; H13.1 201.81,153.8 ; H13.1 197.33,151.27 ; H13.1 197.33,156.33 ; H13.1 199.57,151.27 ; H13.1 199.57,156.33 ; H13.1 201.81,156.33 ; H13.1 197.33,153.8 ; JDP.23 230.35,179.76 ; JDP.23 228.8,178.45 ; JDP.23 230.35,178.45 ; JDP.23 228.8,177.14 ; JDP.23 229.57,177.14 ; JDP.23 228.8,179.76 ; JDP.23 230.35,177.14 ; JDP.23 229.57,179.76 ; 100.65,6.88 H18.1 ; H18.1 103.49,9.72 ; H18.1 100.65,9.72 ; H18.1 100.14,8.3 ; H18.1 102.07,10.23 ; H18.1 103.49,6.88 ; H18.1 102.07,6.37 ; H18.1 104,8.3 ; JUSBC1.5 189.63,181 ; JUSBC1.5 189.63,180.28 ; JUSBC1.5 188.73,181.72 ; JUSBC1.5 189.63,181.72 ; JUSBC1.5 187.62,180.28 ; JUSBC1.5 187.62,181 ; JUSBC1.5 187.62,181.72 ; H12.1 278.1,172.4 ; H12.1 274.75,173.82 ; H12.1 276.17,174.33 ; H12.1 277.59,170.98 ; H12.1 276.17,170.47 ; H12.1 274.24,172.4 ; H12.1 274.75,170.98 ; H12.1 277.59,173.82 ; 208.44,175.68 JHDMI.20 ; JHDMI.20 210.3,175.68 ; JHDMI.20 209.37,175.68 ; JHDMI.20 209.37,173.12 ; JHDMI.20 210.3,173.12 ; JHDMI.20 208.44,173.12 ; JHDMI.20 210.3,174.4 ; JHDMI.20 208.44,174.4 ; H22.1 199.29,55.98 ; H22.1 199.8,57.4 ; H22.1 196.45,58.82 ; H22.1 195.94,57.4 ; H22.1 196.45,55.98 ; H22.1 199.29,58.82 ; H22.1 197.87,55.47 ; H22.1 197.87,59.33 ; 206.54,182.6 JHDMI.21 ; JHDMI.21 208.4,183.88 ; JHDMI.21 207.47,183.88 ; JHDMI.21 207.47,181.32 ; JHDMI.21 208.4,182.6 ; JHDMI.21 208.4,181.32 ; JHDMI.21 206.54,183.88 ; JHDMI.21 206.54,181.32 ; JDP.13 236.07,174.87 ; JDP.13 236.54,174.75 ; JDP.13 236.54,173.83 ; JDP.13 235.49,174.29 ; JDP.13 235.61,174.75 ; JDP.13 236.07,173.71 ; JDP.13 235.61,173.83 ; 212.16,175.01 JHDMI.2 ; JHDMI.2 212.62,175.13 ; JHDMI.2 213.08,174.09 ; JHDMI.2 212.04,174.55 ; JHDMI.2 212.62,173.97 ; JHDMI.2 213.08,175.01 ; JHDMI.2 212.16,174.09 ; JUSBC1.4 197.04,186.97 ; JUSBC1.4 197.87,185.55 ; JUSBC1.4 196.21,186.97 ; JUSBC1.4 197.87,186.97 ; JUSBC1.4 196.21,184.13 ; JUSBC1.4 197.87,184.13 ; JUSBC1.4 196.21,185.55 ; JUSBC1.4 197.04,184.13 ; H5.1 277.77,43.6 ; H5.1 276.07,42.96 ; H5.1 278.41,45.3 ; H5.1 274.37,47 ; H5.1 277.77,47 ; H5.1 273.73,45.3 ; H5.1 274.37,43.6 ; H5.1 276.07,47.64 ; 0.38,65.59 JUSBC2.2 ; JUSBC2.2 0.38,66.42 ; JUSBC2.2 1.8,67.25 ; JUSBC2.2 3.22,65.59 ; JUSBC2.2 0.38,67.25 ; JUSBC2.2 3.22,67.25 ; JUSBC2.2 3.22,66.42 ; JUSBC2.2 1.8,65.59 ; 225.77,182.57 JHDMI.23 ; JHDMI.23 226.7,183.85 ; JHDMI.23 224.84,182.57 ; JHDMI.23 226.7,185.13 ; JHDMI.23 226.7,182.57 ; JHDMI.23 225.77,185.13 ; JHDMI.23 224.84,185.13 ; JHDMI.23 224.84,183.85 ; H15.1 184.64,180.48 ; H15.1 183.22,183.83 ; H15.1 183.22,179.97 ; H15.1 181.8,183.32 ; H15.1 181.29,181.9 ; H15.1 181.8,180.48 ; H15.1 185.15,181.9 ; H15.1 184.64,183.32 ; 15.05,38.94 JUSB1.7 ; JUSB1.7 15.64,39.11 ; JUSB1.7 15.81,39.7 ; JUSB1.7 15.64,40.29 ; JUSB1.7 15.05,40.46 ; JUSB1.7 14.29,39.7 ; JUSB1.7 14.46,40.29 ; JUSB1.7 14.46,39.11 ; 266.73,152.3 H7.1 ; H7.1 269.07,154.64 ; H7.1 267.37,154 ; H7.1 269.07,149.96 ; H7.1 271.41,152.3 ; H7.1 270.77,150.6 ; H7.1 270.77,154 ; H7.1 267.37,150.6 ; 5.15,54.02 H9.1 ; H9.1 6.57,54.53 ; H9.1 5.15,51.18 ; H9.1 7.99,54.02 ; H9.1 8.5,52.6 ; H9.1 4.64,52.6 ; H9.1 7.99,51.18 ; H9.1 6.57,50.67 ; 188.4,179.27 JUSBC1.1 ; JUSBC1.1 187.62,181.73 ; JUSBC1.1 189.18,179.27 ; JUSBC1.1 188.4,181.73 ; JUSBC1.1 189.18,181.73 ; JUSBC1.1 187.62,180.5 ; JUSBC1.1 187.62,179.27 ; 213.66,175.64 JHDMI.5 ; JHDMI.5 214.12,176.68 ; JHDMI.5 214.58,175.64 ; JHDMI.5 214.58,176.56 ; JHDMI.5 214.12,175.52 ; JHDMI.5 213.66,176.56 ; H1.1 147.31,157.4 ; H1.1 142.63,157.4 ; H1.1 144.97,155.06 ; H1.1 146.67,159.1 ; H1.1 143.27,159.1 ; H1.1 146.67,155.7 ; H1.1 143.27,155.7 ; H1.1 144.97,159.74 ; H6.1 179.67,10.23 ; H6.1 181.6,8.3 ; H6.1 181.09,9.72 ; H6.1 178.25,9.72 ; H6.1 181.09,6.88 ; H6.1 178.25,6.88 ; H6.1 177.74,8.3 ; H6.1 179.67,6.37 ; JCDRA.50 178.67,184.11 ; JCDRA.50 176.67,185.67 ; JCDRA.50 176.67,184.11 ; JCDRA.50 178.67,185.67 ; JCDRA.50 177.67,185.67 ; JCDRA.50 177.67,182.55 ; JCDRA.50 178.67,182.55 ; JCDRA.50 176.67,182.55 ; 14.96,45.24 JUSB1.12 ; JUSB1.12 13.21,46.1 ; JUSB1.12 16.71,45.24 ; JUSB1.12 16.71,46.1 ; JUSB1.12 13.21,46.96 ; JUSB1.12 16.71,46.96 ; JUSB1.12 14.96,46.96 ; JUSB1.12 13.21,45.24 ; JHDMI.22 224.8,175.68 ; JHDMI.22 223.87,175.68 ; JHDMI.22 224.8,174.4 ; JHDMI.22 222.94,174.4 ; JHDMI.22 223.87,173.12 ; JHDMI.22 222.94,175.68 ; JHDMI.22 224.8,173.12 ; JHDMI.22 222.94,173.12 ; 144.17,184.11 JCDRA.48 ; JCDRA.48 146.17,185.67 ; JCDRA.48 144.17,182.55 ; JCDRA.48 144.17,185.67 ; JCDRA.48 146.17,184.11 ; JCDRA.48 146.17,182.55 ; JCDRA.48 145.17,182.55 ; JCDRA.48 145.17,185.67 ; 5.07,69.67 H8.1 ; H8.1 3.65,73.02 ; H8.1 3.65,70.18 ; H8.1 6.49,73.02 ; H8.1 7,71.6 ; H8.1 5.07,73.53 ; H8.1 6.49,70.18 ; H8.1 3.14,71.6 ; JUSB1.11 16.71,34.16 ; JUSB1.11 14.96,34.16 ; JUSB1.11 13.21,34.16 ; JUSB1.11 13.21,33.3 ; JUSB1.11 16.71,32.44 ; JUSB1.11 13.21,32.44 ; JUSB1.11 14.96,32.44 ; JUSB1.11 16.71,33.3 ; JDP.22 241.35,174.76 ; JDP.22 241.35,172.14 ; JDP.22 240.57,172.14 ; JDP.22 239.8,172.14 ; JDP.22 240.57,174.76 ; JDP.22 239.8,173.45 ; JDP.22 241.35,173.45 ; H23.1 270.45,8.3 ; H23.1 270.45,6.06 ; H23.1 267.97,6.06 ; H23.1 267.97,10.54 ; H23.1 270.45,10.54 ; H23.1 265.49,6.06 ; H23.1 265.49,10.54 ; H23.1 265.49,8.3 ; JDP.1 232.84,175.95 ; JDP.1 232.37,176.07 ; JDP.1 232.84,175.03 ; JDP.1 231.91,175.95 ; JDP.1 232.37,174.91 ; JDP.1 231.91,175.03 ; JDP.1 231.79,175.49 ; 6.2,30.94 JUSB1.13 ; JUSB1.13 4.69,31.8 ; JUSB1.13 7.71,31.8 ; JUSB1.13 7.71,30.94 ; JUSB1.13 4.69,30.94 ; 216.66,176.56 JHDMI.11 ; JHDMI.11 217.58,176.56 ; JHDMI.11 217.12,175.52 ; JHDMI.11 216.66,175.64 ; JHDMI.11 217.58,175.64 ; JHDMI.11 217.12,176.68 ; JLAN.14 263.65,178.23 ; JLAN.14 263.65,181.74 ; JLAN.14 263.65,179.99 ; JLAN.14 262.74,181.74 ; JLAN.14 262.74,178.23 ; JLAN.14 261.82,178.23 ; JLAN.14 261.82,179.99 ; JLAN.14 261.82,181.74 ; H4.1 207.41,50.3 ; H4.1 203.37,48.6 ; H4.1 205.07,47.96 ; H4.1 206.77,52 ; H4.1 205.07,52.64 ; H4.1 206.77,48.6 ; H4.1 203.37,52 ; H4.1 202.73,50.3 ; H17.1 145.99,174.72 ; H17.1 142.64,173.3 ; H17.1 143.15,171.88 ; H17.1 146.5,173.3 ; H17.1 144.57,171.37 ; H17.1 144.57,175.23 ; H17.1 145.99,171.88 ; H17.1 143.15,174.72 ; JDP.24 229.57,174.76 ; JDP.24 229.57,172.14 ; JDP.24 228.8,172.14 ; JDP.24 230.35,172.14 ; JDP.24 228.8,174.76 ; JDP.24 228.8,173.45 ; JDP.24 230.35,173.45 ; 20.44,14.93 H11.1 ; H11.1 23.7,11.67 ; H11.1 22.07,15.54 ; H11.1 23.7,14.93 ; H11.1 24.31,13.3 ; H11.1 22.07,11.06 ; H11.1 19.83,13.3 ; H11.1 20.44,11.67 ; JHDMI.8 216.08,174.09 ; JHDMI.8 215.62,173.97 ; JHDMI.8 215.62,175.13 ; JHDMI.8 215.16,174.09 ; JHDMI.8 215.16,175.01 ; JHDMI.8 216.08,175.01 ; JDP.19 238.24,175.03 ; JDP.19 238.24,175.95 ; JDP.19 238.36,175.49 ; JDP.19 237.77,174.91 ; JDP.19 237.31,175.95 ; JDP.19 237.77,176.07 ; JDP.19 237.31,175.03 ; JUSBC2.6 7.07,59.01 ; JUSBC2.6 6.35,59.01 ; JUSBC2.6 5.63,59.01 ; JUSBC2.6 5.63,57 ; JUSBC2.6 7.07,57 ; JUSBC2.6 5.63,58.11 ; JUSBC2.6 6.35,57 ; 196.27,181.73 JUSBC1.3 ; JUSBC1.3 197.04,181.73 ; JUSBC1.3 197.82,180.5 ; JUSBC1.3 196.27,179.27 ; JUSBC1.3 197.82,181.73 ; JUSBC1.3 197.82,179.27 ; JUSBC1.3 197.04,179.27 ; 233.61,174.75 JDP.7 ; JDP.7 234.54,173.83 ; JDP.7 234.54,174.75 ; JDP.7 234.07,173.71 ; JDP.7 233.61,173.83 ; JDP.7 234.07,174.87 ; JDP.7 234.66,174.29 ; 5.63,67.2 JUSBC2.5 ; JUSBC2.5 7.07,65.19 ; JUSBC2.5 5.63,65.19 ; JUSBC2.5 5.63,66.1 ; JUSBC2.5 7.07,67.2 ; JUSBC2.5 6.35,67.2 ; JUSBC2.5 6.35,65.19 ; 5.62,66.42 JUSBC2.1 ; JUSBC2.1 6.85,67.2 ; JUSBC2.1 8.08,66.42 ; JUSBC2.1 8.08,67.2 ; JUSBC2.1 5.62,65.64 ; JUSBC2.1 5.62,67.2 ; JUSBC2.1 8.08,65.64 ; 239.8,179.76 JDP.21 ; JDP.21 240.57,177.14 ; JDP.21 241.35,179.76 ; JDP.21 241.35,177.14 ; JDP.21 240.57,179.76 ; JDP.21 241.35,178.45 ; JDP.21 239.8,178.45 ; JDP.21 239.8,177.14 ; 188.4,184.13 JUSBC1.2 ; JUSBC1.2 187.57,184.13 ; JUSBC1.2 189.23,184.13 ; JUSBC1.2 189.23,185.55 ; JUSBC1.2 187.57,186.97 ; JUSBC1.2 188.4,186.97 ; JUSBC1.2 187.57,185.55 ; JUSBC1.2 189.23,186.97 ; H14.1 203.64,180.48 ; H14.1 202.22,179.97 ; H14.1 200.8,183.32 ; H14.1 200.29,181.9 ; H14.1 203.64,183.32 ; H14.1 204.15,181.9 ; H14.1 200.8,180.48 ; H14.1 202.22,183.83 ; 262.07,6.37 H21.1 ; H21.1 260.65,9.72 ; H21.1 262.07,10.23 ; H21.1 263.49,6.88 ; H21.1 263.49,9.72 ; H21.1 260.14,8.3 ; H21.1 260.65,6.88 ; H21.1 264,8.3
  IN2 w0.508: v2(29.79,25.08) 29.79,25.39 30.87,26.47 33.85,26.47 34.77,27.38 v2(34.77,27.41)
  GND3 w0.203: 240.57,172.14 JDP.22 ; JDP.22 241.35,174.76 ; JDP.22 239.8,173.45 ; JDP.22 241.35,173.45 ; JDP.22 240.57,174.76 ; JDP.22 239.8,172.14 ; JDP.22 241.35,172.14 ; JPCMC.36 119.77,160.84 ; JPCMC.36 122.25,158.36 ; JPCMC.36 121.57,156.56 ; JPCMC.36 117.97,160.16 ; JPCMC.36 117.97,156.56 ; JPCMC.36 119.77,155.88 ; 14.96,32.44 JUSB1.11 ; JUSB1.11 14.96,34.16 ; JUSB1.11 13.21,33.3 ; JUSB1.11 13.21,34.16 ; JUSB1.11 16.71,32.44 ; JUSB1.11 13.21,32.44 ; JUSB1.11 16.71,33.3 ; JUSB1.11 16.71,34.16 ; JHDMI.20 210.3,173.12 ; JHDMI.20 208.44,174.4 ; JHDMI.20 208.44,173.12 ; JHDMI.20 210.3,174.4 ; JHDMI.20 209.37,173.12 ; JHDMI.20 210.3,175.68 ; JHDMI.20 209.37,175.68 ; JHDMI.20 208.44,175.68 ; 144.17,181.07 JCDRA.47 ; JCDRA.47 146.17,181.07 ; JCDRA.47 144.17,177.95 ; JCDRA.47 145.17,181.07 ; JCDRA.47 146.17,177.95 ; JCDRA.47 146.17,179.51 ; JCDRA.47 144.17,179.51 ; JCDRA.47 145.17,177.95 ; 15.79,36.2 JUSB1.4 ; JUSB1.4 17.14,35.61 ; JUSB1.4 16.55,35.44 ; JUSB1.4 16.55,36.96 ; JUSB1.4 17.14,36.79 ; JUSB1.4 15.96,35.61 ; JUSB1.4 15.96,36.79 ; JUSB1.4 17.31,36.2 ; H8.1 6.49,73.02 ; H8.1 3.65,70.18 ; H8.1 5.07,69.67 ; H8.1 6.49,70.18 ; H8.1 5.07,73.53 ; H8.1 3.65,73.02 ; H8.1 3.14,71.6 ; H8.1 7,71.6 ; H17.1 145.99,174.72 ; H17.1 146.5,173.3 ; H17.1 144.57,171.37 ; H17.1 143.15,174.72 ; H17.1 142.64,173.3 ; H17.1 143.15,171.88 ; H17.1 145.99,171.88 ; H17.1 144.57,175.23 ; 26.14,55.8 H10.1 ; H10.1 30,55.8 ; H10.1 28.07,53.87 ; H10.1 28.07,57.73 ; H10.1 29.49,54.38 ; H10.1 26.65,54.38 ; H10.1 26.65,57.22 ; H10.1 29.49,57.22 ; 267.37,154 H7.1 ; H7.1 267.37,150.6 ; H7.1 271.41,152.3 ; H7.1 270.77,154 ; H7.1 269.07,154.64 ; H7.1 266.73,152.3 ; H7.1 269.07,149.96 ; H7.1 270.77,150.6 ; JCDRA.48 146.17,185.67 ; JCDRA.48 144.17,185.67 ; JCDRA.48 145.17,185.67 ; JCDRA.48 144.17,184.11 ; JCDRA.48 146.17,182.55 ; JCDRA.48 145.17,182.55 ; JCDRA.48 144.17,182.55 ; JCDRA.48 146.17,184.11 ; JUSB1.14 6.2,48.46 ; JUSB1.14 4.69,48.46 ; JUSB1.14 7.71,48.46 ; JUSB1.14 7.71,47.6 ; JUSB1.14 4.69,47.6 ; 197.87,55.47 H22.1 ; H22.1 197.87,59.33 ; H22.1 199.29,58.82 ; H22.1 199.8,57.4 ; H22.1 195.94,57.4 ; H22.1 199.29,55.98 ; H22.1 196.45,58.82 ; H22.1 196.45,55.98 ; 196.21,185.55 JUSBC1.4 ; JUSBC1.4 197.87,186.97 ; JUSBC1.4 196.21,186.97 ; JUSBC1.4 197.04,184.13 ; JUSBC1.4 196.21,184.13 ; JUSBC1.4 197.04,186.97 ; JUSBC1.4 197.87,184.13 ; JUSBC1.4 197.87,185.55 ; 274.37,43.6 H5.1 ; H5.1 276.07,47.64 ; H5.1 277.77,47 ; H5.1 273.73,45.3 ; H5.1 276.07,42.96 ; H5.1 277.77,43.6 ; H5.1 278.41,45.3 ; H5.1 274.37,47 ; JUSBC2.2 3.22,65.59 ; JUSBC2.2 0.38,65.59 ; JUSBC2.2 0.38,67.25 ; JUSBC2.2 3.22,66.42 ; JUSBC2.2 0.38,66.42 ; JUSBC2.2 1.8,67.25 ; JUSBC2.2 3.22,67.25 ; JUSBC2.2 1.8,65.59 ; 187.57,185.55 JUSBC1.2 ; JUSBC1.2 188.4,184.13 ; JUSBC1.2 187.57,184.13 ; JUSBC1.2 188.4,186.97 ; JUSBC1.2 189.23,184.13 ; JUSBC1.2 187.57,186.97 ; JUSBC1.2 189.23,185.55 ; JUSBC1.2 189.23,186.97 ; 225.77,182.57 JHDMI.23 ; JHDMI.23 226.7,182.57 ; JHDMI.23 225.77,185.13 ; JHDMI.23 224.84,185.13 ; JHDMI.23 226.7,183.85 ; JHDMI.23 226.7,185.13 ; JHDMI.23 224.84,182.57 ; JHDMI.23 224.84,183.85 ; H23.1 270.45,6.06 ; H23.1 265.49,8.3 ; H23.1 270.45,8.3 ; H23.1 265.49,6.06 ; H23.1 267.97,6.06 ; 20.44,14.93 H11.1 ; H11.1 20.44,11.67 ; H11.1 22.07,15.54 ; H11.1 24.31,13.3 ; H11.1 19.83,13.3 ; H11.1 23.7,11.67 ; H11.1 23.7,14.93 ; H11.1 22.07,11.06 ; 212.04,174.55 JHDMI.2 ; JHDMI.2 213.08,174.09 ; JHDMI.2 212.16,175.01 ; JHDMI.2 213.08,175.01 ; JHDMI.2 212.62,173.97 ; JHDMI.2 212.62,175.13 ; JHDMI.2 212.16,174.09 ; 196.27,179.27 JUSBC1.3 ; JUSBC1.3 197.04,179.27 ; JUSBC1.3 197.82,181.73 ; JUSBC1.3 197.82,179.27 ; JUSBC1.3 197.04,181.73 ; JUSBC1.3 197.82,180.5 ; JUSBC1.3 196.27,181.73 ; H21.1 263.49,6.88 ; H21.1 263.49,9.72 ; H21.1 260.65,6.88 ; H21.1 262.07,10.23 ; H21.1 264,8.3 ; H21.1 262.07,6.37 ; H21.1 260.65,9.72 ; H21.1 260.14,8.3 ; 176.67,177.95 JCDRA.49 ; JCDRA.49 177.67,177.95 ; JCDRA.49 178.67,177.95 ; JCDRA.49 176.67,179.51 ; JCDRA.49 178.67,181.07 ; JCDRA.49 176.67,181.07 ; JCDRA.49 178.67,179.51 ; JCDRA.49 177.67,181.07 ; H14.1 203.64,180.48 ; H14.1 200.8,180.48 ; H14.1 200.8,183.32 ; H14.1 204.15,181.9 ; H14.1 202.22,179.97 ; H14.1 200.29,181.9 ; H14.1 203.64,183.32 ; H14.1 202.22,183.83 ; 5.63,67.2 JUSBC2.5 ; JUSBC2.5 6.35,65.19 ; JUSBC2.5 5.63,66.1 ; JUSBC2.5 7.07,65.19 ; JUSBC2.5 6.35,67.2 ; JUSBC2.5 7.07,67.2 ; JUSBC2.5 5.63,65.19 ; H2.1 124.37,94.4 ; H2.1 124.37,91 ; H2.1 122.67,90.36 ; H2.1 120.97,94.4 ; H2.1 125.01,92.7 ; H2.1 120.97,91 ; H2.1 122.67,95.04 ; H2.1 120.33,92.7 ; 296.45,79.47 H20.1 ; H20.1 299.29,79.47 ; H20.1 296.45,76.63 ; H20.1 295.94,78.05 ; H20.1 299.8,78.05 ; H20.1 297.87,79.98 ; H20.1 297.87,76.12 ; H20.1 299.29,76.63 ; JLAN.16 244.6,178.23 ; JLAN.16 242.77,178.23 ; JLAN.16 243.69,181.74 ; JLAN.16 244.6,179.99 ; JLAN.16 243.69,178.23 ; JLAN.16 242.77,179.99 ; JLAN.16 242.77,181.74 ; JLAN.16 244.6,181.74 ; H9.1 7.99,51.18 ; H9.1 7.99,54.02 ; H9.1 5.15,54.02 ; H9.1 4.64,52.6 ; H9.1 6.57,54.53 ; H9.1 8.5,52.6 ; H9.1 5.15,51.18 ; H9.1 6.57,50.67 ; 90.94,58.7 H19.1 ; H19.1 92.87,60.63 ; H19.1 94.29,57.28 ; H19.1 91.45,60.12 ; H19.1 91.45,57.28 ; H19.1 94.29,60.12 ; H19.1 92.87,56.77 ; H19.1 94.8,58.7 ; JUSBC2.3 8.08,57.78 ; JUSBC2.3 8.08,57 ; JUSBC2.3 6.85,57 ; JUSBC2.3 8.08,58.56 ; JUSBC2.3 5.62,58.56 ; JUSBC2.3 5.62,57 ; JUSBC2.3 5.62,57.78 ; 203.37,48.6 H4.1 ; H4.1 202.73,50.3 ; H4.1 207.41,50.3 ; H4.1 205.07,52.64 ; H4.1 205.07,47.96 ; H4.1 206.77,48.6 ; H4.1 206.77,52 ; H4.1 203.37,52 ; JUSBC2.6 7.07,57 ; JUSBC2.6 5.63,58.11 ; JUSBC2.6 6.35,57 ; JUSBC2.6 7.07,59.01 ; JUSBC2.6 5.63,57 ; JUSBC2.6 6.35,59.01 ; JUSBC2.6 5.63,59.01 ; JDP.24 230.35,172.14 ; JDP.24 229.57,174.76 ; JDP.24 229.57,172.14 ; JDP.24 228.8,174.76 ; JDP.24 228.8,172.14 ; JDP.24 230.35,173.45 ; JDP.24 228.8,173.45 ; JCDRA.50 177.67,185.67 ; JCDRA.50 176.67,182.55 ; JCDRA.50 176.67,185.67 ; JCDRA.50 178.67,185.67 ; JCDRA.50 176.67,184.11 ; JCDRA.50 177.67,182.55 ; JCDRA.50 178.67,182.55 ; JCDRA.50 178.67,184.11 ; 197.33,156.33 H13.1 ; H13.1 201.81,153.8 ; H13.1 201.81,156.33 ; H13.1 197.33,151.27 ; H13.1 199.57,156.33 ; H13.1 199.57,151.27 ; H13.1 201.81,151.27 ; H13.1 197.33,153.8 ; 232.37,174.91 JDP.1 ; JDP.1 232.84,175.03 ; JDP.1 232.84,175.95 ; JDP.1 231.79,175.49 ; JDP.1 231.91,175.95 ; JDP.1 231.91,175.03 ; JDP.1 232.37,176.07 ; H3.1 183.3,93.73 ; H3.1 181.67,89.86 ; H3.1 183.91,92.1 ; H3.1 180.04,90.47 ; H3.1 183.3,90.47 ; H3.1 180.04,93.73 ; H3.1 179.43,92.1 ; H3.1 181.67,94.34 ; 229.57,177.14 JDP.23 ; JDP.23 228.8,177.14 ; JDP.23 228.8,178.45 ; JDP.23 230.35,178.45 ; JDP.23 229.57,179.76 ; JDP.23 228.8,179.76 ; JDP.23 230.35,179.76 ; JDP.23 230.35,177.14 ; H12.1 277.59,173.82 ; H12.1 276.17,170.47 ; H12.1 274.75,170.98 ; H12.1 274.75,173.82 ; H12.1 274.24,172.4 ; H12.1 278.1,172.4 ; H12.1 277.59,170.98 ; H12.1 276.17,174.33 ; 237.77,174.91 JDP.19 ; JDP.19 237.31,175.95 ; JDP.19 237.31,175.03 ; JDP.19 238.36,175.49 ; JDP.19 237.77,176.07 ; JDP.19 238.24,175.03 ; JDP.19 238.24,175.95 ; 235.49,174.29 JDP.13 ; JDP.13 236.07,173.71 ; JDP.13 236.54,174.75 ; JDP.13 236.54,173.83 ; JDP.13 235.61,173.83 ; JDP.13 235.61,174.75 ; JDP.13 236.07,174.87 ; 181.8,180.48 H15.1 ; H15.1 183.22,179.97 ; H15.1 184.64,180.48 ; H15.1 181.29,181.9 ; H15.1 184.64,183.32 ; H15.1 185.15,181.9 ; H15.1 183.22,183.83 ; H15.1 181.8,183.32 ; 223.87,173.12 JHDMI.22 ; JHDMI.22 224.8,173.12 ; JHDMI.22 224.8,174.4 ; JHDMI.22 224.8,175.68 ; JHDMI.22 222.94,174.4 ; JHDMI.22 222.94,175.68 ; JHDMI.22 223.87,175.68 ; JHDMI.22 222.94,173.12 ; 262.74,178.23 JLAN.14 ; JLAN.14 261.82,179.99 ; JLAN.14 263.65,179.99 ; JLAN.14 262.74,181.74 ; JLAN.14 263.65,178.23 ; JLAN.14 263.65,181.74 ; JLAN.14 261.82,181.74 ; JLAN.14 261.82,178.23 ; 15.05,38.94 JUSB1.7 ; JUSB1.7 14.46,40.29 ; JUSB1.7 15.64,40.29 ; JUSB1.7 14.29,39.7 ; JUSB1.7 14.46,39.11 ; JUSB1.7 15.64,39.11 ; JUSB1.7 15.05,40.46 ; JUSB1.7 15.81,39.7 ; JHDMI.8 216.08,174.09 ; JHDMI.8 215.16,175.01 ; JHDMI.8 215.62,175.13 ; JHDMI.8 215.62,173.97 ; JHDMI.8 215.16,174.09 ; JHDMI.8 216.08,175.01 ; 195.81,180.28 JUSBC1.6 ; JUSBC1.6 196.72,181.72 ; JUSBC1.6 195.81,181 ; JUSBC1.6 195.81,181.72 ; JUSBC1.6 197.82,180.28 ; JUSBC1.6 197.82,181.72 ; JUSBC1.6 197.82,181 ; 239.8,177.14 JDP.21 ; JDP.21 240.57,179.76 ; JDP.21 241.35,179.76 ; JDP.21 239.8,179.76 ; JDP.21 241.35,178.45 ; JDP.21 239.8,178.45 ; JDP.21 240.57,177.14 ; JDP.21 241.35,177.14 ; JUSBC2.4 3.22,58.61 ; JUSBC2.4 1.8,58.61 ; JUSBC2.4 0.38,56.95 ; JUSBC2.4 1.8,56.95 ; JUSBC2.4 3.22,56.95 ; JUSBC2.4 0.38,58.61 ; JUSBC2.4 3.22,57.78 ; JUSBC2.4 0.38,57.78 ; 13.21,46.1 JUSB1.12 ; JUSB1.12 16.71,46.1 ; JUSB1.12 14.96,45.24 ; JUSB1.12 13.21,45.24 ; JUSB1.12 13.21,46.96 ; JUSB1.12 16.71,45.24 ; JUSB1.12 14.96,46.96 ; JUSB1.12 16.71,46.96 ; 187.62,181 JUSBC1.5 ; JUSBC1.5 189.63,180.28 ; JUSBC1.5 187.62,180.28 ; JUSBC1.5 189.63,181.72 ; JUSBC1.5 188.73,181.72 ; JUSBC1.5 187.62,181.72 ; JUSBC1.5 189.63,181 ; JUSBC1.1 189.18,181.73 ; JUSBC1.1 187.62,179.27 ; JUSBC1.1 187.62,180.5 ; JUSBC1.1 188.4,179.27 ; JUSBC1.1 187.62,181.73 ; JUSBC1.1 188.4,181.73 ; JUSBC1.1 189.18,179.27 ; JHDMI.11 217.12,176.68 ; JHDMI.11 216.66,176.56 ; JHDMI.11 216.66,175.64 ; JHDMI.11 217.58,176.56 ; JHDMI.11 217.58,175.64 ; JHDMI.11 217.12,175.52 ; JUSBC2.1 8.08,67.2 ; JUSBC2.1 8.08,66.42 ; JUSBC2.1 8.08,65.64 ; JUSBC2.1 6.85,67.2 ; JUSBC2.1 5.62,65.64 ; JUSBC2.1 5.62,66.42 ; JUSBC2.1 5.62,67.2 ; 6.2,30.94 JUSB1.13 ; JUSB1.13 4.69,31.8 ; JUSB1.13 4.69,30.94 ; JUSB1.13 7.71,30.94 ; JUSB1.13 7.71,31.8 ; 219.66,175.64 JHDMI.17 ; JHDMI.17 220.58,176.56 ; JHDMI.17 220.58,175.64 ; JHDMI.17 219.66,176.56 ; JHDMI.17 220.12,176.68 ; JHDMI.17 220.12,175.52 ; 100.65,6.88 H18.1 ; H18.1 104,8.3 ; H18.1 100.65,9.72 ; H18.1 102.07,6.37 ; H18.1 100.14,8.3 ; H18.1 103.49,9.72 ; H18.1 103.49,6.88 ; H18.1 102.07,10.23 ; JDP.7 234.54,174.75 ; JDP.7 233.61,173.83 ; JDP.7 234.07,174.87 ; JDP.7 234.66,174.29 ; JDP.7 234.07,173.71 ; JDP.7 234.54,173.83 ; JDP.7 233.61,174.75 ; H16.1 22.07,7.93 ; H16.1 20.14,6 ; H16.1 20.65,7.42 ; H16.1 23.49,7.42 ; H16.1 22.07,4.07 ; H16.1 23.49,4.58 ; H16.1 24,6 ; H16.1 20.65,4.58 ; H1.1 146.67,155.7 ; H1.1 146.67,159.1 ; H1.1 144.97,155.06 ; H1.1 144.97,159.74 ; H1.1 143.27,155.7 ; H1.1 143.27,159.1 ; H1.1 147.31,157.4 ; H1.1 142.63,157.4 ; 213.66,175.64 JHDMI.5 ; JHDMI.5 213.66,176.56 ; JHDMI.5 214.58,175.64 ; JHDMI.5 214.12,176.68 ; JHDMI.5 214.12,175.52 ; JHDMI.5 214.58,176.56 ; JHDMI.21 208.4,182.6 ; JHDMI.21 207.47,181.32 ; JHDMI.21 206.54,182.6 ; JHDMI.21 206.54,183.88 ; JHDMI.21 206.54,181.32 ; JHDMI.21 207.47,183.88 ; JHDMI.21 208.4,181.32 ; JHDMI.21 208.4,183.88
  GND4 w0.203: H1.1 147.31,157.4 ; H1.1 143.27,155.7 ; H1.1 144.97,159.74 ; H1.1 144.97,155.06 ; H1.1 143.27,159.1 ; H1.1 142.63,157.4 ; H1.1 146.67,155.7 ; H1.1 146.67,159.1 ; 237.31,175.95 JDP.19 ; JDP.19 238.24,175.03 ; JDP.19 238.24,175.95 ; JDP.19 237.31,175.03 ; JDP.19 237.77,174.91 ; JDP.19 238.36,175.49 ; JDP.19 237.77,176.07 ; 212.16,174.09 JHDMI.2 ; JHDMI.2 212.04,174.55 ; JHDMI.2 212.16,175.01 ; JHDMI.2 212.62,175.13 ; JHDMI.2 212.62,173.97 ; JHDMI.2 213.08,175.01 ; JHDMI.2 213.08,174.09 ; 176.67,177.95 JCDRA.49 ; JCDRA.49 177.67,181.07 ; JCDRA.49 178.67,181.07 ; JCDRA.49 176.67,179.51 ; JCDRA.49 176.67,181.07 ; JCDRA.49 177.67,177.95 ; JCDRA.49 178.67,179.51 ; JCDRA.49 178.67,177.95 ; JUSB1.11 16.71,32.44 ; JUSB1.11 13.21,32.44 ; JUSB1.11 14.96,32.44 ; JUSB1.11 13.21,34.16 ; JUSB1.11 16.71,34.16 ; JUSB1.11 13.21,33.3 ; JUSB1.11 16.71,33.3 ; JUSB1.11 14.96,34.16 ; JLAN.16 243.69,181.74 ; JLAN.16 244.6,181.74 ; JLAN.16 242.77,179.99 ; JLAN.16 242.77,178.23 ; JLAN.16 242.77,181.74 ; JLAN.16 243.69,178.23 ; JLAN.16 244.6,179.99 ; JLAN.16 244.6,178.23 ; 215.16,174.09 JHDMI.8 ; JHDMI.8 215.62,173.97 ; JHDMI.8 215.16,175.01 ; JHDMI.8 216.08,175.01 ; JHDMI.8 215.62,175.13 ; JHDMI.8 216.08,174.09 ; 224.84,182.57 JHDMI.23 ; JHDMI.23 226.7,182.57 ; JHDMI.23 225.77,185.13 ; JHDMI.23 224.84,183.85 ; JHDMI.23 225.77,182.57 ; JHDMI.23 226.7,185.13 ; JHDMI.23 226.7,183.85 ; JHDMI.23 224.84,185.13 ; 196.21,186.97 JUSBC1.4 ; JUSBC1.4 197.04,186.97 ; JUSBC1.4 196.21,185.55 ; JUSBC1.4 197.87,185.55 ; JUSBC1.4 197.87,186.97 ; JUSBC1.4 197.87,184.13 ; JUSBC1.4 197.04,184.13 ; JUSBC1.4 196.21,184.13 ; 232.37,174.91 JDP.1 ; JDP.1 232.37,176.07 ; JDP.1 232.84,175.95 ; JDP.1 231.79,175.49 ; JDP.1 232.84,175.03 ; JDP.1 231.91,175.95 ; JDP.1 231.91,175.03 ; H11.1 23.7,14.93 ; H11.1 20.44,11.67 ; H11.1 22.07,11.06 ; H11.1 20.44,14.93 ; H11.1 24.31,13.3 ; H11.1 19.83,13.3 ; H11.1 23.7,11.67 ; H11.1 22.07,15.54 ; 187.62,180.5 JUSBC1.1 ; JUSBC1.1 187.62,181.73 ; JUSBC1.1 188.4,179.27 ; JUSBC1.1 187.62,179.27 ; JUSBC1.1 189.18,181.73 ; JUSBC1.1 189.18,179.27 ; JUSBC1.1 188.4,181.73 ; H10.1 29.49,54.38 ; H10.1 29.49,57.22 ; H10.1 28.07,53.87 ; H10.1 30,55.8 ; H10.1 26.14,55.8 ; H10.1 26.65,57.22 ; H10.1 26.65,54.38 ; H10.1 28.07,57.73 ; H22.1 199.8,57.4 ; H22.1 197.87,59.33 ; H22.1 197.87,55.47 ; H22.1 199.29,55.98 ; H22.1 195.94,57.4 ; H22.1 196.45,55.98 ; H22.1 196.45,58.82 ; H22.1 199.29,58.82 ; H8.1 7,71.6 ; H8.1 3.65,73.02 ; H8.1 6.49,73.02 ; H8.1 3.65,70.18 ; H8.1 5.07,69.67 ; H8.1 3.14,71.6 ; H8.1 5.07,73.53 ; H8.1 6.49,70.18 ; 260.65,9.72 H21.1 ; H21.1 262.07,6.37 ; H21.1 263.49,6.88 ; H21.1 263.49,9.72 ; H21.1 262.07,10.23 ; H21.1 260.65,6.88 ; H21.1 260.14,8.3 ; H21.1 264,8.3 ; 92.87,56.77 H19.1 ; H19.1 91.45,57.28 ; H19.1 92.87,60.63 ; H19.1 90.94,58.7 ; H19.1 91.45,60.12 ; H19.1 94.8,58.7 ; H19.1 94.29,60.12 ; H19.1 94.29,57.28 ; 197.33,153.8 H13.1 ; H13.1 201.81,153.8 ; H13.1 199.57,151.27 ; H13.1 197.33,156.33 ; H13.1 201.81,156.33 ; H13.1 199.57,156.33 ; H13.1 201.81,151.27 ; H13.1 197.33,151.27 ; H17.1 144.57,175.23 ; H17.1 145.99,171.88 ; H17.1 146.5,173.3 ; H17.1 142.64,173.3 ; H17.1 145.99,174.72 ; H17.1 143.15,171.88 ; H17.1 144.57,171.37 ; H17.1 143.15,174.72 ; 265.49,6.06 H23.1 ; H23.1 265.49,10.54 ; H23.1 267.97,6.06 ; H23.1 265.49,8.3 ; H23.1 270.45,8.3 ; H23.1 267.97,10.54 ; H23.1 270.45,6.06 ; H23.1 270.45,10.54 ; 235.61,173.83 JDP.13 ; JDP.13 235.61,174.75 ; JDP.13 236.07,173.71 ; JDP.13 236.54,173.83 ; JDP.13 236.07,174.87 ; JDP.13 236.54,174.75 ; JDP.13 235.49,174.29 ; 187.57,184.13 JUSBC1.2 ; JUSBC1.2 187.57,185.55 ; JUSBC1.2 189.23,185.55 ; JUSBC1.2 189.23,184.13 ; JUSBC1.2 189.23,186.97 ; JUSBC1.2 188.4,186.97 ; JUSBC1.2 188.4,184.13 ; JUSBC1.2 187.57,186.97 ; 13.21,46.96 JUSB1.12 ; JUSB1.12 13.21,46.1 ; JUSB1.12 16.71,46.1 ; JUSB1.12 13.21,45.24 ; JUSB1.12 14.96,45.24 ; JUSB1.12 16.71,45.24 ; JUSB1.12 16.71,46.96 ; JUSB1.12 14.96,46.96 ; H15.1 185.15,181.9 ; H15.1 181.29,181.9 ; H15.1 183.22,183.83 ; H15.1 184.64,183.32 ; H15.1 181.8,183.32 ; H15.1 183.22,179.97 ; H15.1 181.8,180.48 ; H15.1 184.64,180.48 ; 205.07,47.96 H4.1 ; H4.1 207.41,50.3 ; H4.1 205.07,52.64 ; H4.1 202.73,50.3 ; H4.1 203.37,52 ; H4.1 206.77,52 ; H4.1 203.37,48.6 ; H4.1 206.77,48.6 ; 117.97,156.56 JPCMC.36 ; JPCMC.36 117.97,160.16 ; JPCMC.36 119.77,160.84 ; JPCMC.36 119.77,155.88 ; JPCMC.36 121.57,156.56 ; JPCMC.36 122.25,158.36 ; H14.1 202.22,183.83 ; H14.1 203.64,183.32 ; H14.1 203.64,180.48 ; H14.1 202.22,179.97 ; H14.1 200.8,180.48 ; H14.1 200.8,183.32 ; H14.1 204.15,181.9 ; H14.1 200.29,181.9 ; JUSBC2.4 3.22,57.78 ; JUSBC2.4 0.38,58.61 ; JUSBC2.4 3.22,58.61 ; JUSBC2.4 0.38,56.95 ; JUSBC2.4 1.8,58.61 ; JUSBC2.4 1.8,56.95 ; JUSBC2.4 0.38,57.78 ; JUSBC2.4 3.22,56.95 ; JHDMI.11 217.58,175.64 ; JHDMI.11 216.66,176.56 ; JHDMI.11 217.12,175.52 ; JHDMI.11 217.58,176.56 ; JHDMI.11 216.66,175.64 ; JHDMI.11 217.12,176.68 ; JCDRA.50 178.67,185.67 ; JCDRA.50 178.67,182.55 ; JCDRA.50 176.67,184.11 ; JCDRA.50 178.67,184.11 ; JCDRA.50 176.67,185.67 ; JCDRA.50 177.67,182.55 ; JCDRA.50 176.67,182.55 ; JCDRA.50 177.67,185.67 ; 0.38,66.42 JUSBC2.2 ; JUSBC2.2 0.38,67.25 ; JUSBC2.2 0.38,65.59 ; JUSBC2.2 1.8,65.59 ; JUSBC2.2 3.22,66.42 ; JUSBC2.2 3.22,67.25 ; JUSBC2.2 3.22,65.59 ; JUSBC2.2 1.8,67.25 ; JUSB1.7 15.64,39.11 ; JUSB1.7 14.46,40.29 ; JUSB1.7 14.46,39.11 ; JUSB1.7 15.81,39.7 ; JUSB1.7 15.05,40.46 ; JUSB1.7 15.64,40.29 ; JUSB1.7 14.29,39.7 ; JUSB1.7 15.05,38.94 ; JHDMI.22 223.87,175.68 ; JHDMI.22 222.94,173.12 ; JHDMI.22 224.8,175.68 ; JHDMI.22 224.8,174.4 ; JHDMI.22 224.8,173.12 ; JHDMI.22 222.94,174.4 ; JHDMI.22 223.87,173.12 ; JHDMI.22 222.94,175.68 ; JUSBC2.3 8.08,58.56 ; JUSBC2.3 5.62,57 ; JUSBC2.3 5.62,58.56 ; JUSBC2.3 6.85,57 ; JUSBC2.3 8.08,57 ; JUSBC2.3 8.08,57.78 ; JUSBC2.3 5.62,57.78 ; H9.1 7.99,54.02 ; H9.1 5.15,51.18 ; H9.1 4.64,52.6 ; H9.1 6.57,50.67 ; H9.1 6.57,54.53 ; H9.1 8.5,52.6 ; H9.1 5.15,54.02 ; H9.1 7.99,51.18 ; 219.66,175.64 JHDMI.17 ; JHDMI.17 220.58,176.56 ; JHDMI.17 219.66,176.56 ; JHDMI.17 220.12,176.68 ; JHDMI.17 220.58,175.64 ; JHDMI.17 220.12,175.52 ; H20.1 299.29,79.47 ; H20.1 297.87,76.12 ; H20.1 296.45,76.63 ; H20.1 296.45,79.47 ; H20.1 299.8,78.05 ; H20.1 295.94,78.05 ; H20.1 297.87,79.98 ; H20.1 299.29,76.63 ; JLAN.14 263.65,179.99 ; JLAN.14 262.74,178.23 ; JLAN.14 261.82,181.74 ; JLAN.14 261.82,178.23 ; JLAN.14 261.82,179.99 ; JLAN.14 263.65,178.23 ; JLAN.14 262.74,181.74 ; JLAN.14 263.65,181.74 ; JDP.21 241.35,177.14 ; JDP.21 240.57,179.76 ; JDP.21 240.57,177.14 ; JDP.21 241.35,178.45 ; JDP.21 239.8,178.45 ; JDP.21 239.8,177.14 ; JDP.21 239.8,179.76 ; JDP.21 241.35,179.76 ; H12.1 276.17,174.33 ; H12.1 274.75,170.98 ; H12.1 278.1,172.4 ; H12.1 274.75,173.82 ; H12.1 276.17,170.47 ; H12.1 277.59,170.98 ; H12.1 274.24,172.4 ; H12.1 277.59,173.82 ; 5.63,58.11 JUSBC2.6 ; JUSBC2.6 5.63,57 ; JUSBC2.6 7.07,59.01 ; JUSBC2.6 5.63,59.01 ; JUSBC2.6 6.35,59.01 ; JUSBC2.6 7.07,57 ; JUSBC2.6 6.35,57 ; 180.04,90.47 H3.1 ; H3.1 181.67,94.34 ; H3.1 179.43,92.1 ; H3.1 183.91,92.1 ; H3.1 183.3,93.73 ; H3.1 180.04,93.73 ; H3.1 181.67,89.86 ; H3.1 183.3,90.47 ; JUSB1.14 7.71,48.46 ; JUSB1.14 6.2,48.46 ; JUSB1.14 4.69,48.46 ; JUSB1.14 4.69,47.6 ; JUSB1.14 7.71,47.6 ; JUSBC1.5 189.63,181.72 ; JUSBC1.5 187.62,181.72 ; JUSBC1.5 189.63,180.28 ; JUSBC1.5 187.62,181 ; JUSBC1.5 188.73,181.72 ; JUSBC1.5 187.62,180.28 ; JUSBC1.5 189.63,181 ; H6.1 181.6,8.3 ; H6.1 178.25,9.72 ; H6.1 179.67,6.37 ; H6.1 179.67,10.23 ; H6.1 181.09,9.72 ; H6.1 177.74,8.3 ; H6.1 178.25,6.88 ; H6.1 181.09,6.88 ; JCDRA.48 146.17,182.55 ; JCDRA.48 144.17,182.55 ; JCDRA.48 146.17,184.11 ; JCDRA.48 144.17,185.67 ; JCDRA.48 146.17,185.67 ; JCDRA.48 145.17,182.55 ; JCDRA.48 144.17,184.11 ; JCDRA.48 145.17,185.67 ; 233.61,173.83 JDP.7 ; JDP.7 234.54,173.83 ; JDP.7 234.66,174.29 ; JDP.7 233.61,174.75 ; JDP.7 234.54,174.75 ; JDP.7 234.07,174.87 ; JDP.7 234.07,173.71 ; 102.07,6.37 H18.1 ; H18.1 104,8.3 ; H18.1 102.07,10.23 ; H18.1 100.65,9.72 ; H18.1 100.65,6.88 ; H18.1 100.14,8.3 ; H18.1 103.49,9.72 ; H18.1 103.49,6.88 ; JUSBC2.1 6.85,67.2 ; JUSBC2.1 5.62,67.2 ; JUSBC2.1 5.62,65.64 ; JUSBC2.1 8.08,65.64 ; JUSBC2.1 8.08,66.42 ; JUSBC2.1 8.08,67.2 ; JUSBC2.1 5.62,66.42 ; 266.73,152.3 H7.1 ; H7.1 269.07,149.96 ; H7.1 267.37,150.6 ; H7.1 270.77,154 ; H7.1 270.77,150.6 ; H7.1 267.37,154 ; H7.1 269.07,154.64 ; H7.1 271.41,152.3 ; 208.44,174.4 JHDMI.20 ; JHDMI.20 208.44,175.68 ; JHDMI.20 209.37,175.68 ; JHDMI.20 209.37,173.12 ; JHDMI.20 210.3,175.68 ; JHDMI.20 208.44,173.12 ; JHDMI.20 210.3,173.12 ; JHDMI.20 210.3,174.4 ; JUSBC2.5 7.07,67.2 ; JUSBC2.5 5.63,67.2 ; JUSBC2.5 6.35,67.2 ; JUSBC2.5 5.63,66.1 ; JUSBC2.5 5.63,65.19 ; JUSBC2.5 7.07,65.19 ; JUSBC2.5 6.35,65.19 ; JDP.23 230.35,177.14 ; JDP.23 228.8,177.14 ; JDP.23 230.35,178.45 ; JDP.23 228.8,179.76 ; JDP.23 229.57,177.14 ; JDP.23 229.57,179.76 ; JDP.23 230.35,179.76 ; JDP.23 228.8,178.45 ; 206.54,181.32 JHDMI.21 ; JHDMI.21 208.4,181.32 ; JHDMI.21 207.47,181.32 ; JHDMI.21 206.54,182.6 ; JHDMI.21 207.47,183.88 ; JHDMI.21 208.4,183.88 ; JHDMI.21 206.54,183.88 ; JHDMI.21 208.4,182.6 ; JUSBC1.6 196.72,181.72 ; JUSBC1.6 197.82,180.28 ; JUSBC1.6 195.81,180.28 ; JUSBC1.6 195.81,181.72 ; JUSBC1.6 197.82,181 ; JUSBC1.6 195.81,181 ; JUSBC1.6 197.82,181.72 ; 20.65,7.42 H16.1 ; H16.1 20.14,6 ; H16.1 23.49,7.42 ; H16.1 22.07,7.93 ; H16.1 23.49,4.58 ; H16.1 20.65,4.58 ; H16.1 24,6 ; H16.1 22.07,4.07 ; JUSBC1.3 197.82,181.73 ; JUSBC1.3 196.27,179.27 ; JUSBC1.3 197.04,181.73 ; JUSBC1.3 197.82,179.27 ; JUSBC1.3 197.04,179.27 ; JUSBC1.3 196.27,181.73 ; JUSBC1.3 197.82,180.5 ; JHDMI.5 214.58,175.64 ; JHDMI.5 214.58,176.56 ; JHDMI.5 214.12,176.68 ; JHDMI.5 213.66,176.56 ; JHDMI.5 214.12,175.52 ; JHDMI.5 213.66,175.64 ; JCDRA.47 145.17,181.07 ; JCDRA.47 146.17,179.51 ; JCDRA.47 144.17,179.51 ; JCDRA.47 144.17,181.07 ; JCDRA.47 146.17,181.07 ; JCDRA.47 146.17,177.95 ; JCDRA.47 144.17,177.95 ; JCDRA.47 145.17,177.95 ; JDP.24 230.35,173.45 ; JDP.24 228.8,172.14 ; JDP.24 228.8,174.76 ; JDP.24 229.57,172.14 ; JDP.24 229.57,174.76 ; JDP.24 228.8,173.45 ; JDP.24 230.35,172.14 ; 276.07,42.96 H5.1 ; H5.1 274.37,47 ; H5.1 273.73,45.3 ; H5.1 274.37,43.6 ; H5.1 277.77,47 ; H5.1 277.77,43.6 ; H5.1 276.07,47.64 ; H5.1 278.41,45.3 ; JDP.22 241.35,173.45 ; JDP.22 241.35,174.76 ; JDP.22 241.35,172.14 ; JDP.22 240.57,172.14 ; JDP.22 239.8,173.45 ; JDP.22 239.8,172.14 ; JDP.22 240.57,174.76 ; JUSB1.4 17.14,36.79 ; JUSB1.4 15.96,35.61 ; JUSB1.4 15.79,36.2 ; JUSB1.4 15.96,36.79 ; JUSB1.4 17.31,36.2 ; JUSB1.4 16.55,35.44 ; JUSB1.4 17.14,35.61 ; JUSB1.4 16.55,36.96 ; JUSB1.13 7.71,31.8 ; JUSB1.13 6.2,30.94 ; JUSB1.13 4.69,31.8 ; JUSB1.13 7.71,30.94 ; JUSB1.13 4.69,30.94 ; H2.1 124.37,94.4 ; H2.1 124.37,91 ; H2.1 120.33,92.7 ; H2.1 125.01,92.7 ; H2.1 120.97,94.4 ; H2.1 122.67,90.36 ; H2.1 120.97,91 ; H2.1 122.67,95.04
  IN5 w0.203: JCDRA.47 146.17,181.07 ; JCDRA.47 146.17,177.95 ; JCDRA.47 146.17,179.51 ; JCDRA.47 144.17,177.95 ; JCDRA.47 145.17,177.95 ; JCDRA.47 144.17,181.07 ; JCDRA.47 144.17,179.51 ; JCDRA.47 145.17,181.07 ; JUSB1.7 15.64,39.11 ; JUSB1.7 15.05,40.46 ; JUSB1.7 15.81,39.7 ; JUSB1.7 14.46,40.29 ; JUSB1.7 14.46,39.11 ; JUSB1.7 14.29,39.7 ; JUSB1.7 15.05,38.94 ; JUSB1.7 15.64,40.29 ; 242.77,179.99 JLAN.16 ; JLAN.16 243.69,181.74 ; JLAN.16 242.77,178.23 ; JLAN.16 243.69,178.23 ; JLAN.16 242.77,181.74 ; JUSBC2.2 3.22,66.42 ; JUSBC2.2 1.8,65.59 ; JUSBC2.2 1.8,67.25 ; JUSBC2.2 3.22,67.25 ; JUSBC2.2 3.22,65.59 ; 144.17,182.55 JCDRA.48 ; JCDRA.48 146.17,184.11 ; JCDRA.48 146.17,182.55 ; JCDRA.48 144.17,184.11 ; JCDRA.48 146.17,185.67 ; JCDRA.48 144.17,185.67 ; JCDRA.48 145.17,185.67 ; JCDRA.48 145.17,182.55 ; 202.22,179.97 H14.1 ; H14.1 203.64,180.48 ; H14.1 202.22,183.83 ; H14.1 200.8,183.32 ; H14.1 204.15,181.9 ; H14.1 200.8,180.48 ; H14.1 203.64,183.32 ; H14.1 200.29,181.9 ; 215.16,174.09 JHDMI.8 ; JHDMI.8 215.16,175.01 ; JHDMI.8 215.62,175.13 ; JHDMI.8 215.62,173.97 ; JHDMI.8 216.08,174.09 ; JHDMI.8 216.08,175.01 ; 5.07,69.67 H8.1 ; H8.1 3.65,73.02 ; H8.1 6.49,70.18 ; H8.1 6.49,73.02 ; H8.1 3.65,70.18 ; H8.1 7,71.6 ; H8.1 5.07,73.53 ; H8.1 3.14,71.6 ; 4.69,30.94 JUSB1.13 ; JUSB1.13 7.71,31.8 ; JUSB1.13 4.69,31.8 ; JUSB1.13 6.2,30.94 ; JUSB1.13 7.71,30.94 ; JDP.19 238.24,175.95 ; JDP.19 238.24,175.03 ; JDP.19 237.77,174.91 ; JDP.19 237.31,175.03 ; JDP.19 237.77,176.07 ; JDP.19 238.36,175.49 ; JDP.19 237.31,175.95 ; 15.79,36.2 JUSB1.4 ; JUSB1.4 17.31,36.2 ; JUSB1.4 17.14,35.61 ; JUSB1.4 17.14,36.79 ; JUSB1.4 16.55,36.96 ; JUSB1.4 16.55,35.44 ; JUSB1.4 15.96,36.79 ; JUSB1.4 15.96,35.61 ; JUSBC2.6 6.35,59.01 ; JUSBC2.6 5.63,59.01 ; JUSBC2.6 5.63,57 ; JUSBC2.6 7.07,59.01 ; JUSBC2.6 7.07,57 ; JUSBC2.6 5.63,58.11 ; JUSBC2.6 6.35,57 ; JHDMI.22 224.8,175.68 ; JHDMI.22 222.94,175.68 ; JHDMI.22 222.94,174.4 ; JHDMI.22 224.8,174.4 ; H15.1 185.15,181.9 ; H15.1 184.64,180.48 ; H15.1 181.8,183.32 ; H15.1 184.64,183.32 ; H15.1 183.22,183.83 ; H15.1 181.8,180.48 ; H15.1 181.29,181.9 ; H15.1 183.22,179.97 ; 235.61,174.75 JDP.13 ; JDP.13 236.07,173.71 ; JDP.13 235.61,173.83 ; JDP.13 236.54,173.83 ; JDP.13 235.49,174.29 ; JDP.13 236.54,174.75 ; JDP.13 236.07,174.87 ; 5.62,66.42 JUSBC2.1 ; JUSBC2.1 8.08,66.42 ; JUSBC2.1 8.08,65.64 ; JUSBC2.1 6.85,67.2 ; JUSBC2.1 5.62,67.2 ; JUSBC2.1 8.08,67.2 ; JUSBC2.1 5.62,65.64 ; 217.12,175.52 JHDMI.11 ; JHDMI.11 216.66,175.64 ; JHDMI.11 217.58,175.64 ; H7.1 270.77,154 ; H7.1 270.77,150.6 ; H7.1 267.37,154 ; H7.1 271.41,152.3 ; H7.1 269.07,154.64 ; H7.1 267.37,150.6 ; H7.1 269.07,149.96 ; H7.1 266.73,152.3 ; JUSB1.11 16.71,34.16 ; JUSB1.11 16.71,32.44 ; JUSB1.11 14.96,34.16 ; JUSB1.11 14.96,32.44 ; JUSB1.11 16.71,33.3 ; 6.35,65.19 JUSBC2.5 ; JUSBC2.5 5.63,66.1 ; JUSBC2.5 7.07,67.2 ; JUSBC2.5 7.07,65.19 ; JUSBC2.5 5.63,65.19 ; JUSBC2.5 5.63,67.2 ; JUSBC2.5 6.35,67.2 ; JUSBC1.3 197.04,181.73 ; JUSBC1.3 197.82,181.73 ; JUSBC1.3 197.04,179.27 ; JUSBC1.3 197.82,180.5 ; JUSBC1.3 197.82,179.27 ; JUSBC1.3 196.27,179.27 ; JUSBC1.3 196.27,181.73 ; 6.57,50.67 H9.1 ; H9.1 4.64,52.6 ; H9.1 5.15,51.18 ; H9.1 8.5,52.6 ; H9.1 7.99,54.02 ; H9.1 5.15,54.02 ; H9.1 6.57,54.53 ; H9.1 7.99,51.18 ; JCDRA.49 178.67,179.51 ; JCDRA.49 176.67,181.07 ; JCDRA.49 178.67,181.07 ; JCDRA.49 177.67,177.95 ; JCDRA.49 176.67,179.51 ; JCDRA.49 177.67,181.07 ; JCDRA.49 178.67,177.95 ; JCDRA.49 176.67,177.95 ; JLAN.14 263.65,178.23 ; JLAN.14 262.74,181.74 ; JLAN.14 262.74,178.23 ; JLAN.14 263.65,179.99 ; JLAN.14 263.65,181.74 ; JDP.21 241.35,178.45 ; JDP.21 240.57,179.76 ; JDP.21 240.57,177.14 ; JDP.21 241.35,179.76 ; JDP.21 241.35,177.14 ; 197.04,184.13 JUSBC1.4 ; JUSBC1.4 197.87,185.55 ; JUSBC1.4 197.87,184.13 ; JUSBC1.4 196.21,184.13 ; JUSBC1.4 196.21,185.55 ; JDP.22 240.57,174.76 ; JDP.22 239.8,173.45 ; JDP.22 241.35,173.45 ; JDP.22 241.35,174.76 ; 176.67,184.11 JCDRA.50 ; JCDRA.50 177.67,182.55 ; JCDRA.50 176.67,185.67 ; JCDRA.50 178.67,182.55 ; JCDRA.50 178.67,184.11 ; JCDRA.50 176.67,182.55 ; JCDRA.50 177.67,185.67 ; JCDRA.50 178.67,185.67 ; JUSBC1.6 196.72,181.72 ; JUSBC1.6 197.82,181.72 ; JUSBC1.6 195.81,181.72 ; JUSBC1.6 197.82,180.28 ; JUSBC1.6 197.82,181 ; JUSBC1.6 195.81,181 ; JUSBC1.6 195.81,180.28 ; JHDMI.21 207.47,183.88 ; JHDMI.21 206.54,183.88 ; JHDMI.21 206.54,182.6 ; JHDMI.21 207.47,181.32 ; JHDMI.21 206.54,181.32 ; 5.62,57 JUSBC2.3 ; JUSBC2.3 8.08,57 ; JUSBC2.3 6.85,57 ; JUSBC2.3 5.62,57.78 ; JUSBC2.3 5.62,58.56 ; JUSBC2.3 8.08,58.56 ; JUSBC2.3 8.08,57.78 ; JUSB1.12 14.96,46.96 ; JUSB1.12 14.96,45.24 ; JUSB1.12 16.71,45.24 ; JUSB1.12 16.71,46.1 ; JUSB1.12 16.71,46.96 ; JUSBC1.2 189.23,184.13 ; JUSBC1.2 188.4,184.13 ; JUSBC1.2 187.57,184.13 ; JUSBC1.2 187.57,185.55 ; JUSBC1.2 189.23,185.55 ; JUSBC2.4 3.22,58.61 ; JUSBC2.4 3.22,57.78 ; JUSBC2.4 3.22,56.95 ; JUSBC2.4 1.8,58.61 ; JUSBC2.4 1.8,56.95 ; 228.8,179.76 JDP.23 ; JDP.23 229.57,177.14 ; JDP.23 229.57,179.76 ; JDP.23 228.8,178.45 ; JDP.23 228.8,177.14 ; 4.69,48.46 JUSB1.14 ; JUSB1.14 6.2,48.46 ; JUSB1.14 7.71,48.46 ; JUSB1.14 7.71,47.6 ; JUSB1.14 4.69,47.6 ; JHDMI.2 213.08,175.01 ; JHDMI.2 212.16,175.01 ; JHDMI.2 212.04,174.55 ; JHDMI.2 212.16,174.09 ; JHDMI.2 213.08,174.09 ; JHDMI.2 212.62,175.13 ; JHDMI.2 212.62,173.97 ; 219.66,175.64 JHDMI.17 ; JHDMI.17 220.58,175.64 ; JHDMI.17 220.12,175.52 ; JDP.7 234.54,173.83 ; JDP.7 234.66,174.29 ; JDP.7 234.07,173.71 ; JDP.7 234.07,174.87 ; JDP.7 233.61,173.83 ; JDP.7 233.61,174.75 ; JDP.7 234.54,174.75 ; 187.62,181.72 JUSBC1.5 ; JUSBC1.5 187.62,180.28 ; JUSBC1.5 188.73,181.72 ; JUSBC1.5 187.62,181 ; JUSBC1.5 189.63,180.28 ; JUSBC1.5 189.63,181 ; JUSBC1.5 189.63,181.72 ; 213.66,175.64 JHDMI.5 ; JHDMI.5 214.58,175.64 ; JHDMI.5 214.12,175.52 ; JDP.24 230.35,173.45 ; JDP.24 228.8,174.76 ; JDP.24 228.8,173.45 ; JDP.24 229.57,174.76 ; 274.75,173.82 H12.1 ; H12.1 277.59,173.82 ; H12.1 278.1,172.4 ; H12.1 276.17,170.47 ; H12.1 274.24,172.4 ; H12.1 277.59,170.98 ; H12.1 276.17,174.33 ; H12.1 274.75,170.98 ; JUSBC1.1 189.18,181.73 ; JUSBC1.1 187.62,181.73 ; JUSBC1.1 188.4,179.27 ; JUSBC1.1 189.18,179.27 ; JUSBC1.1 187.62,179.27 ; JUSBC1.1 187.62,180.5 ; JUSBC1.1 188.4,181.73 ; JDP.1 232.84,175.95 ; JDP.1 231.79,175.49 ; JDP.1 232.37,176.07 ; JDP.1 232.37,174.91 ; JDP.1 231.91,175.95 ; JDP.1 232.84,175.03 ; JDP.1 231.91,175.03 ; 208.44,174.4 JHDMI.20 ; JHDMI.20 210.3,174.4 ; JHDMI.20 210.3,175.68 ; JHDMI.20 208.44,175.68 ; JHDMI.23 226.7,183.85 ; JHDMI.23 226.7,182.57 ; JHDMI.23 225.77,182.57
  GND5 w0.203: JDP.7 234.54,173.83 ; JDP.7 234.07,174.87 ; JDP.7 234.54,174.75 ; JDP.7 233.61,174.75 ; JDP.7 234.07,173.71 ; JDP.7 233.61,173.83 ; JDP.7 234.66,174.29 ; H7.1 270.77,154 ; H7.1 269.07,149.96 ; H7.1 267.37,154 ; H7.1 269.07,154.64 ; H7.1 271.41,152.3 ; H7.1 267.37,150.6 ; H7.1 266.73,152.3 ; H7.1 270.77,150.6 ; 0.38,58.61 JUSBC2.4 ; JUSBC2.4 0.38,57.78 ; JUSBC2.4 1.8,56.95 ; JUSBC2.4 3.22,57.78 ; JUSBC2.4 3.22,56.95 ; JUSBC2.4 3.22,58.61 ; JUSBC2.4 1.8,58.61 ; JUSBC2.4 0.38,56.95 ; 274.75,173.82 H12.1 ; H12.1 274.75,170.98 ; H12.1 276.17,170.47 ; H12.1 277.59,173.82 ; H12.1 276.17,174.33 ; H12.1 274.24,172.4 ; H12.1 278.1,172.4 ; H12.1 277.59,170.98 ; JDP.24 230.35,173.45 ; JDP.24 229.57,174.76 ; JDP.24 228.8,174.76 ; JDP.24 230.35,172.14 ; JDP.24 229.57,172.14 ; JDP.24 228.8,173.45 ; JDP.24 228.8,172.14 ; 242.77,181.74 JLAN.16 ; JLAN.16 244.6,178.23 ; JLAN.16 243.69,178.23 ; JLAN.16 242.77,179.99 ; JLAN.16 244.6,181.74 ; JLAN.16 244.6,179.99 ; JLAN.16 243.69,181.74 ; JLAN.16 242.77,178.23 ; JHDMI.17 220.58,175.64 ; JHDMI.17 219.66,176.56 ; JHDMI.17 220.12,176.68 ; JHDMI.17 219.66,175.64 ; JHDMI.17 220.58,176.56 ; JHDMI.17 220.12,175.52 ; 235.61,174.75 JDP.13 ; JDP.13 236.54,173.83 ; JDP.13 236.07,173.71 ; JDP.13 236.54,174.75 ; JDP.13 236.07,174.87 ; JDP.13 235.49,174.29 ; JDP.13 235.61,173.83 ; JHDMI.20 209.37,175.68 ; JHDMI.20 208.44,173.12 ; JHDMI.20 210.3,173.12 ; JHDMI.20 210.3,175.68 ; JHDMI.20 208.44,174.4 ; JHDMI.20 210.3,174.4 ; JHDMI.20 208.44,175.68 ; JHDMI.20 209.37,173.12 ; H23.1 270.45,10.54 ; H23.1 267.97,6.06 ; H23.1 267.97,10.54 ; H23.1 270.45,8.3 ; H23.1 265.49,8.3 ; H23.1 270.45,6.06 ; H23.1 265.49,6.06 ; H23.1 265.49,10.54 ; JUSB1.14 6.2,48.46 ; JUSB1.14 4.69,47.6 ; JUSB1.14 4.69,48.46 ; JUSB1.14 7.71,47.6 ; JUSB1.14 7.71,48.46 ; H10.1 29.49,57.22 ; H10.1 28.07,57.73 ; H10.1 26.14,55.8 ; H10.1 29.49,54.38 ; H10.1 28.07,53.87 ; H10.1 26.65,54.38 ; H10.1 30,55.8 ; H10.1 26.65,57.22 ; JCDRA.47 146.17,177.95 ; JCDRA.47 146.17,179.51 ; JCDRA.47 145.17,181.07 ; JCDRA.47 144.17,177.95 ; JCDRA.47 144.17,181.07 ; JCDRA.47 145.17,177.95 ; JCDRA.47 146.17,181.07 ; JCDRA.47 144.17,179.51 ; H13.1 201.81,151.27 ; H13.1 201.81,156.33 ; H13.1 201.81,153.8 ; H13.1 199.57,156.33 ; H13.1 197.33,151.27 ; H13.1 197.33,153.8 ; H13.1 199.57,151.27 ; H13.1 197.33,156.33 ; JCDRA.49 178.67,181.07 ; JCDRA.49 176.67,177.95 ; JCDRA.49 177.67,181.07 ; JCDRA.49 176.67,181.07 ; JCDRA.49 176.67,179.51 ; JCDRA.49 178.67,179.51 ; JCDRA.49 177.67,177.95 ; JCDRA.49 178.67,177.95 ; H1.1 146.67,155.7 ; H1.1 143.27,159.1 ; H1.1 144.97,155.06 ; H1.1 147.31,157.4 ; H1.1 142.63,157.4 ; H1.1 146.67,159.1 ; H1.1 144.97,159.74 ; H1.1 143.27,155.7 ; 237.31,175.03 JDP.19 ; JDP.19 237.77,174.91 ; JDP.19 238.24,175.03 ; JDP.19 238.36,175.49 ; JDP.19 238.24,175.95 ; JDP.19 237.77,176.07 ; JDP.19 237.31,175.95 ; 188.4,184.13 JUSBC1.2 ; JUSBC1.2 189.23,185.55 ; JUSBC1.2 187.57,186.97 ; JUSBC1.2 189.23,184.13 ; JUSBC1.2 187.57,185.55 ; JUSBC1.2 189.23,186.97 ; JUSBC1.2 187.57,184.13 ; JUSBC1.2 188.4,186.97 ; H2.1 124.37,91 ; H2.1 124.37,94.4 ; H2.1 120.97,94.4 ; H2.1 122.67,95.04 ; H2.1 122.67,90.36 ; H2.1 125.01,92.7 ; H2.1 120.33,92.7 ; H2.1 120.97,91 ; 231.91,175.95 JDP.1 ; JDP.1 232.84,175.03 ; JDP.1 231.91,175.03 ; JDP.1 232.84,175.95 ; JDP.1 232.37,174.91 ; JDP.1 231.79,175.49 ; JDP.1 232.37,176.07 ; 295.94,78.05 H20.1 ; H20.1 299.29,76.63 ; H20.1 297.87,76.12 ; H20.1 297.87,79.98 ; H20.1 296.45,79.47 ; H20.1 299.8,78.05 ; H20.1 296.45,76.63 ; H20.1 299.29,79.47 ; JHDMI.11 217.58,175.64 ; JHDMI.11 216.66,175.64 ; JHDMI.11 217.58,176.56 ; JHDMI.11 216.66,176.56 ; JHDMI.11 217.12,176.68 ; JHDMI.11 217.12,175.52 ; H11.1 23.7,14.93 ; H11.1 22.07,11.06 ; H11.1 20.44,14.93 ; H11.1 23.7,11.67 ; H11.1 20.44,11.67 ; H11.1 19.83,13.3 ; H11.1 22.07,15.54 ; H11.1 24.31,13.3 ; 222.94,175.68 JHDMI.22 ; JHDMI.22 222.94,174.4 ; JHDMI.22 223.87,173.12 ; JHDMI.22 223.87,175.68 ; JHDMI.22 224.8,173.12 ; JHDMI.22 222.94,173.12 ; JHDMI.22 224.8,175.68 ; JHDMI.22 224.8,174.4 ; 179.43,92.1 H3.1 ; H3.1 180.04,93.73 ; H3.1 180.04,90.47 ; H3.1 183.3,90.47 ; H3.1 181.67,89.86 ; H3.1 183.3,93.73 ; H3.1 181.67,94.34 ; H3.1 183.91,92.1 ; H22.1 199.8,57.4 ; H22.1 199.29,58.82 ; H22.1 199.29,55.98 ; H22.1 197.87,55.47 ; H22.1 196.45,58.82 ; H22.1 196.45,55.98 ; H22.1 197.87,59.33 ; H22.1 195.94,57.4 ; 144.57,171.37 H17.1 ; H17.1 145.99,174.72 ; H17.1 142.64,173.3 ; H17.1 146.5,173.3 ; H17.1 145.99,171.88 ; H17.1 144.57,175.23 ; H17.1 143.15,174.72 ; H17.1 143.15,171.88 ; 5.63,59.01 JUSBC2.6 ; JUSBC2.6 5.63,58.11 ; JUSBC2.6 6.35,59.01 ; JUSBC2.6 7.07,57 ; JUSBC2.6 7.07,59.01 ; JUSBC2.6 6.35,57 ; JUSBC2.6 5.63,57 ; 196.21,186.97 JUSBC1.4 ; JUSBC1.4 196.21,184.13 ; JUSBC1.4 196.21,185.55 ; JUSBC1.4 197.04,184.13 ; JUSBC1.4 197.87,186.97 ; JUSBC1.4 197.87,185.55 ; JUSBC1.4 197.87,184.13 ; JUSBC1.4 197.04,186.97 ; JUSBC2.1 8.08,65.64 ; JUSBC2.1 6.85,67.2 ; JUSBC2.1 5.62,66.42 ; JUSBC2.1 5.62,65.64 ; JUSBC2.1 5.62,67.2 ; JUSBC2.1 8.08,67.2 ; JUSBC2.1 8.08,66.42 ; 187.62,181 JUSBC1.5 ; JUSBC1.5 189.63,180.28 ; JUSBC1.5 189.63,181.72 ; JUSBC1.5 188.73,181.72 ; JUSBC1.5 187.62,181.72 ; JUSBC1.5 187.62,180.28 ; JUSBC1.5 189.63,181 ; 224.84,185.13 JHDMI.23 ; JHDMI.23 225.77,182.57 ; JHDMI.23 224.84,183.85 ; JHDMI.23 225.77,185.13 ; JHDMI.23 226.7,183.85 ; JHDMI.23 226.7,185.13 ; JHDMI.23 224.84,182.57 ; JHDMI.23 226.7,182.57 ; 100.65,6.88 H18.1 ; H18.1 102.07,10.23 ; H18.1 103.49,6.88 ; H18.1 100.65,9.72 ; H18.1 102.07,6.37 ; H18.1 103.49,9.72 ; H18.1 104,8.3 ; H18.1 100.14,8.3 ; H6.1 181.09,9.72 ; H6.1 179.67,10.23 ; H6.1 177.74,8.3 ; H6.1 178.25,6.88 ; H6.1 178.25,9.72 ; H6.1 179.67,6.37 ; H6.1 181.6,8.3 ; H6.1 181.09,6.88 ; JUSBC2.2 3.22,67.25 ; JUSBC2.2 1.8,65.59 ; JUSBC2.2 3.22,66.42 ; JUSBC2.2 0.38,67.25 ; JUSBC2.2 0.38,65.59 ; JUSBC2.2 3.22,65.59 ; JUSBC2.2 0.38,66.42 ; JUSBC2.2 1.8,67.25 ; 206.54,183.88 JHDMI.21 ; JHDMI.21 208.4,181.32 ; JHDMI.21 207.47,183.88 ; JHDMI.21 207.47,181.32 ; JHDMI.21 208.4,182.6 ; JHDMI.21 206.54,181.32 ; JHDMI.21 206.54,182.6 ; JHDMI.21 208.4,183.88 ; 212.16,174.09 JHDMI.2 ; JHDMI.2 213.08,175.01 ; JHDMI.2 212.62,175.13 ; JHDMI.2 212.04,174.55 ; JHDMI.2 212.62,173.97 ; JHDMI.2 213.08,174.09 ; JHDMI.2 212.16,175.01 ; 200.8,183.32 H14.1 ; H14.1 202.22,179.97 ; H14.1 203.64,183.32 ; H14.1 202.22,183.83 ; H14.1 203.64,180.48 ; H14.1 200.29,181.9 ; H14.1 200.8,180.48 ; H14.1 204.15,181.9 ; H21.1 263.49,9.72 ; H21.1 263.49,6.88 ; H21.1 264,8.3 ; H21.1 262.07,6.37 ; H21.1 260.65,9.72 ; H21.1 262.07,10.23 ; H21.1 260.14,8.3 ; H21.1 260.65,6.88 ; JUSB1.12 14.96,46.96 ; JUSB1.12 13.21,46.1 ; JUSB1.12 16.71,45.24 ; JUSB1.12 13.21,45.24 ; JUSB1.12 16.71,46.96 ; JUSB1.12 13.21,46.96 ; JUSB1.12 16.71,46.1 ; JUSB1.12 14.96,45.24 ; JUSB1.7 15.81,39.7 ; JUSB1.7 15.05,38.94 ; JUSB1.7 14.46,39.11 ; JUSB1.7 14.46,40.29 ; JUSB1.7 15.05,40.46 ; JUSB1.7 15.64,39.11 ; JUSB1.7 14.29,39.7 ; JUSB1.7 15.64,40.29 ; JDP.21 241.35,179.76 ; JDP.21 240.57,179.76 ; JDP.21 239.8,178.45 ; JDP.21 241.35,177.14 ; JDP.21 239.8,179.76 ; JDP.21 239.8,177.14 ; JDP.21 240.57,177.14 ; JDP.21 241.35,178.45 ; JUSB1.4 17.14,36.79 ; JUSB1.4 16.55,36.96 ; JUSB1.4 16.55,35.44 ; JUSB1.4 17.31,36.2 ; JUSB1.4 17.14,35.61 ; JUSB1.4 15.96,36.79 ; JUSB1.4 15.79,36.2 ; JUSB1.4 15.96,35.61 ; 261.82,181.74 JLAN.14 ; JLAN.14 263.65,181.74 ; JLAN.14 261.82,178.23 ; JLAN.14 262.74,181.74 ; JLAN.14 262.74,178.23 ; JLAN.14 263.65,179.99 ; JLAN.14 261.82,179.99 ; JLAN.14 263.65,178.23 ; 228.8,178.45 JDP.23 ; JDP.23 229.57,179.76 ; JDP.23 230.35,179.76 ; JDP.23 230.35,178.45 ; JDP.23 229.57,177.14 ; JDP.23 228.8,177.14 ; JDP.23 228.8,179.76 ; JDP.23 230.35,177.14 ; JUSBC1.6 197.82,181 ; JUSBC1.6 197.82,181.72 ; JUSBC1.6 196.72,181.72 ; JUSBC1.6 195.81,181.72 ; JUSBC1.6 195.81,180.28 ; JUSBC1.6 197.82,180.28 ; JUSBC1.6 195.81,181 ; JUSBC2.3 8.08,57.78 ; JUSBC2.3 8.08,58.56 ; JUSBC2.3 5.62,58.56 ; JUSBC2.3 5.62,57 ; JUSBC2.3 6.85,57 ; JUSBC2.3 8.08,57 ; JUSBC2.3 5.62,57.78 ; 5.63,66.1 JUSBC2.5 ; JUSBC2.5 5.63,65.19 ; JUSBC2.5 6.35,65.19 ; JUSBC2.5 7.07,65.19 ; JUSBC2.5 5.63,67.2 ; JUSBC2.5 7.07,67.2 ; JUSBC2.5 6.35,67.2 ; JHDMI.5 214.58,176.56 ; JHDMI.5 213.66,175.64 ; JHDMI.5 213.66,176.56 ; JHDMI.5 214.12,176.68 ; JHDMI.5 214.12,175.52 ; JHDMI.5 214.58,175.64 ; H15.1 184.64,180.48 ; H15.1 181.8,180.48 ; H15.1 185.15,181.9 ; H15.1 183.22,179.97 ; H15.1 181.8,183.32 ; H15.1 181.29,181.9 ; H15.1 184.64,183.32 ; H15.1 183.22,183.83 ; H16.1 23.49,7.42 ; H16.1 20.14,6 ; H16.1 20.65,4.58 ; H16.1 20.65,7.42 ; H16.1 22.07,4.07 ; H16.1 23.49,4.58 ; H16.1 22.07,7.93 ; H16.1 24,6 ; 176.67,184.11 JCDRA.50 ; JCDRA.50 178.67,184.11 ; JCDRA.50 176.67,182.55 ; JCDRA.50 178.67,185.67 ; JCDRA.50 177.67,185.67 ; JCDRA.50 177.67,182.55 ; JCDRA.50 176.67,185.67 ; JCDRA.50 178.67,182.55 ; 144.17,184.11 JCDRA.48 ; JCDRA.48 145.17,185.67 ; JCDRA.48 145.17,182.55 ; JCDRA.48 146.17,182.55 ; JCDRA.48 146.17,184.11 ; JCDRA.48 144.17,182.55 ; JCDRA.48 144.17,185.67 ; JCDRA.48 146.17,185.67 ; H9.1 6.57,54.53 ; H9.1 4.64,52.6 ; H9.1 7.99,54.02 ; H9.1 5.15,51.18 ; H9.1 6.57,50.67 ; H9.1 7.99,51.18 ; H9.1 8.5,52.6 ; H9.1 5.15,54.02 ; 6.2,30.94 JUSB1.13 ; JUSB1.13 4.69,30.94 ; JUSB1.13 7.71,30.94 ; JUSB1.13 7.71,31.8 ; JUSB1.13 4.69,31.8 ; JDP.22 240.57,174.76 ; JDP.22 239.8,173.45 ; JDP.22 239.8,172.14 ; JDP.22 241.35,174.76 ; JDP.22 240.57,172.14 ; JDP.22 241.35,172.14 ; JDP.22 241.35,173.45 ; 197.04,179.27 JUSBC1.3 ; JUSBC1.3 197.04,181.73 ; JUSBC1.3 197.82,179.27 ; JUSBC1.3 196.27,181.73 ; JUSBC1.3 197.82,180.5 ; JUSBC1.3 196.27,179.27 ; JUSBC1.3 197.82,181.73 ; H8.1 7,71.6 ; H8.1 6.49,70.18 ; H8.1 5.07,73.53 ; H8.1 6.49,73.02 ; H8.1 3.65,73.02 ; H8.1 3.14,71.6 ; H8.1 5.07,69.67 ; H8.1 3.65,70.18 ; 274.37,43.6 H5.1 ; H5.1 276.07,42.96 ; H5.1 277.77,47 ; H5.1 278.41,45.3 ; H5.1 273.73,45.3 ; H5.1 277.77,43.6 ; H5.1 276.07,47.64 ; H5.1 274.37,47 ; 13.21,32.44 JUSB1.11 ; JUSB1.11 13.21,33.3 ; JUSB1.11 13.21,34.16 ; JUSB1.11 14.96,34.16 ; JUSB1.11 16.71,33.3 ; JUSB1.11 16.71,32.44 ; JUSB1.11 14.96,32.44 ; JUSB1.11 16.71,34.16 ; H4.1 206.77,52 ; H4.1 202.73,50.3 ; H4.1 206.77,48.6 ; H4.1 205.07,47.96 ; H4.1 203.37,52 ; H4.1 205.07,52.64 ; H4.1 207.41,50.3 ; H4.1 203.37,48.6 ; 187.62,180.5 JUSBC1.1 ; JUSBC1.1 188.4,181.73 ; JUSBC1.1 189.18,181.73 ; JUSBC1.1 188.4,179.27 ; JUSBC1.1 187.62,181.73 ; JUSBC1.1 187.62,179.27 ; JUSBC1.1 189.18,179.27 ; H19.1 94.29,57.28 ; H19.1 92.87,60.63 ; H19.1 91.45,60.12 ; H19.1 92.87,56.77 ; H19.1 94.8,58.7 ; H19.1 94.29,60.12 ; H19.1 90.94,58.7 ; H19.1 91.45,57.28 ; JPCMC.36 122.25,158.36 ; JPCMC.36 119.77,160.84 ; JPCMC.36 121.57,156.56 ; JPCMC.36 119.77,155.88 ; JPCMC.36 117.97,160.16 ; JPCMC.36 117.97,156.56 ; 215.62,173.97 JHDMI.8 ; JHDMI.8 215.62,175.13 ; JHDMI.8 215.16,174.09 ; JHDMI.8 216.08,175.01 ; JHDMI.8 215.16,175.01 ; JHDMI.8 216.08,174.09
  IN6 w0.15: v2(221.54,88.65) 221.75,88.85 222.47,88.85 v2(222.77,89.15) 223.07,88.85 223.3,88.85 223.3,88.85 223.64,88.85 223.87,88.85 ; 222.53,101.45 222.23,101.15 v2(222.17,101.15) 222.04,101.15 221.74,101.45 ; 222.53,101.45 222.28,101.7 v2(222.12,101.7) 221.99,101.7 221.74,101.45 ; 222.53,101.45 223.15,101.45 v2(223.32,101.27) ; 223.87,88.85 v2(224.17,89.15) ; 223.87,88.85 223.87,88.55 v2(224.04,88.38) ; v2(248.83,107.51) 249.36,107.51 v2(249.42,107.45) 249.72,107.75 ; 221.74,101.45 221.64,101.45 221.64,101.45 221.16,101.45 221.01,101.3 v2(220.67,101.3) 220.65,101.32 v2(220.08,101.32) ; 249.72,107.75 249.72,107.8 249.49,108.03 v2(249.35,108.03) ; 249.72,107.75 UG9.AU47 ; UG9.AU47 v2(251.47,108.05) v2(251.47,107.45) UG9.AU47 ; v2(251.52,96.94) 251.2,97.25 250.38,97.25 v2(250.12,97.51) 249.85,97.24 249.66,97.24 249.65,97.25 249.3,97.25 249.29,97.24 249.13,97.24 v2(248.95,97.06)
  IN6 w0.25: v2(253.42,97.1) 253.27,96.95 v2(252.87,96.95) 252.38,97.44 v2(252.01,97.44) 252.01,97.43 v2(251.52,96.94)
  IN6 w0.3: v2(249.32,99.17) 249.59,99.17 v2(250.07,99.65) ; v2(249.32,99.17) 250.12,98.37 ; v2(249.32,99.17) 249.1,98.95 v2(248.77,98.95) 248.77,99.62 v2(248.74,99.65) ; v2(251.47,99.05) 251.47,98.8 251.04,98.37 250.12,98.37 ; 250.12,98.37 v2(250.12,97.51)
  GND6 w0.203: JUSBC1.6 196.72,181.72 ; JUSBC1.6 195.81,181 ; JUSBC1.6 195.81,181.72 ; JUSBC1.6 195.81,180.28 ; JUSBC1.6 197.82,181 ; JUSBC1.6 197.82,181.72 ; JUSBC1.6 197.82,180.28 ; 181.67,89.86 H3.1 ; H3.1 183.3,90.47 ; H3.1 181.67,94.34 ; H3.1 183.3,93.73 ; H3.1 183.91,92.1 ; H3.1 180.04,93.73 ; H3.1 179.43,92.1 ; H3.1 180.04,90.47 ; 13.21,46.1 JUSB1.12 ; JUSB1.12 16.71,46.1 ; JUSB1.12 14.96,45.24 ; JUSB1.12 14.96,46.96 ; JUSB1.12 16.71,45.24 ; JUSB1.12 13.21,45.24 ; JUSB1.12 13.21,46.96 ; JUSB1.12 16.71,46.96 ; JUSBC1.4 197.04,186.97 ; JUSBC1.4 197.87,186.97 ; JUSBC1.4 196.21,184.13 ; JUSBC1.4 197.87,184.13 ; JUSBC1.4 197.87,185.55 ; JUSBC1.4 196.21,186.97 ; JUSBC1.4 197.04,184.13 ; JUSBC1.4 196.21,185.55 ; 145.17,177.95 JCDRA.47 ; JCDRA.47 146.17,177.95 ; JCDRA.47 146.17,179.51 ; JCDRA.47 144.17,181.07 ; JCDRA.47 145.17,181.07 ; JCDRA.47 146.17,181.07 ; JCDRA.47 144.17,179.51 ; JCDRA.47 144.17,177.95 ; H6.1 181.09,9.72 ; H6.1 181.6,8.3 ; H6.1 179.67,10.23 ; H6.1 178.25,6.88 ; H6.1 179.67,6.37 ; H6.1 178.25,9.72 ; H6.1 181.09,6.88 ; H6.1 177.74,8.3 ; JHDMI.20 210.3,173.12 ; JHDMI.20 208.44,173.12 ; JHDMI.20 208.44,175.68 ; JHDMI.20 209.37,175.68 ; JHDMI.20 210.3,174.4 ; JHDMI.20 210.3,175.68 ; JHDMI.20 208.44,174.4 ; JHDMI.20 209.37,173.12 ; JLAN.16 243.69,181.74 ; JLAN.16 242.77,179.99 ; JLAN.16 244.6,178.23 ; JLAN.16 242.77,181.74 ; JLAN.16 244.6,181.74 ; JLAN.16 242.77,178.23 ; JLAN.16 243.69,178.23 ; JLAN.16 244.6,179.99 ; 144.57,171.37 H17.1 ; H17.1 143.15,171.88 ; H17.1 146.5,173.3 ; H17.1 143.15,174.72 ; H17.1 142.64,173.3 ; H17.1 145.99,171.88 ; H17.1 144.57,175.23 ; H17.1 145.99,174.72 ; 224.84,183.85 JHDMI.23 ; JHDMI.23 226.7,185.13 ; JHDMI.23 224.84,185.13 ; JHDMI.23 224.84,182.57 ; JHDMI.23 225.77,182.57 ; JHDMI.23 226.7,182.57 ; JHDMI.23 225.77,185.13 ; JHDMI.23 226.7,183.85 ; JCDRA.50 178.67,185.67 ; JCDRA.50 176.67,185.67 ; JCDRA.50 178.67,182.55 ; JCDRA.50 178.67,184.11 ; JCDRA.50 176.67,182.55 ; JCDRA.50 177.67,185.67 ; JCDRA.50 176.67,184.11 ; JCDRA.50 177.67,182.55 ; H11.1 23.7,14.93 ; H11.1 20.44,14.93 ; H11.1 22.07,11.06 ; H11.1 24.31,13.3 ; H11.1 19.83,13.3 ; H11.1 23.7,11.67 ; H11.1 22.07,15.54 ; H11.1 20.44,11.67 ; JUSBC1.2 189.23,185.55 ; JUSBC1.2 187.57,184.13 ; JUSBC1.2 188.4,186.97 ; JUSBC1.2 188.4,184.13 ; JUSBC1.2 187.57,185.55 ; JUSBC1.2 187.57,186.97 ; JUSBC1.2 189.23,186.97 ; JUSBC1.2 189.23,184.13 ; 237.31,175.95 JDP.19 ; JDP.19 237.77,176.07 ; JDP.19 238.24,175.95 ; JDP.19 237.77,174.91 ; JDP.19 237.31,175.03 ; JDP.19 238.36,175.49 ; JDP.19 238.24,175.03 ; 203.37,52 H4.1 ; H4.1 205.07,47.96 ; H4.1 205.07,52.64 ; H4.1 206.77,52 ; H4.1 203.37,48.6 ; H4.1 207.41,50.3 ; H4.1 206.77,48.6 ; H4.1 202.73,50.3 ; 0.38,56.95 JUSBC2.4 ; JUSBC2.4 3.22,58.61 ; JUSBC2.4 3.22,57.78 ; JUSBC2.4 1.8,58.61 ; JUSBC2.4 0.38,57.78 ; JUSBC2.4 0.38,58.61 ; JUSBC2.4 1.8,56.95 ; JUSBC2.4 3.22,56.95 ; JUSB1.4 17.14,35.61 ; JUSB1.4 17.14,36.79 ; JUSB1.4 16.55,35.44 ; JUSB1.4 16.55,36.96 ; JUSB1.4 15.96,36.79 ; JUSB1.4 15.96,35.61 ; JUSB1.4 15.79,36.2 ; JUSB1.4 17.31,36.2 ; 177.67,177.95 JCDRA.49 ; JCDRA.49 177.67,181.07 ; JCDRA.49 176.67,177.95 ; JCDRA.49 176.67,179.51 ; JCDRA.49 178.67,179.51 ; JCDRA.49 178.67,177.95 ; JCDRA.49 178.67,181.07 ; JCDRA.49 176.67,181.07 ; 202.22,179.97 H14.1 ; H14.1 200.8,180.48 ; H14.1 200.29,181.9 ; H14.1 204.15,181.9 ; H14.1 200.8,183.32 ; H14.1 203.64,183.32 ; H14.1 202.22,183.83 ; H14.1 203.64,180.48 ; H15.1 184.64,183.32 ; H15.1 181.8,180.48 ; H15.1 183.22,183.83 ; H15.1 184.64,180.48 ; H15.1 183.22,179.97 ; H15.1 185.15,181.9 ; H15.1 181.29,181.9 ; H15.1 181.8,183.32 ; JHDMI.22 224.8,173.12 ; JHDMI.22 223.87,173.12 ; JHDMI.22 222.94,173.12 ; JHDMI.22 223.87,175.68 ; JHDMI.22 222.94,175.68 ; JHDMI.22 222.94,174.4 ; JHDMI.22 224.8,175.68 ; JHDMI.22 224.8,174.4 ; 187.62,180.28 JUSBC1.5 ; JUSBC1.5 187.62,181 ; JUSBC1.5 189.63,181.72 ; JUSBC1.5 187.62,181.72 ; JUSBC1.5 189.63,181 ; JUSBC1.5 189.63,180.28 ; JUSBC1.5 188.73,181.72 ; 5.63,57 JUSBC2.6 ; JUSBC2.6 7.07,59.01 ; JUSBC2.6 7.07,57 ; JUSBC2.6 5.63,58.11 ; JUSBC2.6 6.35,57 ; JUSBC2.6 6.35,59.01 ; JUSBC2.6 5.63,59.01 ; 26.65,57.22 H10.1 ; H10.1 29.49,57.22 ; H10.1 28.07,57.73 ; H10.1 28.07,53.87 ; H10.1 30,55.8 ; H10.1 26.14,55.8 ; H10.1 26.65,54.38 ; H10.1 29.49,54.38 ; H22.1 199.29,58.82 ; H22.1 196.45,58.82 ; H22.1 197.87,55.47 ; H22.1 199.8,57.4 ; H22.1 196.45,55.98 ; H22.1 197.87,59.33 ; H22.1 195.94,57.4 ; H22.1 199.29,55.98 ; 215.62,173.97 JHDMI.8 ; JHDMI.8 216.08,174.09 ; JHDMI.8 215.16,174.09 ; JHDMI.8 215.16,175.01 ; JHDMI.8 215.62,175.13 ; JHDMI.8 216.08,175.01 ; 239.8,172.14 JDP.22 ; JDP.22 241.35,174.76 ; JDP.22 240.57,174.76 ; JDP.22 241.35,172.14 ; JDP.22 241.35,173.45 ; JDP.22 239.8,173.45 ; JDP.22 240.57,172.14 ; 5.63,66.1 JUSBC2.5 ; JUSBC2.5 6.35,65.19 ; JUSBC2.5 7.07,65.19 ; JUSBC2.5 6.35,67.2 ; JUSBC2.5 5.63,67.2 ; JUSBC2.5 7.07,67.2 ; JUSBC2.5 5.63,65.19 ; JHDMI.21 207.47,183.88 ; JHDMI.21 208.4,182.6 ; JHDMI.21 208.4,183.88 ; JHDMI.21 206.54,183.88 ; JHDMI.21 207.47,181.32 ; JHDMI.21 206.54,182.6 ; JHDMI.21 206.54,181.32 ; JHDMI.21 208.4,181.32 ; JUSBC1.1 189.18,179.27 ; JUSBC1.1 188.4,179.27 ; JUSBC1.1 188.4,181.73 ; JUSBC1.1 187.62,179.27 ; JUSBC1.1 187.62,180.5 ; JUSBC1.1 187.62,181.73 ; JUSBC1.1 189.18,181.73 ; 5.07,69.67 H8.1 ; H8.1 5.07,73.53 ; H8.1 3.14,71.6 ; H8.1 7,71.6 ; H8.1 6.49,73.02 ; H8.1 6.49,70.18 ; H8.1 3.65,73.02 ; H8.1 3.65,70.18 ; H19.1 94.8,58.7 ; H19.1 94.29,60.12 ; H19.1 91.45,60.12 ; H19.1 94.29,57.28 ; H19.1 90.94,58.7 ; H19.1 92.87,60.63 ; H19.1 92.87,56.77 ; H19.1 91.45,57.28 ; 197.33,156.33 H13.1 ; H13.1 199.57,156.33 ; H13.1 201.81,151.27 ; H13.1 201.81,156.33 ; H13.1 201.81,153.8 ; H13.1 197.33,151.27 ; H13.1 197.33,153.8 ; H13.1 199.57,151.27 ; JHDMI.17 220.58,176.56 ; JHDMI.17 219.66,175.64 ; JHDMI.17 220.12,176.68 ; JHDMI.17 219.66,176.56 ; JHDMI.17 220.58,175.64 ; JHDMI.17 220.12,175.52 ; JUSBC2.3 8.08,57.78 ; JUSBC2.3 8.08,58.56 ; JUSBC2.3 6.85,57 ; JUSBC2.3 8.08,57 ; JUSBC2.3 5.62,58.56 ; JUSBC2.3 5.62,57 ; JUSBC2.3 5.62,57.78 ; JHDMI.2 212.62,175.13 ; JHDMI.2 212.62,173.97 ; JHDMI.2 213.08,175.01 ; JHDMI.2 213.08,174.09 ; JHDMI.2 212.04,174.55 ; JHDMI.2 212.16,175.01 ; JHDMI.2 212.16,174.09 ; JCDRA.48 146.17,182.55 ; JCDRA.48 144.17,185.67 ; JCDRA.48 146.17,185.67 ; JCDRA.48 144.17,184.11 ; JCDRA.48 146.17,184.11 ; JCDRA.48 145.17,182.55 ; JCDRA.48 144.17,182.55 ; JCDRA.48 145.17,185.67 ; 100.65,9.72 H18.1 ; H18.1 102.07,10.23 ; H18.1 103.49,9.72 ; H18.1 100.14,8.3 ; H18.1 103.49,6.88 ; H18.1 102.07,6.37 ; H18.1 100.65,6.88 ; H18.1 104,8.3 ; H12.1 277.59,170.98 ; H12.1 274.75,173.82 ; H12.1 276.17,170.47 ; H12.1 274.75,170.98 ; H12.1 278.1,172.4 ; H12.1 274.24,172.4 ; H12.1 276.17,174.33 ; H12.1 277.59,173.82 ; H2.1 124.37,94.4 ; H2.1 120.97,91 ; H2.1 120.33,92.7 ; H2.1 122.67,95.04 ; H2.1 120.97,94.4 ; H2.1 122.67,90.36 ; H2.1 124.37,91 ; H2.1 125.01,92.7 ; JDP.24 230.35,172.14 ; JDP.24 228.8,172.14 ; JDP.24 228.8,174.76 ; JDP.24 229.57,172.14 ; JDP.24 228.8,173.45 ; JDP.24 229.57,174.76 ; JDP.24 230.35,173.45 ; JUSBC2.1 8.08,65.64 ; JUSBC2.1 6.85,67.2 ; JUSBC2.1 5.62,65.64 ; JUSBC2.1 8.08,67.2 ; JUSBC2.1 5.62,67.2 ; JUSBC2.1 5.62,66.42 ; JUSBC2.1 8.08,66.42 ; 142.63,157.4 H1.1 ; H1.1 147.31,157.4 ; H1.1 143.27,159.1 ; H1.1 146.67,155.7 ; H1.1 143.27,155.7 ; H1.1 146.67,159.1 ; H1.1 144.97,159.74 ; H1.1 144.97,155.06 ; H20.1 297.87,79.98 ; H20.1 296.45,79.47 ; H20.1 295.94,78.05 ; H20.1 297.87,76.12 ; H20.1 299.29,76.63 ; H20.1 299.8,78.05 ; H20.1 296.45,76.63 ; H20.1 299.29,79.47 ; 274.37,47 H5.1 ; H5.1 273.73,45.3 ; H5.1 278.41,45.3 ; H5.1 277.77,43.6 ; H5.1 277.77,47 ; H5.1 276.07,47.64 ; H5.1 274.37,43.6 ; H5.1 276.07,42.96 ; JDP.23 230.35,179.76 ; JDP.23 229.57,177.14 ; JDP.23 228.8,179.76 ; JDP.23 228.8,178.45 ; JDP.23 229.57,179.76 ; JDP.23 230.35,178.45 ; JDP.23 228.8,177.14 ; JDP.23 230.35,177.14 ; 216.66,175.64 JHDMI.11 ; JHDMI.11 217.58,176.56 ; JHDMI.11 217.12,176.68 ; JHDMI.11 217.12,175.52 ; JHDMI.11 216.66,176.56 ; JHDMI.11 217.58,175.64 ; 262.74,178.23 JLAN.14 ; JLAN.14 263.65,178.23 ; JLAN.14 261.82,178.23 ; JLAN.14 261.82,179.99 ; JLAN.14 263.65,181.74 ; JLAN.14 263.65,179.99 ; JLAN.14 262.74,181.74 ; JLAN.14 261.82,181.74 ; 0.38,66.42 JUSBC2.2 ; JUSBC2.2 1.8,67.25 ; JUSBC2.2 0.38,65.59 ; JUSBC2.2 3.22,66.42 ; JUSBC2.2 3.22,67.25 ; JUSBC2.2 3.22,65.59 ; JUSBC2.2 0.38,67.25 ; JUSBC2.2 1.8,65.59 ; H9.1 6.57,54.53 ; H9.1 4.64,52.6 ; H9.1 7.99,51.18 ; H9.1 5.15,51.18 ; H9.1 8.5,52.6 ; H9.1 5.15,54.02 ; H9.1 6.57,50.67 ; H9.1 7.99,54.02 ; 213.66,175.64 JHDMI.5 ; JHDMI.5 214.58,175.64 ; JHDMI.5 214.12,175.52 ; JHDMI.5 214.58,176.56 ; JHDMI.5 213.66,176.56 ; JHDMI.5 214.12,176.68 ; 265.49,8.3 H23.1 ; H23.1 267.97,10.54 ; H23.1 265.49,10.54 ; H23.1 270.45,10.54 ; H23.1 267.97,6.06 ; H23.1 265.49,6.06 ; H23.1 270.45,8.3 ; H23.1 270.45,6.06 ; 239.8,179.76 JDP.21 ; JDP.21 240.57,177.14 ; JDP.21 240.57,179.76 ; JDP.21 241.35,179.76 ; JDP.21 241.35,178.45 ; JDP.21 241.35,177.14 ; JDP.21 239.8,177.14 ; JDP.21 239.8,178.45 ; H21.1 263.49,6.88 ; H21.1 263.49,9.72 ; H21.1 260.65,6.88 ; H21.1 262.07,6.37 ; H21.1 260.65,9.72 ; H21.1 262.07,10.23 ; H21.1 260.14,8.3 ; H21.1 264,8.3 ; 196.27,181.73 JUSBC1.3 ; JUSBC1.3 197.04,181.73 ; JUSBC1.3 196.27,179.27 ; JUSBC1.3 197.04,179.27 ; JUSBC1.3 197.82,180.5 ; JUSBC1.3 197.82,181.73 ; JUSBC1.3 197.82,179.27 ; 14.46,39.11 JUSB1.7 ; JUSB1.7 14.46,40.29 ; JUSB1.7 15.05,38.94 ; JUSB1.7 15.64,39.11 ; JUSB1.7 15.81,39.7 ; JUSB1.7 15.64,40.29 ; JUSB1.7 15.05,40.46 ; JUSB1.7 14.29,39.7 ; 234.07,173.71 JDP.7 ; JDP.7 234.54,173.83 ; JDP.7 233.61,173.83 ; JDP.7 234.66,174.29 ; JDP.7 234.07,174.87 ; JDP.7 234.54,174.75 ; JDP.7 233.61,174.75 ; 235.61,173.83 JDP.13 ; JDP.13 236.54,173.83 ; JDP.13 236.07,173.71 ; JDP.13 235.61,174.75 ; JDP.13 236.07,174.87 ; JDP.13 235.49,174.29 ; JDP.13 236.54,174.75 ; H7.1 269.07,154.64 ; H7.1 269.07,149.96 ; H7.1 267.37,154 ; H7.1 270.77,154 ; H7.1 267.37,150.6 ; H7.1 266.73,152.3 ; H7.1 271.41,152.3 ; H7.1 270.77,150.6 ; JDP.1 232.84,175.95 ; JDP.1 232.37,174.91 ; JDP.1 231.91,175.95 ; JDP.1 231.79,175.49 ; JDP.1 232.84,175.03 ; JDP.1 231.91,175.03 ; JDP.1 232.37,176.07 ; 13.21,34.16 JUSB1.11 ; JUSB1.11 16.71,32.44 ; JUSB1.11 14.96,32.44 ; JUSB1.11 14.96,34.16 ; JUSB1.11 13.21,33.3 ; JUSB1.11 16.71,34.16 ; JUSB1.11 13.21,32.44 ; JUSB1.11 16.71,33.3 ; 22.07,4.07 H16.1 ; H16.1 20.65,4.58 ; H16.1 20.65,7.42 ; H16.1 20.14,6 ; H16.1 22.07,7.93 ; H16.1 23.49,7.42 ; H16.1 24,6 ; H16.1 23.49,4.58 ; 117.97,156.56 JPCMC.36 ; JPCMC.36 122.25,158.36 ; JPCMC.36 119.77,155.88 ; JPCMC.36 117.97,160.16 ; JPCMC.36 121.57,156.56 ; JPCMC.36 119.77,160.84 ; JUSB1.13 7.71,31.8 ; JUSB1.13 7.71,30.94 ; JUSB1.13 6.2,30.94 ; JUSB1.13 4.69,30.94 ; JUSB1.13 4.69,31.8 ; JUSB1.14 7.71,48.46 ; JUSB1.14 4.69,47.6 ; JUSB1.14 4.69,48.46 ; JUSB1.14 6.2,48.46 ; JUSB1.14 7.71,47.6
  BOTTOM w0.076: UC1.BL33 135.81,118.76 v2(136.13,119.08) ; UC1.BM33 134.96,118.44 v2(134.63,118.77) ; UC1.BJ33 136.59,118.76 v2(136.92,119.08) ; v2(131.33,112.04) 131.7,112.04 132.13,112.46 132.61,112.46 UC1.BR25 ; v2(137.42,104.57) 137.38,104.57 137.05,104.24 UC1.BJ14
  BOTTOM w0.089: UH1.AP4 209.89,39.61 209.89,40.25 209.77,40.37 209.77,40.63 209.97,40.83 v2(209.97,41.78)
  BOTTOM w0.1: v2(256.27,88.1) 256.49,88.1 v2(257.11,88.72)
  BOTTOM w0.102: v2(256.97,110.76) 256.97,110.4 256.6,110.03 256.6,109.04 255.24,107.68 254.04,107.68 UG9.AU51 ; 257.09,107.78 257.09,108.38 257.43,108.72 257.43,109.37 257.8,109.74 257.8,111.53 v2(257.68,111.65) ; v2(256.87,92.35) 255.96,91.44 254.96,91.44 254.84,91.32 254.5,91.32 254.17,91.65 UG9.P51
  BOTTOM w0.127: UC1.B37 172.63,121.29 172.84,121.08 173.37,121.08 v2(173.41,121.03) ; 198.61,20.98 198.88,20.71 198.88,19.79 198.67,19.58 198.28,19.58 198.04,19.34 UH1.J46 197.9,18.95 UH1.J47 ; 198.61,20.98 198.23,21.35 ; 198.61,20.98 198.61,21 199.1,21.5 199.57,21.5 v2(200.07,21) ; UH1.K39 198.23,22.19 198.23,21.35 ; 198.23,21.35 197.84,21.35 197.48,20.99 197.48,20.74 197.3,20.56 197.05,20.56 196.87,20.38 UH1.G44 ; UG9.W10 v2(225.97,95.15)
  BOTTOM w0.13: v2(250.12,97.51) 250.38,97.25 UG9.AB47
  BOTTOM w0.15: v2(247.67,93.05) UG9.T43 UG9.T45 ; v2(215.07,102.85) 216.01,101.91 218.65,101.91 218.76,101.8 219.12,101.8 219.47,102.15 UG9.AJ2 ; 219.32,85 v2(219.37,85.05) ; v2(225.97,99.35) UG9.AE10 ; v2(251.47,99.05) UG9.AE47 v2(251.47,99.65) ; v2(250.13,93.38) 250.46,93.05 UG9.T47 ; UG9.AB8 223.97,97.25 v2(224.27,97.55) ; UG9.AB8 v2(223.53,96.91) ; UG9.AB8 v2(223.57,97.55) ; UG9.BC22 v2(233.67,111.25) ; UG9.AP47 250.49,105.65 ; v2(250.07,101.75) 250.52,101.3 v2(250.74,101.3) ; UG9.AB10 v2(225.97,97.25) ; v2(251.54,94.83) 251.22,95.15 UG9.W47 ; v2(215.71,85.05) 216.16,84.6 217.19,84.6 v2(217.64,85.05) 218.08,84.6 218.34,84.6 218.38,84.64 218.38,84.64 218.62,84.87 218.62,84.88 218.74,85 ; UG9.K40 v2(246.27,89.55) ; UG9.W43 v2(247.67,95.15) ; UG9.BC19 v2(231.57,111.25) ; v2(248.7,101.15) 248.99,101.45 UG9.AH45 ; 254.32,85 254.33,85.01 255.96,85.01 ; UG9.AP43 v2(247.67,105.65) ; UG9.BC37 v2(244.17,111.25) ; v2(225.97,90.95) UG9.N10 ; v2(229.67,88.3) 229.67,88.65 UG9.K16 v2(229.47,89.55) ; UG9.AP10 v2(225.97,105.65) ; v2(251.47,105.35) 251.77,105.65 UG9.AP49 ; UG9.AH47 251.87,101.45 v2(251.99,101.33) ; v2(227.37,89.55) UG9.K13 ; v2(255.32,86.05) 255.48,85.89 257.25,85.89 v2(257.49,85.65) 258.17,85.65 v2(258.21,85.69) ; v2(239.97,89.55) UG9.K31 239.97,88.15 v2(240.22,87.9) ; v2(225.97,93.05) UG9.T10 225.07,93.25 v2(224.77,93.25) ; v2(250.07,91.25) UG9.N45 249.98,90.74 v2(250.31,90.74) ; v2(256.93,106.31) 256.93,106.48 256.66,106.75 256.13,106.75 255.81,106.43 v2(255.81,106.38) ; v2(248.77,103.15) UG9.AL43 v2(247.67,103.55) ; UG9.K28 v2(237.87,89.55) ; UG9.AU47 v2(251.47,107.45) ; UG9.AU47 v2(251.47,108.05) 251.77,107.75 UG9.AU49 ; UG9.AU47 UG9.AU45 ; UG9.AH43 v2(247.67,101.45) ; UG9.N43 v2(247.67,90.95) ; v2(236.07,87.15) UG9.H25 v2(235.47,87.75) ; v2(249.46,94.86) 249.48,94.86 UG9.W45 250.03,95.41 v2(250.2,95.41) ; UG9.BC28 v2(237.87,111.25) ; v2(253.52,105.7) 253.42,105.8 v2(252.98,105.8) ; UG9.BC16 v2(229.47,111.25) ; UG9.BC31 v2(239.97,111.25) ; v2(218.47,86.7) 218.27,86.5 218.27,86.42 218.06,86.21 217.46,86.21 217.27,86.4 v2(217.27,86.64) ; UG9.K34 v2(242.07,89.55) ; UG9.BC13 v2(227.37,111.25) ; v2(247.67,97.25) UG9.AB43 ; v2(249.32,99.17) 249.59,99.17 UG9.AE45 ; v2(255.15,107.05) 255.45,107.05 256.18,107.78 257.09,107.78 v2(257.54,107.33) ; v2(252.87,110.15) v2(253.67,110.15) ; v2(235.77,89.55) UG9.K25 ; v2(215.41,100.09) 215.41,100.19 216.55,101.33 219.55,101.33 UG9.AH2 ; v2(229.57,83.68) 229.81,83.91 229.81,84.31 UG9.D16 ; UG9.AL10 v2(225.97,103.55) ; v2(233.67,89.55) UG9.K22 ; UG9.AE43 v2(247.67,99.35) ; UG9.BC34 v2(242.07,111.25) ; UG9.AV45 v2(249.35,108.03) ; UG9.AU10 v2(225.97,107.75) ; UG9.K19 v2(231.57,89.55) ; UG9.K37 v2(244.17,89.55) ; UG9.AW52 v2(254.97,109.45)
  BOTTOM w0.152: UH1.P46 200.14,19.34 200.48,19.68 200.48,20.62 200.1,21 v2(200.07,21) ; UH1.AD49 205.2,17.72 v2(206.34,17.72) 206.62,17.72 UH1.AG49 ; v2(200.75,17.38) 200.95,17.59 UH1.T49 ; v2(208.94,41.84) UH1.AM1 ; UH1.E13 195.49,35.61 UH1.D12 194.84,35.61 UH1.C12 194.39,35.33 194.17,35.33 v2(193.56,34.73) ; UH1.BG28 216.71,27.72 v2(216.85,27.59) ; UH1.BG25 216.69,29.71 v2(216.86,29.71) ; v2(217.51,22.99) 217.17,23.33 UH1.BG37 ; UH1.AG1 206.75,42.64 v2(206.66,42.73) ; UH1.J48 197.95,18.4 197.79,18.55 UH1.J47 ; UH1.C48 194.99,17.91 195.58,17.91 UH1.F47 ; v2(218.96,33.46) 218.82,33.32 218.29,33.32 218.27,33.33 218.27,33.33 217.95,33.65 216.75,33.65 UH1.BG17 ; v2(211.61,43.31) 211.61,43.13 211.17,42.69 UH1.AT1 ; v2(193.05,27.87) 193.05,27.87 193.05,27.87 193.05,27.87 193.31,27.61 193.64,27.61 UH1.A28 ; UH1.AD2 UH1.AD1 205.07,41.69 v2(204.99,41.77) ; UH1.AM49 208.94,17.69 208.75,17.88 208.75,18.88 208.48,19.15 v2(208.3,19.15) ; UH1.A37 193.52,23.33 193.34,23.51 v2(193.34,23.56) ; UH1.BG22 216.64,31.08 v2(216.82,30.9) ; UH1.A33 193.75,25.64 193.53,25.86 v2(193.34,25.86) ; UG9.AH10 v2(225.97,101.45) ; v2(195.21,29.2) 195.01,29.4 UH1.C25 ; UC1.G28 169.08,115.21 168.77,114.89 168.77,114.8 168.76,114.8 168.76,114.53 168.77,114.19 UC1.G26 ; v2(217.27,86.64) 218.08,87.45 UG9.H1 ; UH1.BG33 216.74,25.53 v2(216.83,25.61) ; 207.01,26.69 UH1.AJ31
  BOTTOM w0.178: v2(180,169.51) 180.02,169.51 CT83.2
  BOTTOM w0.2: UG9.BJ16 UG9.BJ17 UG9.BJ18 UG9.BH18 ; UG9.AU45 249.47,107.45 v2(249.42,107.45) ; UG9.BH21 UG9.BJ21 UG9.BJ20 UG9.BJ19 ; UG9.BJ13 UG9.BJ14 UG9.BJ15 UG9.BH15 ; 255.96,85.01 256.52,84.45 258.59,84.45 260.37,86.23 v2(261.12,86.23) ; v2(253.47,92.95) 253.17,92.95 v2(252.87,92.65) ; UG9.BH24 UG9.BJ24 UG9.BJ23 UG9.BJ22 ; v2(252.02,93.25) 252.02,93.2 v2(251.57,92.75) ; UG9.BJ28 UG9.BJ29 UG9.BJ30 UG9.BH30 ; v2(248.83,107.51) v2(249.35,108.03) ; UG9.BJ39 UG9.BJ40 ; UG9.BJ39 UG9.BH39 ; UG9.BJ39 UG9.BJ38 UG9.BJ37 ; UG9.BH27 UG9.BJ27 UG9.BJ26 UG9.BJ25 ; 250.49,105.65 250.43,105.65 v2(250.24,105.85) 249.97,105.85 UG9.AP45 ; 254.32,85 v2(254.27,85.05) ; UG9.BH33 UG9.BJ33 UG9.BJ32 UG9.BJ31 ; UG9.BH36 UG9.BJ36 UG9.BJ35 UG9.BJ34
  BOTTOM w0.203: UC1.BT32 131.6,118.31 v2(131.57,118.34) ; UC1.BH5 137.22,98.08 137.26,98.12 137.26,98.5 137.22,98.54 UC1.BH6 ; UC1.BH5 137.08,97.99 v2(136.8,98.26) ; UC1.BH5 UC1.BH4 UC1.BH3 UC1.BH2 136.97,95.78 UC1.BH1 136.97,94.83 v2(137.18,94.62) ; UC1.BC34 141.32,119.41 v2(141.64,119.73) ; v2(155.81,118.43) UC1.AE33 UC1.AE34 ; UG12.11 196.66,111.21 196.69,111.18 196.69,110.48 CG64.2 ; UC1.BN19 134.31,108.2 v2(133.98,108.53) 133.98,108.6 UC1.BN20 134.31,108.99 v2(134,109.3) ; v2(188.64,53.93) 188.69,53.98 188.7,53.98 188.7,53.99 188.73,53.99 188.73,53.97 188.78,53.97 UG31.11 ; UC1.T11 162.28,101.9 v2(162.56,101.62) 162.18,101.25 UC1.T10 ; UC1.T11 UC1.T10 ; UC1.T11 UC1.T12 ; v2(144.32,95.71) 144.32,95.68 144.62,95.39 UC1.AW1 UC1.AW2 144.8,96.07 144.8,96.65 UC1.AW3 ; UC1.K3 UC1.K2 UC1.K1 ; UC1.K3 167.4,96.81 167.41,96.82 167.41,97.2 167.4,97.21 UC1.K4 ; UC1.K3 167.25,96.69 v2(166.89,96.32) ; UG9.B16 229.47,83.58 v2(229.57,83.68) ; 135.99,103.73 135.93,103.73 UC1.BL13 135.28,103.09 v2(135.28,103.02) 135.28,102.95 UC1.BM12 134.96,102.58 134.63,102.26 ; 135.99,103.73 136.26,103.99 UC1.BK14 ; 135.99,103.73 136.26,103.47 UC1.BK13 136.26,102.99 v2(136.09,102.82) ; v2(154.33,101.62) 154.24,101.62 UC1.AG10 ; UC1.T10 162.35,100.99 162.48,100.99 ; UC1.T10 UC1.T9 ; UC1.AC4 157.34,97.51 157.35,97.52 157.35,97.85 157.34,97.86 UC1.AC5 157.34,98.11 157.35,98.12 157.35,98.5 157.34,98.52 UC1.AC6 UC1.AB6 158.48,98.94 158.58,98.94 158.69,99.05 159.1,99.05 UC1.Y7 UC1.Y8 UC1.Y9 UC1.Y10 ; UC1.AC4 157.19,97.34 v2(156.88,97.03) ; UC1.AC4 UC1.AC3 UC1.AC2 157.34,95.99 157.33,95.99 157.34,95.86 UC1.AC1 v2(157.34,94.84) ; UC1.BB3 142.34,96.6 142.34,96.12 UC1.BB2 142.25,95.9 142.29,95.85 142.29,95.57 142.25,95.52 UC1.BB1 142.3,95.34 142.3,94.85 v2(141.9,94.45) ; UC1.BB3 142.25,96.81 142.32,96.87 142.32,97.15 142.25,97.21 UC1.BB4 142.25,97.46 142.32,97.52 142.32,97.8 142.25,97.86 UC1.BB5 ; UC1.BB3 142.15,96.69 141.87,96.41 v2(141.87,96.36) ; v2(137.86,100.99) 137.6,101.25 UC1.BH10 ; UC1.BA12 143.06,102.55 v2(143.35,102.26) 143.64,102.55 UC1.AY12 ; UC1.BA12 142.76,102.55 v2(142.43,102.87) 142.3,102.87 UC1.BB12 141.71,102.82 v2(141.52,102.82) ; UC1.BA12 UC1.BA11 ; UC1.BA12 143.24,102.89 v2(143.35,102.89) 143.46,102.89 UC1.AY12 ; UC1.A30 173.38,117.23 173.74,117.59 v2(174,117.59) ; UC1.T12 161.83,102.81 161.58,102.81 161.31,102.55 UC1.V12 160.92,102.81 160.53,102.81 UC1.W12 ; UC1.T12 162.26,102.55 v2(162.55,102.26) 162.84,102.55 UC1.R12 163.27,102.81 163.66,102.81 UC1.P12 164.18,102.81 164.58,102.81 UC1.N12 ; UC1.T12 UC1.T13 161.95,103.2 v2(161.65,103.5) 162,103.85 UC1.T14 ; UC1.AD10 UC1.AD11 ; UC1.AD10 156.98,101.62 v2(157.07,101.62) 157.06,101.63 v2(157.06,102.26) ; UC1.AD10 UC1.AD9 ; UC1.AD11 UC1.AD12 156.78,102.55 v2(157.06,102.26) ; UC1.AD11 156.7,101.9 v2(157.06,102.26) ; v2(161.33,177.28) 161.33,177.29 161.42,177.38 JCDRA.23 ; UC1.BD7 UC1.BD8 ; UC1.BD7 140.25,99.3 140.61,99.65 v2(140.61,100.35) ; UC1.BD7 140.15,98.9 140.16,98.89 ; UC1.BD8 UC1.BD9 ; UC1.BD8 140.2,99.95 v2(140.61,100.35) ; v2(242.24,36.54) 242.67,36.11 242.67,35.71 242.87,35.51 PU8200.10 ; UC1.K4 167.4,97.46 167.41,97.47 167.41,97.85 167.4,97.86 UC1.K5 167.07,98.31 v2(166.96,98.31) ; UC1.K4 UC1.J4 168.56,97.66 168.64,97.66 ; UC1.G20 169.08,109.09 v2(169.41,108.76) 169.73,108.44 UC1.F19 ; UC1.D38 170.89,122.22 171.3,122.64 171.5,122.64 v2(171.78,122.92) ; v2(135.27,110.1) 135.27,110.03 UC1.BM21 134.88,109.71 134.83,109.65 134.51,109.65 134.45,109.71 UC1.BN21 134.31,109.6 v2(134,109.3) ; UC1.BH12 137.58,102.55 v2(137.86,102.26) 138.15,102.55 UC1.BG12 UC1.BG13 ; UC1.BH12 137.27,102.55 v2(136.95,102.22) 136.58,102.59 UC1.BJ12 ; UC1.BH12 UC1.BH11 ; JCDRA.8 v2(155.42,178.25) ; UC1.BP33 133.91,118.12 133.91,117.98 UC1.BN31 134.62,117.27 v2(134.62,117.22) 134.62,117.11 UC1.BN30 ; v2(170.06,100.1) 169.73,99.77 UC1.F8 UC1.G8 168.66,99.28 UC1.J7 ; v2(170.06,100.1) 170.38,100.42 UC1.E9 ; v2(170.06,100.1) 169.73,100.42 UC1.F9 169.73,100.56 v2(169.41,100.89) ; UC1.AP9 148.59,100.6 v2(148.83,100.35) ; UC1.BM6 134.84,98.64 UC1.BL6 UC1.BK6 136.38,98.59 136.71,98.26 v2(136.8,98.26) ; UC1.BM6 134.75,98.01 UC1.BM5 ; UC1.BM6 134.75,98.56 v2(134.38,98.94) 134.38,99.4 UC1.BN7 ; v2(136.8,98.26) 136.85,98.26 UC1.BH6 ; UH1.U33 202.41,25.27 v2(202.51,25.37) 202.51,25.37 UH1.Y33 ; UC1.AR38 147.62,122.01 v2(147.94,122.34) ; UC1.BJ32 136.45,118.11 v2(136.13,118.43) ; UC1.AM4 149.8,97.21 149.82,97.18 149.82,96.84 149.8,96.81 UC1.AM3 UC1.AM2 UC1.AM1 v2(149.8,94.84) ; UC1.BN24 134.63,111.75 v2(134.63,111.68) 134.96,111.35 UC1.BM23 ; JCDRA.41 v2(168.62,178.17) ; UC1.BT26 132.29,113.71 132.04,113.71 131.9,113.85 131.87,113.85 v2(131.76,113.96) ; UC1.BG13 138.67,102.85 v2(138.82,102.85) 139.12,102.55 UC1.BF12 ; UC1.BG13 UC1.BG14 ; v2(131.78,97.21) 131.91,97.34 132.29,97.34 UC1.BT4 ; v2(141.87,98.31) 141.87,98.28 142.17,97.99 UC1.BB5 ; v2(141.87,98.31) 141.55,98.64 UC1.BC6 UC1.BD6 ; v2(141.87,98.31) 142.2,98.64 UC1.BB6 ; v2(148.83,100.99) v2(148.84,101.62) 148.84,102.26 v2(148.83,102.26) ; v2(148.83,100.99) v2(148.83,100.35) ; v2(148.83,100.99) 148.58,101.25 UC1.AP10 ; 168.64,97.66 168.97,97.34 UC1.G4 UC1.F4 ; 168.64,97.66 168.97,97.99 UC1.G5 ; UC1.BH10 UC1.BH11 ; UC1.BH10 UC1.BH9 ; UC1.A34 173.08,119.75 v2(173.62,119.75) ; v2(143.35,100.35) v2(143.35,100.99) 143.09,101.25 UC1.BA10 ; v2(143.35,100.35) 142.94,99.95 UC1.BA8 ; v2(143.35,100.35) 143.1,100.6 UC1.BA9 ; UC1.AN12 148.93,102.91 v2(148.85,102.91) 148.74,102.91 UC1.AP12 ; UC1.AN12 149.12,102.55 v2(148.83,102.26) ; UC1.AN12 149.55,102.81 149.95,102.81 UC1.AM12 150.47,102.81 150.86,102.81 UC1.AL12 ; v2(148.83,102.26) 148.74,102.26 UC1.AP11 ; v2(148.83,102.26) 148.55,102.55 UC1.AP12 ; UC1.D16 171.28,105.75 171.28,105.61 UC1.C15 172.01,104.89 v2(172.01,104.82) ; UC1.F5 169.18,98.13 UC1.G5 ; UC1.BD10 UC1.BD9 ; UC1.BD10 140.35,101.25 v2(140.61,100.99) ; UC1.BD10 UC1.BD11 ; UC1.BD9 140.36,100.6 v2(140.61,100.35) ; 171.28,100.89 171.28,101.03 UC1.D10 ; 171.28,100.89 UC1.D9 ; 171.28,100.89 UC1.C9 171.68,100.42 v2(172.01,100.1) ; JCDRA.5 v2(154.22,178.25) ; v2(134,109.3) 133.66,109.64 UC1.BP21 UC1.BR21 UC1.BT21 v2(131.58,109.71) ; UC1.BG37 138.16,121.36 v2(138.49,121.04) ; UC1.W3 159.74,96.69 159.41,96.36 v2(159.41,96.39) ; UC1.W3 159.89,96.65 159.89,96.07 UC1.W2 159.85,95.91 159.85,95.69 UC1.W1 159.85,94.67 v2(159.41,94.3) ; UC1.W3 UC1.W4 UC1.W5 160.25,98.39 160.44,98.39 UC1.V6 UC1.U6 161.84,98.95 161.84,99.05 UC1.T7 UC1.T8 UC1.T9 ; JCDRA.20 160.22,178.13 v2(160.22,178.12) ; v2(168.42,118.43) 168.73,118.11 UC1.H32 169.07,117.84 169.7,117.84 UC1.F31 ; v2(168.42,118.43) 168.1,118.11 UC1.J32 ; v2(168.42,118.43) 168.08,118.76 UC1.J33 ; JCDRA.17 159.02,178.23 v2(158.97,178.18) ; v2(164.41,96.38) 164.46,96.38 164.77,96.69 UC1.N3 ; UC1.N6 UC1.M6 ; UC1.N6 UC1.P6 ; UC1.N6 164.88,98.99 164.84,99.04 UC1.N7 UC1.N8 ; UC1.N6 164.92,98.6 164.92,98.03 UC1.N5 UC1.N4 UC1.N3 ; v2(157.06,102.26) 157.35,102.55 UC1.AC12 157.78,102.81 158.18,102.81 UC1.AA12 ; v2(129.98,98.53) 130.22,98.53 130.72,99.03 130.93,99.03 131,99.1 131.13,99.1 131.59,99.56 132.08,99.56 132.14,99.5 132.84,99.5 132.87,99.47 UC1.BR7 UC1.BP7 UC1.BN7 ; v2(171.35,117.47) 171.35,117.37 171.03,117.05 UC1.D30 ; UC1.BN34 134.31,119.09 v2(133.98,118.77) 133.98,118.83 UC1.BP34 UC1.BR34 ; UC1.A6 172.98,98.93 172.54,98.49 172.18,98.49 171.82,98.13 UC1.C5 171.19,97.64 v2(170.85,97.64) ; UC1.AL8 151.17,99.95 v2(151.58,100.35) v2(151.58,100.99) ; UC1.AL8 UC1.AL7 151.43,98.99 151.62,98.99 151.72,98.89 152.06,98.89 UC1.AJ6 UC1.AH6 UC1.AG6 154.24,98.89 v2(154.4,98.89) ; UC1.AL8 UC1.AL9 ; UC1.AC37 v2(157.39,121.04) ; UC1.AY12 143.9,102.55 v2(144.27,102.91) 144.37,102.91 144.72,102.56 UC1.AW12 145.05,102.88 v2(145.2,102.88) 145.53,102.55 UC1.AU12 ; UC1.BH11 137.59,101.9 v2(137.87,101.62) ; UC1.AR13 147.79,103.52 v2(147.92,103.52) 147.6,103.85 UC1.AR14 147.33,103.85 v2(147.01,103.52) ; UC1.AR13 147.13,102.87 v2(147.02,102.87) ; UC1.AR13 147.78,102.88 v2(147.92,102.88) 148.05,102.88 UC1.AP12 ; v2(151.88,121.04) 152.2,121.36 UC1.AJ37 152.27,121.43 152.21,121.5 152.21,121.87 152.27,121.94 UC1.AJ38 ; UC1.BM27 135.28,114.76 v2(135.28,114.83) 134.96,115.15 UC1.BM28 UC1.BM29 ; v2(224.87,101.85) UG9.AH10 225.12,101.3 v2(224.82,101.3) ; UC1.AM5 149.73,97.99 v2(149.4,97.66) 149.23,97.66 UC1.AN5 148.91,98.59 UC1.AN6 148.96,99.02 148.82,99.16 148.82,99.51 UC1.AP8 148.43,99.95 v2(148.83,100.35) ; UC1.BE3 139.74,96.81 139.75,96.82 139.75,97.2 139.74,97.21 UC1.BE4 139.74,97.46 139.75,97.47 139.75,97.85 139.74,97.86 UC1.BE5 ; UC1.BE3 139.32,96.27 v2(139.28,96.27) ; UC1.BE3 139.74,96.56 139.75,96.55 139.75,96.17 139.74,96.16 UC1.BE2 UC1.BE1 139.74,94.87 v2(139.29,94.43) ; v2(156.51,177.63) 156.62,177.73 JCDRA.11 ; UC1.AB34 v2(158.18,119.08) UC1.AB33 ; v2(172.02,115.82) 172.02,115.83 172.02,115.94 171.72,116.24 UC1.C29 ; UC1.AT6 146.03,99.05 145.89,99.05 UC1.AU7 ; UC1.BE5 139.6,98.13 139.6,98.5 UC1.BE6 ; UC1.BE5 139.82,97.99 140.13,98.3 v2(140.13,98.31) 140.46,98.64 UC1.BD6 ; UC1.BD38 140.52,122.01 v2(140.85,121.69) 140.53,121.36 UC1.BD37 ; UC1.BA9 UC1.BA10 ; UC1.BA9 UC1.BA8 ; UC1.BF34 138.95,119.41 v2(139.28,119.08) 138.96,118.76 UC1.BF33 ; UC1.AH12 153.1,102.55 v2(153.41,102.86) ; UC1.BE6 UC1.BF6 UC1.BG6 UC1.BH6 ; UC1.BE6 139.99,98.89 140.16,98.89 ; v2(169.42,112.71) 169.42,112.78 UC1.F25 ; v2(172.01,106.4) 172.01,106.47 UC1.C17 171.37,107.1 171.37,107.24 UC1.D18 ; UC1.N3 UC1.N2 UC1.N1 164.88,95.25 164.89,95.25 164.89,94.67 164.88,94.67 v2(164.88,94.61) ; UC1.Y14 159.45,103.85 v2(159.78,103.52) 159.45,103.2 UC1.Y13 ; v2(172.01,100.1) 172.17,100.26 172.17,100.33 UC1.B9 UC1.A9 ; v2(172.01,100.1) 172.01,100.03 UC1.C8 UC1.D6 ; UC1.L29 UC1.L30 ; UH1.C4 194.48,39.63 v2(194.17,39.56) ; v2(156.13,100.34) 156.39,100.6 UC1.AD9 ; 134.63,102.26 134.31,102.58 UC1.BN12 ; 134.63,102.26 134.96,101.93 UC1.BM11 134.96,101.77 134.63,101.44 134.96,101.12 UC1.BM9 134.71,100.8 134.71,100.51 UC1.BM8 134.71,100.01 134.71,99.73 UC1.BM7 UC1.BN7 ; UC1.H25 UC1.J25 167.44,113.09 167.16,113.37 v2(167.16,113.54) ; 164.45,119.08 164.84,118.76 UC1.N33 ; 164.45,119.08 v2(164.44,119.08) ; 164.45,119.08 164.84,119.41 UC1.N34 ; v2(173.47,113.82) 173.41,113.88 UC1.A26 ; UC1.G26 169.08,113.91 v2(169.42,114.25) 169.42,114.43 169.66,114.66 UC1.F27 ; UC1.BN12 134.26,102.57 134.18,102.57 134.17,102.56 133.79,102.56 133.78,102.57 133.71,102.57 UC1.BP12 133.53,102.62 133.5,102.6 133.16,102.6 133.14,102.62 UC1.BR12 UC1.BT12 132.21,102.77 v2(131.06,102.77) ; UC1.BN12 134.63,102.94 v2(134.63,103.01) 134.96,103.34 UC1.BM13 ; v2(187.07,169.02) 186.71,169.37 186.71,169.73 186.6,169.85 v2(186.6,170.1) ; UC1.AD9 UC1.AD8 UC1.AD7 ; v2(147.3,93.92) 147.3,95.36 147.28,95.37 ; UC1.BB5 142.41,98.15 142.41,98.47 UC1.BB6 ; v2(169.41,111.91) 169.41,111.84 UC1.F23 ; v2(169.41,111.91) 169.08,112.24 UC1.G24 ; v2(169.41,111.91) 169.08,111.59 UC1.G23 ; UC1.F3 169.82,97.24 UC1.F4 ; v2(151.58,100.99) 151.51,100.99 UC1.AL9 ; v2(151.58,100.99) v2(151.58,101.62) 151.5,101.62 UC1.AL10 UC1.AL9 ; UC1.BB6 142.64,99.02 142.64,99.05 UC1.BA7 UC1.BA8 ; UC1.BB6 UC1.BA6 ; UC1.AL14 150.99,103.85 v2(150.66,103.52) ; UC1.G5 169.04,98.06 169.09,98.11 169.09,98.49 169.04,98.55 UC1.G6 ; UC1.A28 173.9,115.45 v2(174.06,115.29) ; v2(92.15,43.42) 92.29,43.57 PU201.14 ; v2(173.73,109.15) UC1.A20 ; UC1.BD11 140.34,101.9 v2(140.61,101.62) ; UC1.BD11 UC1.BD12 140.32,102.55 v2(140.61,102.26) 140.89,102.55 UC1.BC12 UC1.BC13 140.87,103.2 v2(140.59,102.92) ; v2(146.08,102.91) 145.72,102.55 UC1.AU12 ; UC1.BM35 134.96,119.96 v2(135.3,120.3) 135.54,120.06 UC1.BL35 ; UC1.AU11 UC1.AU12 ; UC1.AU11 UC1.AU10 UC1.AU9 UC1.AU8 UC1.AU7 ; UC1.AU11 145.81,101.9 145.9,101.8 145.92,101.8 v2(146.1,101.62) ; v2(173.62,102.85) UC1.A12 ; UC1.W33 v2(160.54,118.43) ; UC1.AH33 153.13,118.76 v2(153.45,119.08) 153.12,119.41 UC1.AH34 ; UC1.BH9 UC1.BH8 ; UC1.BH9 137.62,100.6 v2(137.86,100.35) ; UC1.BH8 137.46,99.95 v2(137.86,100.35) ; UC1.BH8 UC1.BH7 ; UC1.AU7 145.63,98.67 UC1.AU6 145.35,98.39 145.17,98.39 UC1.AW5 UC1.AW4 UC1.AW3 ; v2(172.01,101.67) 171.68,102 UC1.C11 171.4,102.35 171.4,102.49 UC1.D12 ; JCDRA.35 166.22,180.54 v2(165.96,180.8) 165.41,180.8 165.02,180.41 JCDRA.32 ; UC1.C37 UC1.B37 ; v2(173.62,106) UC1.A16 ; UC1.A18 173.45,107.58 v2(173.49,107.62) ; v2(169.41,102.45) 169.41,102.38 UC1.F11 ; UH1.A2 UH1.A3 UH1.A4 UH1.A5 ; UC1.N9 UC1.N10 UC1.N11 ; UC1.N9 UC1.N8 ; UC1.N9 164.95,100.6 165.23,100.87 v2(165.29,100.87) 165.29,100.4 UC1.N8 ; UC1.BR36 132.47,120.58 UC1.BT36 132.15,120.7 v2(131.79,120.33) 132.24,119.88 UC1.BT35 ; v2(64.69,15.88) U17.11 ; v2(143.35,104.17) 143.67,103.85 UC1.AY14 ; UC1.Y38 v2(159.75,121.69) UC1.Y37 ; UC1.G16 169.08,105.94 v2(169.41,105.61) 169.73,105.29 UC1.F15 169.08,104.57 UC1.G14 ; UC1.N12 UC1.N11 ; UC1.N12 164.98,102.55 v2(165.3,102.23) ; UC1.N11 164.96,101.9 v2(165.3,102.23) ; v2(141.64,118.43) 141.31,118.76 UC1.BC33 ; UC1.BA38 142.82,121.94 142.88,121.87 142.88,121.5 142.82,121.43 UC1.BA37 142.89,121.36 v2(143.21,121.04) ; JCDRA.14 157.82,178.29 v2(157.88,178.23) ; UC1.BD6 140.32,98.89 140.16,98.89 ; UC1.BH6 137.22,99.11 UC1.BH7 ; v2(162.95,180.76) 163.56,180.76 163.82,180.5 JCDRA.29 ; UC1.L34 166.51,119.41 v2(166.84,119.08) 166.52,118.76 UC1.L33 ; UC1.F13 169.35,103.26 169.35,103.12 UC1.G12 169.08,102.79 v2(168.76,102.46) ; UL1.27 269.11,164.04 v2(268.93,163.85) ; UC1.T5 UC1.T4 UC1.T3 UC1.T2 UC1.T1 162.37,95.29 162.37,95.29 162.37,94.88 v2(161.92,94.43) ; UC1.D20 171.28,108.9 171.28,108.76 UC1.C19 171.68,108.3 v2(172.01,107.97) ; UC1.AW3 144.44,96.36 v2(144.32,96.36) ; v2(135.09,97.46) 134.86,97.23 UC1.BM3 134.83,96.97 134.83,96.45 UC1.BM2 134.62,96.04 UC1.BN2 ; 162.48,100.99 v2(162.56,100.99) ; 162.48,100.99 UC1.T9 ; UC1.BA10 UC1.BA11 ; UC1.BA11 143.08,101.9 v2(143.35,101.62) ; v2(200.75,17.38) 200.74,17.38 200.32,16.95 199.97,16.95 199.96,16.96 199.74,16.96 199.73,16.95 199.39,16.95 199.06,17.28 199.06,17.31 198.97,17.39 UH1.M49 ; UC1.P38 v2(164.47,121.69) UC1.P37 ; UC1.BM29 UC1.BL29 135.82,116.22 UC1.BK29 136.66,116.62 UC1.BJ30 136.52,116.74 v2(136.13,117.13) 136.46,117.46 UC1.BJ31 ; UC1.BM29 UC1.BN29 UC1.BP29 UC1.BR29 ; UC1.BH7 137.58,99.3 137.89,99.6 137.89,100.33 v2(137.86,100.35) ; v2(172.01,111.12) 171.68,111.45 UC1.C23 171.28,111.91 171.28,112.05 UC1.D24 ; v2(170.08,178.19) 169.82,178.45 JCDRA.44 ; UC1.E4 UC1.F4 ; UC1.AV37 145.26,121.36 v2(145.58,121.69) 145.25,122.01 UC1.AV38 ; v2(165.3,102.23) 165.61,102.55 UC1.M12 UC1.M13 UC1.M14 ; UC1.AU33 146.04,118.76 v2(146.36,118.43) ; v2(167.65,180.78) 167.42,180.55 JCDRA.38 ; UC1.D22 171.28,110.48 171.28,110.34 UC1.C21 172.01,109.61 v2(172.01,109.52) ; UC1.BM38 135.1,122.02 v2(135.47,122.39) 135.81,122.05 UC1.BL38 ; UC1.F2 169.75,96.04 v2(169.43,96.36) ; v2(172.01,103.25) 171.68,103.57 UC1.C13 171.28,104.04 171.28,104.18 UC1.D14 ; v2(146.36,119.73) 146.04,119.41 UC1.AU34 ; v2(195.32,37.12) 195.35,37.15 195.35,37.71 UH1.D8 195.13,37.81 194.9,37.58 193.87,37.58 UH1.A8 ; UC1.T34 162.57,119.41 v2(162.9,119.08) UC1.T33 ; UC1.H12 168.43,102.79 v2(168.76,102.46) ; 134.63,106.96 134.31,107.28 UC1.BN18 UC1.BP18 UC1.BR18 UC1.BT18 v2(131.49,107.35) ; UC1.AR5 147.28,97.85 147.33,97.8 147.33,97.52 147.28,97.48 UC1.AR4 147.28,97.21 147.29,97.2 147.29,96.7 UC1.AR3 147.32,96.65 147.32,96.07 UC1.AR2 ; UC1.H11 168.43,102.14 v2(168.76,102.46) ; UC1.AF14 UC1.AF13 UC1.AF12 154.45,102.22 v2(154.28,102.22) 153.97,101.9 UC1.AG11 ; UC1.AC38 v2(157.39,122.34) ; v2(167.21,107.58) UC1.J18 UC1.H18 168.47,107.49 169,107.49 UC1.G18 169.08,107.51 v2(169.41,107.19) 169.73,106.86 UC1.F17 169.41,106.47 v2(169.41,106.39) ; v2(160.55,119.07) 160.21,119.41 UC1.W34 ; v2(131.36,98.16) 131.39,98.18 132.34,98.18 UC1.BT5 ; v2(173.55,101.24) 173.52,101.28 UC1.A10 ; v2(214.81,34.8) 214.77,34.81 UH1.BC13 ; v2(135.28,113.25) 134.96,113.58 UC1.BM26 ; UC1.AM38 149.97,122.01 v2(150.3,121.69) 149.98,121.36 UC1.AM37 ; UC1.A4 UC1.A3 172.41,96.64 UC1.B3 ; v2(173.8,110.73) UC1.A22 ; v2(172.03,114.24) 172.03,114.29 172.02,114.29 171.68,114.63 UC1.C27 171.28,115.06 171.28,115.2 UC1.D28 ; UC1.U37 v2(162.11,121.69) UC1.U38 ; UC1.AL34 150.63,119.41 v2(150.3,119.08) 150.62,118.76 UC1.AL33 ; v2(172.01,112.7) 171.68,113.02 UC1.C25 171.28,113.49 171.28,113.63 UC1.D26 ; UC1.E38 169.96,121.88 169.96,121.06 v2(169.99,121.04) 169.91,121.04 UC1.F36 169.26,120.38 169.2,120.38 168.88,120.06 UC1.H35 168.41,120.46 168.27,120.46 UC1.J36 ; UC1.AY34 143.67,119.41 v2(144,119.08) 143.68,118.76 UC1.AY33 ; UC1.Y10 UC1.Y11 159.52,101.9 159.62,101.8 159.63,101.8 v2(159.81,101.62) 159.44,101.25 UC1.Y10 ; UC1.AG7 UC1.AG8 ; v2(130.88,99.96) 131.34,99.96 131.4,100.02 132.34,100.02 UC1.BT8 ; UC1.AE6 156,98.3 v2(156.08,98.3) 156.17,98.3 UC1.AD6 ; v2(243.4,32.38) 243.93,32.9 PU8200.5 ; UC1.BG38 v2(138.49,122.34) ; UC1.K38 166.81,122.43 v2(166.77,122.43) ; UC1.BR38 v2(132.53,122.43) ; UC1.F21 169.73,110.01 v2(169.41,110.34) 169.08,110.66 UC1.G22 ; v2(174.2,104.43) UC1.A14 ; UC1.AR37 147.61,121.36 v2(147.94,121.04) ; v2(173.99,112.3) UC1.A24
  BOTTOM w0.229: v2(197.28,175.92) DT8.2 ; v2(194.72,175.92) DT7.2
  BOTTOM w0.25: UG9.BL25 235.77,117.24 v2(235.65,117.12) v2(235.65,116.57) ; UG9.AF1 v2(218.52,100.05) ; v2(241.95,116.57) 241.79,116.57 UG9.BJ33 ; v2(241.95,116.57) 241.95,116.98 242.07,117.1 v2(242.02,117.12) 242.07,117.24 242.07,117.24 UG9.BL34 ; v2(241.95,116.57) 241.95,116.27 UG9.BJ34 ; UG9.BL40 246.27,117.2 v2(246.19,117.12) 246.37,116.95 v2(246.37,116.6) 246.27,116.5 UG9.BJ40 UG9.BJ41 ; v2(253.47,92.95) 253.57,93.05 UG9.T51 ; UG9.AP47 v2(251.47,105.35) ; UG9.BE18 v2(231.17,113.05) ; UG9.D16 229.28,84.84 v2(229.28,85.03) ; UG9.BJ31 239.85,116.27 v2(239.85,116.57) ; UG9.BD32 v2(240.37,112.35) ; v2(248.7,101.15) 248.4,101.45 UG9.AH43 ; UG9.BL19 231.57,117.24 v2(231.45,117.12) v2(231.45,116.56) ; v2(223.49,115.1) UG9.BG7 UG9.BF6 ; v2(233.55,116.57) 233.55,116.27 UG9.BJ22 ; v2(233.55,116.57) v2(233.55,117.12) 233.67,117.24 UG9.BL22 ; v2(233.55,116.57) 233.39,116.57 UG9.BJ21 ; UG9.AK1 v2(218.52,102.85) ; UG9.BE21 v2(233.27,113.05) ; UG9.AH49 252.45,101.33 v2(251.99,101.33) ; UG9.AP43 248.51,105.51 248.96,105.51 v2(249,105.55) ; UG9.BE22 v2(233.37,113.65) ; UG9.BG16 v2(229.77,114.45) ; CG277.2 192.4,84.64 192.39,84.63 192.39,84.52 192.23,84.36 v2(192.23,83.9) ; UG9.BG40 v2(246.57,114.45) ; v2(248.07,115.73) 247.92,115.7 UG9.BH42 ; v2(248.74,99.65) 248.67,99.65 UG9.AE43 ; UG9.BJ30 239.69,116.57 v2(239.85,116.57) ; UG9.BJ43 248.07,116.45 v2(247.97,116.45) UG9.BJ42 ; v2(213.93,102.84) 213.93,102.98 214.25,103.3 214.71,103.3 215.07,102.94 v2(215.07,102.85) ; UG9.BE25 v2(235.46,113.66) ; UG9.BE24 v2(235.37,113.05) ; UG9.AF45 250.07,99.75 v2(250.07,99.65) ; UG9.BJ27 237.59,116.57 v2(237.75,116.57) ; UG9.BJ18 231.29,116.57 231.44,116.57 v2(231.45,116.56) ; v2(239.85,116.57) 239.85,117.07 v2(239.91,117.13) 239.97,117.19 UG9.BL31 ; UG9.AL45 249.78,103.55 v2(250.07,103.85) ; UG9.M52 v2(255.12,90.25) ; v2(237.75,116.57) 237.75,117.02 237.84,117.11 v2(237.84,117.11) 237.84,117.21 237.87,117.24 UG9.BL28 ; v2(237.75,116.57) 237.75,116.27 UG9.BJ28 ; UG9.BG25 v2(236.07,114.45) ; UG9.BH2 v2(219.37,115.75) ; UG9.AA8 v2(224.29,96.97) ; UG9.BJ36 243.89,116.57 v2(244.05,116.57) ; v2(248.95,97.06) 248.56,97.06 UG9.AB43 ; UG9.BJ16 229.35,116.27 v2(229.35,116.57) 229.47,116.69 UG9.BL16 ; UG9.A29 v2(238.57,82.1) ; UG9.BE15 v2(229.07,113.05) ; UG9.BE31 v2(239.67,113.65) ; v2(255.81,106.38) 255.78,106.35 UG9.AR52 ; UG9.BE19 v2(231.27,113.65) ; UG9.BE30 v2(239.57,113.05) ; UG9.BL43 248.37,117.1 ; UG9.BH5 v2(221.47,115.75) ; UG9.BJ25 235.65,116.27 v2(235.65,116.57) ; UG9.BJ24 235.49,116.57 v2(235.65,116.57) ; v2(240.62,82.1) 240.67,82.15 UG9.A32 ; v2(244.05,116.57) 244.05,116.27 UG9.BJ37 ; v2(244.05,116.57) 244.05,117.01 v2(244.14,117.12) 244.16,117.23 244.17,117.24 UG9.BL37 ; UG9.BE34 v2(241.77,113.65) ; UG9.BG37 v2(244.47,114.45) ; v2(231.82,114.3) 231.82,114.5 UG9.BG19 ; UG9.BE36 v2(243.77,113.05) ; UG9.BD29 v2(238.27,112.35) ; UG9.BF41 v2(246.67,113.75) ; UG9.R52 v2(255.12,92.35) ; v2(255.12,112.56) 255.31,112.37 255.31,111.69 v2(255.2,111.57) ; UG9.BB49 v2(252.27,111.55) ; UG9.BE39 v2(245.87,113.05) ; UG9.BE16 v2(229.17,113.65) ; UG9.BG34 v2(242.37,114.45) ; v2(231.45,116.56) 231.45,116.27 UG9.BJ19 ; UG9.AP49 252.72,105.8 v2(252.98,105.8) ; v2(250.74,101.3) 251.02,101.3 UG9.AH47 ; UG9.AY2 v2(219.08,109.85) ; UG9.W43 v2(248.67,94.85) 248.68,94.86 v2(249.46,94.86) ; UG9.K25 235.77,88.79 ; UG9.BE33 v2(241.67,113.05) ; v2(240.27,114.45) UG9.BG31 ; UG9.V52 v2(255.12,94.45) ; UG9.BE13 v2(227.07,113.05) ; UG9.A26 236.47,82.1 v2(236.52,82.05) ; UG9.R49 v2(252.87,92.65) ; UG9.BD38 v2(244.57,112.35) ; UG9.BE40 v2(245.97,113.65) ; UG9.BD35 v2(242.47,112.35) ; UG9.BE37 v2(243.87,113.65) ; UG9.AB10 v2(224.97,97.55) ; UG9.BG22 v2(233.97,114.45) ; UG9.BG28 v2(238.17,114.45) ; UG9.BL5 v2(221.47,117.85) ; UG9.BG13 v2(227.67,114.45) ; UG9.BG42 v2(248.07,115.15)
  BOTTOM w0.254: UH1.BG2 UH1.BG3 ; UH1.BG2 UH1.BF2 ; UH1.BG2 v2(216.91,41.21) ; UH1.BG3 UH1.BG4 ; UH1.BG3 UH1.BF3 ; v2(207.78,32.11) UH1.AK20 ; v2(207.78,32.11) UH1.AK19 ; v2(207.78,32.11) UH1.AJ20 ; v2(207.78,32.11) UH1.AJ19 207.01,32.11 UH1.AJ20 ; UH1.AK20 208.48,31.41 UH1.AL21 ; UH1.AK20 207.78,31.34 UH1.AJ20 ; PU511.14 179.9,144.14 v2(179.75,144.3) ; 240.22,87.7 v2(240.22,87.9) ; UC1.BE6 139.81,98.64 v2(140.13,98.31) ; v2(203.91,26.69) UH1.AA31 ; v2(203.91,26.69) UH1.AB31 ; v2(203.91,26.69) UH1.AA30 v2(203.13,27.46) ; v2(167.91,99.56) 167.52,99.95 UC1.K8 ; v2(167.91,99.56) 168.19,99.28 UC1.J7 ; v2(167.91,99.56) 167.65,99.3 UC1.K7 ; UC1.F29 169.73,116.17 v2(169.41,115.85) ; UH1.AA27 v2(203.13,28.24) ; UH1.AA27 v2(203.13,29.01) ; UH1.AA27 v2(203.91,29.01) ; v2(203.13,28.24) UH1.W27 v2(203.13,29.01) ; v2(203.13,28.24) UH1.AA28 v2(203.13,27.46) ; v2(203.13,28.24) UH1.W28 v2(203.13,27.46) ; v2(207.78,29.01) UH1.AJ27 ; v2(207.78,29.01) UH1.AK25 ; v2(207.78,29.01) UH1.AJ25 ; v2(207.78,29.01) UH1.AK27 ; UH1.AJ27 207.01,29.01 ; UH1.AJ27 207.01,28.24 ; UH1.AJ27 v2(207.78,28.24) ; UH1.AD22 205.46,31.34 UH1.AF22 206.23,31.34 UH1.AG22 UH1.AJ20 ; UH1.AJ25 207.78,29.79 UH1.AK25 ; UH1.AJ25 207.01,29.79 ; UH1.AJ25 207.01,29.01 ; UC1.K9 167.21,100.89 v2(167.08,100.89) 167.44,101.25 UC1.K10 ; UH1.AN12 v2(209.97,35.84) ; UH1.BG4 UH1.BF3 ; UH1.BG4 216.42,39.86 216.91,40.35 v2(216.91,41.21) ; UC1.L29 166.44,115.63 v2(166.51,115.56) ; UH1.T5 v2(201.75,39.54) ; v2(201.75,39.54) 201.82,39.46 UH1.V4 ; v2(201.75,39.54) UH1.T4 ; v2(203.13,27.46) UH1.W30 ; UH1.G44 196.73,20.41 196.73,20.94 UH1.F41 196.19,21.59 195.69,21.59 v2(195.43,21.68) ; PU510.4 175.36,147.27 v2(175.46,147.37) ; UC1.G10 169.08,101.21 v2(169.41,100.89) 169.41,100.82 UC1.G9 ; v2(154.82,94.84) UC1.AF1 UC1.AF2 UC1.AF3 154.84,96.7 154.84,97.32 UC1.AF4 155.25,97.77 155.25,98.23 UC1.AE6 ; v2(135.26,111.65) 135.26,111.77 UC1.BM24 ; UC1.BM14 UC1.BL14 135.9,104.49 v2(135.9,104.61) ; 212.24,19.45 UH1.AW46 ; 212.24,19.45 212.71,19.92 212.71,20.37 v2(212.78,20.44) 212.78,20.44 212.78,20.45 212.8,20.44 213.1,20.44 UH1.BA44 ; 212.24,19.45 212.24,19.52 212.03,19.72 211.67,19.72 211.49,19.54 UH1.AT45 ; v2(214.7,25.96) 214.63,26.04 UH1.BC31 ; UH1.E10 195.73,36.57 195.95,36.79 195.95,36.96 v2(196.03,37.03) 195.91,37.15 195.91,37.39 UH1.E8 ; UC1.E34 170.38,119.43 170.48,119.52 170.48,119.96 UC1.E35 170,120.44 169.86,120.44 UC1.F36 ; v2(208.05,39.06) 207.84,39.26 UH1.AK4 ; v2(136.56,104.61) 136.91,104.96 UC1.BJ15 ; v2(136.56,104.61) 136.26,104.91 UC1.BK15 ; v2(136.56,104.61) 136.26,104.31 UC1.BK14 ; JSSD2.57 272.7,12.06 272.96,11.8 v2(272.96,11.36) ; PU511.2 181.66,146.5 ; v2(207.78,28.24) UH1.AJ28 ; v2(207.78,28.24) UH1.AK27 ; v2(207.78,28.24) UH1.AK28 v2(207.78,27.46) ; UH1.AJ28 207.01,28.24 ; UH1.AJ28 v2(207.78,27.46) ; UH1.AJ28 207.01,27.46 ; JSSD1.21 324.79,44.91 v2(324.56,45.14) ; v2(202.32,37.32) 202.32,36.77 v2(202.51,36.58) ; v2(202.32,37.32) 202.14,37.32 201.42,38.03 UH1.T7 v2(200.68,38.03) ; v2(202.32,37.32) UH1.Y9 ; v2(197.67,161.44) 198.09,161.87 UT4.A1 ; v2(152.31,94.84) UC1.AJ1 UC1.AJ2 UC1.AJ3 UC1.AJ4 UC1.AJ5 UC1.AJ6 ; 205.46,28.24 UH1.AF28 v2(206.23,28.24) ; UC1.A3 172.98,96.12 v2(172.9,96.04) ; v2(143.35,101.62) 143.27,101.62 UC1.BA10 ; UH1.V46 202.34,19.34 202.74,19.74 v2(202.89,19.74) ; PU507.4 143.62,150.32 143.46,150.49 v2(143.46,150.84) ; UH1.B48 194.24,18.64 UH1.B47 193.94,18.94 UH1.A46 ; UH1.B48 194.19,18.02 194.19,17.67 UH1.B49 ; UH1.B48 194.28,18.03 UH1.C48 ; UH1.AM18 208.75,33.11 UH1.AL17 207.73,33.53 v2(207.63,33.43) 207.63,33.43 UH1.AH17 ; JHDD.18 v2(121.92,10.72) ; UC1.BL18 135.9,107.06 v2(135.9,106.96) ; UH1.R34 UH1.N34 199.7,25.05 v2(199.15,25.6) UH1.M32 ; UH1.AT18 v2(210.99,33.2) 210.99,33.35 UH1.AT16 UH1.AR16 UH1.AN16 ; 187,166.3 187.04,166.34 CT38.2 ; v2(202.51,36.58) 201.81,35.88 UH1.U12 201.32,35.82 v2(201.24,35.74) ; v2(202.51,36.58) UH1.Y10 ; UH1.AG28 207.01,27.46 ; UH1.AG28 207.01,28.24 ; UH1.AG28 v2(206.23,28.24) ; 207.01,27.46 UH1.AJ30 ; 207.01,27.46 UH1.AG30 207.01,26.69 UH1.AJ30 ; v2(200.14,36.1) 200.39,35.84 UH1.R12 ; v2(115.52,10.72) 115.54,10.72 115.92,11.1 JHDD.6 ; v2(188.48,177.09) 188.48,176.52 DT5.2 ; v2(191.65,177.64) DT3.2 ; UG9.BC25 235.72,111.9 235.72,111.3 ; UC1.AR2 147.25,96.04 v2(146.83,95.62) ; PU502.4 151.19,150.45 v2(151.29,150.55) ; UH1.BC24 214.5,29.98 213.75,30.72 v2(213.75,30.79) ; 207.01,29.79 UH1.AG23 v2(206.23,29.79) ; 207.01,29.79 UH1.AG25 ; UH1.AA5 203.5,39.26 v2(203.91,38.85) ; UH1.AG25 207.01,29.01 ; UH1.AG25 v2(206.23,29.79) ; 207.01,29.01 UH1.AG27 ; v2(149.4,97.66) 149.44,97.66 149.76,97.34 UC1.AM4 ; 206.18,25.42 207.04,25.42 UH1.AH33 207.63,25.37 v2(207.63,25.37) 207.73,25.27 UH1.AL33 ; UC1.BJ34 136.59,119.41 v2(136.92,119.73) ; v2(196.28,46.47) v2(196.28,47.3) 196.24,47.35 v2(196.24,48.28) 196.24,48.92 195.98,49.18 193.98,49.18 v2(193.87,49.28) v2(192.78,49.28) 192.24,49.28 191.91,48.95 191.91,48.58 v2(191.91,48.57) 191.08,47.74 191.08,44.95 191.91,44.12 192.07,44.12 v2(192.14,44.05) ; UH1.AR38 210.51,23.1 210.11,23.5 v2(209.94,23.5) 209.77,23.5 209.42,23.16 UH1.AN38 ; v2(195.43,21.68) UH1.E42 196.07,20.85 UH1.F43 ; v2(195.43,21.68) 195.43,22.15 UH1.E40 ; UH1.M5 v2(199.55,39.54) 199.63,39.46 UH1.P4 UH1.R4 UH1.R3 ; v2(206.23,29.79) UH1.AF25 205.46,29.79 UH1.AD25 204.68,29.79 UH1.AB25 v2(203.91,29.01) ; UH1.BF3 UH1.BF2 ; v2(161.91,96.38) 162.07,96.38 UC1.T3 ; UH1.AK27 208.36,28.82 UH1.AL26 ; v2(202.38,35.23) 202.95,35.8 UH1.Y12 ; v2(208.3,19.15) 208.11,19.34 UH1.AK46 ; v2(210.99,25.6) UH1.AT34 ; v2(210.99,25.6) UH1.AT32 ; v2(210.99,25.6) 210.45,25.06 210.45,25.05 UH1.AR34 UH1.AN34 ; UC1.BJ35 136.43,120.06 v2(136.09,120.4) 136.4,120.71 UC1.BJ36 ; UC1.BN24 134.26,112.12 133.8,112.12 133.75,112.07 UC1.BP24 133.62,112.07 133.53,112.16 133.1,112.16 UC1.BR24 UC1.BT24 ; v2(207.78,26.69) UH1.AK30 ; v2(207.78,26.69) UH1.AK31 208.33,26.14 UH1.AM32 ; v2(207.78,26.69) UH1.AJ30 ; v2(207.78,26.69) UH1.AJ31 ; UH1.AK30 208.48,27.39 UH1.AL29 ; UH1.AK30 v2(207.78,27.46) ; v2(172.45,144.19) 172.52,144.13 PU510.14 ; v2(214.75,37.07) 214.75,37.34 214.49,37.59 UH1.BC8 ; v2(214.75,37.07) 214.75,36.69 UH1.BC10 ; v2(214.75,37.07) 214.32,37.07 213.96,37.42 UH1.BB9 ; v2(171.38,118.2) 171.03,118.55 UC1.D33 ; v2(213.12,34.09) 213.2,34.16 213.2,34.41 213.2,34.42 UH1.BA14 ; UH1.C30 UH1.E31 ; UH1.E31 195.43,26.55 v2(195.43,26.08) ; UH1.E31 UH1.D30 ; UC1.BM25 v2(135.28,113.25) ; v2(199.45,31.96) 199.45,31.69 UH1.M21 ; PU502.14 148.6,147.63 148.34,147.37 v2(148.34,147.37) ; v2(193.33,17.68) 193.3,17.68 193.3,17.64 193.51,17.64 193.6,17.56 193.91,17.56 193.94,17.59 UH1.B49 ; UH1.BF2 UH1.BF1 216.09,41.27 216.84,41.27 v2(216.91,41.21) ; v2(146.13,99.56) 145.74,99.95 UC1.AU8 ; UG9.BD24 235.37,112.35 v2(236.17,112.35) UG9.BD26 ; v2(159.18,147.39) 159.18,147.23 158.99,147.05 PU503.4 ; CT37.2 189.98,168.67 v2(189.98,168.91) 190.6,168.29 192.33,168.29 192.48,168.14 192.48,165.82 192.3,165.64 189.97,165.64 v2(189.8,165.81) ; UH1.A2 193.67,40.86 193.21,40.39 v2(193.21,40.22) ; UH1.R38 200.57,23.1 v2(200.16,23.1) ; v2(276.34,161.84) 276.84,161.84 277.15,162.14 v2(277.8,162.14) v2(279.55,162.14) 281.69,162.14 v2(282.01,162.46) 282.49,162.94 v2(282.49,163.69) 281.92,164.27 281.31,164.27 280.91,164.67 CL8.2 282.01,165.22 282.49,165.7 v2(282.49,167.92) 282.49,168.48 282.18,168.8 281.2,168.8 281.1,168.9 v2(280.56,168.9) v2(279.43,168.9) 279.36,168.82 278.19,168.82 277.75,168.38 v2(277.75,167.82) 277.75,167.14 CL11.2 278.15,166.32 YL1.2 ; UH1.AK25 208.66,29.89 UH1.AL24 ; UH1.AT29 210.97,26.8 v2(210.97,26.8) ; UH1.AJ30 v2(207.78,27.46) ; UH1.AT26 210.66,28.58 210.66,28.04 v2(210.75,27.94) ; v2(206.23,28.24) UH1.AG27 ; v2(203.91,32.11) UH1.AA20 ; v2(203.91,32.11) UH1.AB19 ; v2(203.91,32.11) UH1.AA19 ; UH1.AA20 v2(203.13,31.34) v2(203.13,30.56) v2(203.13,29.79) ; UH1.AA20 v2(203.91,31.34) ; UC1.BR9 133.01,101.02 133.37,100.65 v2(133.97,100.65) ; v2(214.7,23.88) 214.7,24.35 UH1.BC35 ; UH1.AC46 204.41,19.26 v2(204.04,19.26) ; DT2.2 v2(189.11,177.64) ; UC1.BA11 143.25,102.26 v2(143.35,102.26) ; UH1.B49 UH1.A48 UH1.A47 UH1.A46 ; v2(140.61,100.99) 140.54,100.99 UC1.BD9 ; JHDD.9 117.42,10.28 v2(116.47,9.33) ; UC1.AH36 152.93,120.71 v2(152.62,120.4) 152.96,120.06 UC1.AH35 ; v2(171.73,96.72) 171.63,96.62 UC1.D3 ; v2(171.73,96.72) 172.23,96.72 UC1.B3 ; v2(171.73,96.72) 171.73,96.19 UC1.C2 ; v2(270.46,16.71) 270.61,16.56 JSSD2.39 ; v2(120.64,12.69) 120.42,12.47 JHDD.15 120.42,10.74 120.21,10.53 119.39,10.53 118.92,11 JHDD.12 ; UH1.AC4 204.91,39.04 v2(205.11,39.04) 205.23,39.04 UH1.AE4 ; v2(131.91,116.18) 132.08,116.01 UC1.BT29 ; UC1.BN14 UC1.BP14 133.66,104.27 v2(133.33,104.59) 133.01,104.27 UC1.BR14 UC1.BT14 ; UC1.BK18 UC1.BJ18 137.34,107.35 v2(137.5,107.19) ; UH1.A45 UH1.A46 ; UH1.AC38 v2(203.94,23.07) ; UT4.L1 197.89,167.13 197.89,167.55 v2(197.38,168.06) ; v2(131.75,96.49) 131.83,96.57 132.25,96.57 UC1.BT3 ; UC1.J22 167.88,110.58 168.23,110.58 UC1.H22 168.48,110.63 168.98,110.63 UC1.G22 169.08,110.8 v2(169.4,111.11) ; v2(137.47,110.55) 137.41,110.5 UC1.BJ22 136.82,110.5 136.72,110.6 136.36,110.6 UC1.BK22 ; v2(214.11,28.12) 214.11,28.39 214.54,28.82 UH1.BC26 ; UH1.AC33 v2(203.94,25.36) ; v2(137.48,112.86) UC1.BJ25 UC1.BK25 ; v2(166.76,147.37) 166.76,147.3 166.64,147.18 166.64,147.09 166.6,147.05 PU504.4 ; v2(214.32,20.31) UH1.BB43 ; v2(214.32,20.31) UH1.BD43 UH1.BE44 ; v2(214.32,20.31) UH1.BC45 ; UH1.J4 197.42,39.46 v2(197.35,39.54) 197.35,39.24 196.87,38.76 UH1.G6 UH1.H8 UH1.J9 UH1.J10 UH1.K11 198.09,35.84 v2(198.31,35.63) 199.41,35.63 UH1.N12 ; v2(195.43,26.08) UH1.D33 ; v2(195.43,26.08) UH1.E33 ; UC1.BK29 136.58,115.88 UC1.BJ29 ; UH1.AT24 210.83,30.04 210.83,31.27 UH1.AT21 v2(210.97,31.96) ; v2(195.43,32.72) 195.51,32.65 UH1.E19 ; v2(195.43,32.72) 195.27,33.35 UH1.D17 ; v2(195.43,32.72) UH1.E17 ; v2(270.72,25.25) 271.03,25.56 JSSD2.3 ; JSSD2.33 v2(270.66,18.06) ; UH1.AD19 204.49,33.08 UH1.AC17 204.48,33.43 UH1.Y17 ; UC1.BP25 133.66,112.9 133.38,113.17 133.38,113.22 v2(133.36,113.25) ; DT4.2 186.83,176.33 186.35,176.33 v2(186.32,176.3) ; UC1.AP11 148.65,101.62 v2(148.84,101.62) ; UC1.BF12 139.37,102.55 v2(139.69,102.87) 140.02,102.55 UC1.BD12 ; U2407.6 187.89,42.12 188.18,41.83 v2(188.21,41.83) ; v2(190,178.81) 190.1,178.9 JUSBC1.A1 ; UH1.J26 v2(197.72,28.27) 197.65,28.21 UH1.J29 ; UH1.U38 v2(201.26,22.98) ; v2(203.13,29.01) UH1.W25 v2(203.13,29.79) ; v2(203.13,29.01) UH1.AA25 ; UH1.E24 195.43,30.06 v2(195.43,30.53) UH1.E22 ; UH1.K39 197.91,22.14 UH1.J40 197.56,22.78 v2(197.43,22.91) ; v2(202.51,23) UH1.Y38 ; v2(203.64,167.06) 203.64,167.03 203.32,167.03 UT4.L11 ; UH1.U24 201.34,29.98 200.77,29.41 ; UH1.AR12 v2(211.06,35.84) 211.41,35.84 UH1.AV11 UH1.AW10 ; UC1.BT26 UC1.BR26 133.14,113.78 133.52,113.78 UC1.BP26 ; UH1.AC12 v2(203.94,35.73) ; UH1.U21 201.51,31.41 UH1.V22 v2(202.36,31.34) UH1.V20 201.39,32.31 UH1.T18 UH1.T17 201.71,33.53 UH1.U17 UH1.U15 ; v2(170.01,122.54) 170.09,122.46 UC1.E38 ; 200.77,29.41 200.73,29.37 v2(200.16,29.37) 199.58,29.37 v2(199.58,29.37) 199.24,29.7 UH1.M24 ; 200.77,29.41 UH1.R26 ; 207.01,28.24 UH1.AG27 ; v2(203.91,29.01) UH1.AA25 ; v2(135.94,108.51) 135.94,108.47 UC1.BL19 ; v2(209.71,19.76) 210.04,19.43 UH1.AP46 ; JSSD2.15 270.76,22.56 v2(270.71,22.51) ; UH1.AE38 v2(206.19,23.07) ; UZ21.5 127.6,103.69 126.99,103.08 126.99,102.15 127.07,102.06 v2(127.07,101.58) ; UC1.AG13 153.96,103.2 154.32,103.56 154.32,104.18 v2(154.42,104.27) 154.78,103.91 ; UC1.AL12 151.23,102.55 v2(151.58,102.9) 151.88,103.2 UC1.AJ13 ; UH1.AE12 v2(206.19,35.73) ; RH593.1 176.51,120.58 v2(176.36,120.42) ; UH1.BC15 214.77,34.51 214.77,34.75 v2(214.81,34.8) ; 201.12,33.77 201.1,33.75 UH1.R16 UH1.N16 UH1.M16 199.14,33.35 v2(199.15,33.2) UH1.M18 ; v2(169.43,96.36) 169.75,96.69 UC1.F3 ; v2(211.9,21.87) 211.91,21.87 211.91,22.19 UH1.AV39 212.39,22.32 UH1.AW40 ; v2(156.96,98.97) 156.64,99.3 UC1.AD7 ; v2(156.96,98.97) 156.63,98.64 UC1.AD6 ; v2(156.96,98.97) 157.3,98.64 UC1.AC6 ; v2(203.13,29.79) UH1.AA25 ; UC1.J10 168.28,101.28 v2(167.97,101.59) 167.81,101.59 UC1.K11 ; UH1.AL38 v2(208.87,22.98) ; 235.72,111.3 v2(235.77,111.25) ; 235.72,111.3 235.6,111.3 235.07,111.83 UG9.BC24 ; PU507.14 141.15,147.62 140.89,147.37 v2(140.74,147.37) ; v2(195.84,23.99) 195.84,24.09 UH1.E35 ; v2(163.69,144.16) 163.82,144.16 164.03,144.36 164.13,144.36 164.22,144.46 PU504.14 ; UH1.AH12 v2(207.63,35.8) 207.65,35.82 UH1.AL12 ; 216.39,17.94 UH1.BG48 UH1.BF48 UH1.BF49 ; UH1.AH38 v2(207.63,23) ; UH1.BA6 UH1.BA5 v2(212.79,39.54) UH1.AW4 ; UH1.N37 199.34,24 199.25,24 v2(199.25,24) ; JSSD2.21 270.78,21.06 v2(270.71,20.98) ; UC1.BL21 135.26,109.37 v2(135.26,109.32) 135.61,108.97 UC1.BL20 ; v2(151.83,96.38) 151.83,96.93 UC1.AK4 UC1.AL4 ; UC1.AR3 147.2,96.69 v2(146.83,96.32) ; UH1.N38 199.35,23.23 v2(199.25,23.23) ; UC1.BN4 134.44,97.49 UC1.BM5 135.09,97.67 v2(135.09,97.46) ; UH1.E26 195.51,28.35 v2(195.43,28.27) ; UH1.R29 v2(200.42,27.75) ; v2(156.1,144.29) 156.26,144.29 156.37,144.41 156.52,144.41 156.61,144.5 PU503.14 ; JSSD2.9 272.77,24.06 273.02,24.31 v2(273.02,25.36) 273.02,25.74 272.71,26.06 JSSD2.1 ; UC1.BL22 135.61,110.45 135.47,110.31 135.47,110.29 v2(135.27,110.1) 135.12,110.24 135.12,110.29 134.96,110.46 UC1.BM22 ; UH1.N35 199.22,24.48 v2(199.16,24.54) 199.09,24.62 UH1.M34 ; v2(187.07,169.02) 187.07,168.35 v2(186.76,168.05) 186.76,167.22 v2(186.57,167.03) ; v2(200,26.84) 200,26.84 UH1.P29 ; JSSD2.27 270.77,19.56 v2(270.71,19.61) ; UC1.AG7 153.86,98.76 UC1.AG6 ; UM8.25 126.03,158.98 v2(125.98,159.03) ; UC1.C31 171.35,117.48 v2(171.35,117.47) ; UC1.BG14 138.18,103.85 v2(137.86,103.53) 137.54,103.85 UC1.BH14 ; v2(206.08,19.77) 205.95,19.77 205.65,19.47 UH1.AE46 ; UG9.AV45 v2(249.35,108.03) v2(248.83,107.51) ; UC1.AR5 147.23,97.99 v2(146.83,97.59) ; UH1.T32 201.39,25.69 UH1.U33 ; UH1.P26 v2(200,28.27) ; UC1.AP33 148.28,118.76 v2(147.96,119.08) 148.3,119.41 UC1.AP34 ; UH1.BB41 213.9,21.49 214.59,21.73 v2(214.7,21.68) 214.7,22.15 UH1.BC40 ; UC1.AR1 147.28,95.37 v2(146.83,94.92) ; v2(213.75,33.09) 213.75,33 214.55,32.2 214.55,32.18 UH1.BC19 ; UU7.12 24.69,47.47 24.46,47.23 v2(24.33,47.23) ; v2(283.35,89.36) 283.35,89.36 UG1.A1 ; JHDD.3 v2(114.42,12.94) ; v2(183.25,164.96) 183.77,164.96 RT3.2 183.75,164.9 CT77.2 ; UH1.D16 UH1.E15 195.43,34.45 v2(195.43,34.92) UH1.E13 ; UH1.BA12 v2(213.2,36.43) ; UC1.BC14 UC1.BC13 ; UC1.BM18 134.63,106.96
  BOTTOM w0.3: v2(253.42,97.1) 253.57,97.25 UG9.AB51 ; UG9.AB45 250.03,97.51 v2(250.12,97.51) ; UG9.AG44 249.07,100.78 v2(248.7,101.15) ; UG9.AU51 253.42,107.75 v2(253.34,107.68) ; UG9.AH45 v2(250.07,101.75) ; UG9.A3 v2(220.37,81.95) ; v2(252.01,97.44) 252.01,97.43 v2(251.52,96.94) 251.2,97.25 UG9.AB47 ; UG9.AT51 UG9.AT52 v2(255.15,107.05) ; UG9.J17 230.02,88.3 v2(229.67,88.3) ; UG9.B48 v2(252.17,82.95) ; UG9.AH2 219.95,101.45 ; UG9.T45 250.1,93.38 v2(250.13,93.38) ; UG9.AP51 253.92,105.7 v2(253.52,105.7) ; v2(253.5,103.68) 253.63,103.55 UG9.AL51 ; v2(251.57,92.75) 251.47,92.75 UG9.T47 ; UG9.AE51 253.57,99.35 v2(253.42,99.2) ; v2(253.34,101.37) 253.42,101.45 UG9.AH51 ; UG9.BD52 255.03,112.65 v2(255.12,112.56) ; UG9.AW46 v2(250.17,109.45) ; v2(251.57,90.77) 251.35,90.77 UG9.N47 ; UG9.BC51 254.21,111.71 v2(254.41,111.71) ; UG9.J1 v2(218.52,88.15) ; v2(231.84,88.46) 231.96,88.46 UG9.J20 ; UG9.AB6 v2(222.17,97.55) ; UG9.AK44 v2(248.77,103.15) ; UG9.AY47 v2(250.87,109.55) ; UG9.AE45 v2(250.07,99.65) ; UG9.N51 253.49,90.95 v2(253.46,90.92) ; UG9.W51 253.63,95.15 v2(253.46,94.98) ; UG9.AD44 v2(248.77,98.95) ; UG9.AJ9 v2(224.87,101.85) ; v2(219.12,82) UG9.A2
  BOTTOM w0.305: UG8.A1 v2(205.83,72.05) ; v2(327.83,40.28) 327.44,40.67 326.85,40.67 326.58,40.41 JSSD1.39 ; v2(215.79,57.11) 215.39,57.51 UG5.E1 v2(214.99,57.11) v2(214.39,57.11) ; v2(245.44,59.86) 245.39,59.91 UG6.K1 UG6.K2 ; UG2.E3 273.55,116.97 v2(273.75,117.16) ; JDIMM2.1 111.69,50.45 v2(112.13,50.88) 112.69,50.31 JDIMM2.5 ; v2(199.43,100.65) 199.63,100.85 UG7.K2 ; v2(259.59,68.11) v2(259.59,67.51) 259.36,67.29 UG3.U12 ; v2(198.18,90.8) 198.23,90.85 UG7.H14 UG7.H13 ; v2(237.99,57.11) UG6.P10 ; UG6.B10 v2(237.19,66.71) ; v2(283.35,106.91) v2(283.35,107.56) UG2.U14 ; UG3.U14 v2(261.19,67.51) 262.37,68.7 CG279.2 ; v2(305.19,44.19) 305.07,44.06 304.95,44.06 304.57,43.68 JWLAN.18 ; CG266.2 228.16,55.68 227.53,56.31 v2(226.79,56.31) v2(226.19,56.31) UG5.C14 v2(225.39,56.31) ; UG8.N14 v2(195.43,83.25) v2(195.43,83.9) 195.43,84.44 195.26,84.61 CG203.2 ; v2(280.15,90.16) UG1.E3 v2(280.15,90.96) ; v2(202.63,100.65) 202.56,100.59 UG7.N3 ; UG5.N1 v2(214.99,64.31) ; UG7.T5 204.86,98.89 204.86,98.89 v2(205.03,99.05) ; JDIMM1.43 122.19,62.84 122.95,63.59 v2(123.38,63.59) ; v2(277.45,88.41) 277.35,88.51 UG1.H1 UG1.H2 ; v2(171.41,63.06) 171.19,62.84 JDIMM1.231 ; v2(252.39,57.11) 251.99,57.51 UG3.E3 v2(251.59,57.11) ; JDIMM1.238 172.94,52.62 v2(173.28,52.29) ; UG8.T10 v2(193.03,79.25) ; UG8.T10 193.43,79.65 v2(193.83,80.05) UG8.R11 ; UG8.T10 v2(193.03,80.05) ; v2(158.8,39.51) 158.44,39.87 JDIMM2.180 ; UG4.C4 272.09,80.62 v2(272.15,80.62) ; v2(135.26,42.73) 135.39,42.73 135.94,42.17 JDIMM2.98 ; JDIMM1.35 120.19,63.19 120.97,63.96 v2(121.24,63.96) ; v2(224.59,64.31) UG5.N12 v2(224.59,63.51) ; v2(283.35,118.76) v2(283.35,119.41) 284.06,120.12 CG103.2 ; v2(283.35,118.76) 284.07,118.76 284.23,118.93 CG97.2 ; v2(283.35,118.76) UG2.U1 ; UG6.A14 234.19,67.11 v2(233.79,67.51) 233.3,67.51 233.3,67.5 CG172.2 ; v2(279.35,91.76) UG1.F5 v2(278.55,92.56) UG1.G5 ; v2(259.59,57.11) UG3.E12 v2(259.59,57.91) ; v2(167.39,63.24) 167.69,62.93 JDIMM1.217 ; UG3.T10 v2(257.99,66.71) ; v2(192.23,73.65) 192.63,74.05 UG8.U3 ; JWLAN.61 v2(317.32,36.56) ; CG85.2 281.07,101.12 280.95,101 v2(280.95,100.36) v2(280.95,99.76) UG1.C14 v2(280.95,98.96) ; v2(113.71,50.45) 113.69,50.44 JDIMM2.9 ; CG79.2 277.45,106.19 277.6,106.33 v2(277.6,107.31) 277.6,107.71 UG2.K14 v2(277.75,108.36) UG2.K13 v2(276.95,109.16) ; UG1.P10 v2(272.15,96.56) 271.75,96.96 UG1.R11 v2(271.35,97.36) 271.75,97.76 UG1.R12 271.75,97.76 v2(272.15,98.16) ; UG6.H1 245.04,61.51 245.12,61.58 245.12,61.58 245.25,61.71 v2(245.44,61.71) ; v2(276.15,90.16) 275.91,89.92 275.91,89.92 UG1.K2 ; v2(130.25,52.31) 130.53,52.31 130.94,52.72 JDIMM1.78 ; v2(243.59,65.11) UG6.C3 v2(242.79,65.11) UG6.C4 ; UG1.U14 v2(269.75,99.76) 269.75,100.24 269.74,100.25 CG87.2 ; v2(273.35,107.36) 273.35,107.96 ; JDIMM2.23 117.2,49 117.2,50.08 v2(117.48,50.36) 117.95,50.36 118.2,50.12 118.2,49 JDIMM2.27 ; v2(275.6,83.91) 275.78,83.55 UG4.H1 ; v2(257.99,63.51) UG3.M10 v2(257.99,62.71) UG3.L10 ; UG5.H2 UG5.H1 215.17,59.91 v2(214.84,59.81) ; JDIMM2.106 137.94,39.79 138.18,39.55 v2(138.44,39.55) ; JDIMM2.196 162.44,39.81 162.14,39.5 162.07,39.5 v2(162.07,39.51) 162.06,39.5 161.9,39.5 161.44,39.96 JDIMM2.192 ; v2(251.59,61.11) 251.19,61.51 UG3.K2 ; v2(282.55,89.36) 282.95,88.96 UG1.A1 v2(283.35,88.56) v2(283.35,87.96) ; 205.42,82.85 v2(205.04,82.47) ; 205.42,82.85 UG8.A14 ; 205.42,82.85 205.42,83.44 v2(205.43,83.45) ; UG6.G10 v2(237.19,62.71) 237.59,63.11 237.43,63.27 ; UG7.K13 v2(200.23,91.85) 199.83,91.45 UG7.K14 199.83,91 v2(200.03,90.8) ; UG2.M5 279.11,115.01 279.11,115 v2(279.35,114.76) ; v2(201.83,92.65) 202.23,93.05 UG7.N12 ; v2(280.15,116.36) 279.93,116.59 UG2.N3 v2(280.15,117.16) ; v2(226.49,59.71) 226.29,59.91 UG5.H14 ; v2(119.19,58.02) 119.19,58.02 JDIMM1.31 ; v2(126.69,63.71) 126.18,63.71 125.69,63.22 JDIMM1.57 ; v2(161.74,63.74) 162.11,63.74 162.69,63.16 JDIMM1.197 ; v2(126.69,63.07) JDIMM1.61 ; v2(276.95,74.16) 277.35,73.76 UG4.K13 UG4.K14 277.35,72.56 v2(277.6,72.31) 277.6,71.83 277.26,71.49 CG113.2 ; JDIMM2.226 169.95,40.8 169.95,42.97 170.67,43.69 v2(170.8,43.69) ; CG102.2 269.93,106.5 v2(270.15,106.71) v2(270.15,107.36) 270.15,107.96 UG2.A14 ; CG82.2 277.57,86.6 v2(277.82,86.86) ; v2(124.66,42.86) 124.45,42.65 JDIMM2.52 ; UG4.L10 v2(278.55,76.56) UG4.M10 279.16,75.95 v2(279.35,75.76) ; v2(283.35,90.96) UG1.A3 v2(282.55,90.96) ; JDIMM2.99 136.19,50.03 v2(135.98,50.24) ; v2(205.03,73.65) UG8.A3 205.43,74.05 v2(205.83,73.65) v2(206.43,73.65) ; PU511.4 182.66,147.02 v2(182.84,147.2) ; v2(281.75,117.16) UG2.R3 v2(281.75,116.36) UG2.R4 ; v2(137.99,63.84) 136.72,63.84 136.19,63.31 JDIMM1.99 ; JDIMM2.197 162.69,50.36 162.24,50.81 v2(161.63,50.81) ; v2(280.15,106.91) v2(280.15,107.56) UG2.N14 280.15,108.36 v2(280.15,108.36) ; 166.69,63.43 v2(167.39,64.13) ; 166.69,63.43 JDIMM1.213 ; 166.69,63.43 166.32,63.06 165.91,63.06 165.69,62.84 JDIMM1.209 ; v2(112.06,44.02) 112.17,44.02 112.94,43.24 JDIMM2.6 112.94,39.76 112.65,39.47 112.34,39.47 111.94,39.86 JDIMM2.2 ; v2(314.97,36.57) 314.78,36.57 314.32,36.11 JWLAN.49 ; v2(192.23,83.9) v2(192.23,83.25) UG8.U14 ; CG118.2 281.96,84.62 v2(281.75,84.41) v2(281.75,83.76) UG4.R1 ; UG2.P10 v2(280.15,111.56) ; UG5.P10 v2(222.99,65.11) UG5.R11 v2(223.79,65.91) 224.19,65.51 UG5.R12 v2(224.59,65.11) ; UG7.N1 v2(202.23,102.45) ; JDIMM1.60 126.44,52.4 v2(126.6,52.25) 127.08,52.25 127.44,52.61 JDIMM1.64 ; v2(272.95,73.36) 273.35,72.96 UG4.E14 v2(273.35,72.36) ; v2(127.94,63.09) 127.82,63.09 127.69,62.97 JDIMM1.65 ; UG6.N12 v2(235.59,57.11) ; 194.23,93.85 v2(194.63,94.25) UG7.D10 ; 194.23,93.85 UG7.C11 v2(193.83,93.45) UG7.C12 194.23,93.05 v2(194.63,92.65) ; 194.23,93.85 v2(193.83,94.25) 193.43,94.65 UG7.B10 v2(193.03,95.05) ; v2(193.03,101.45) UG7.A1 ; UG7.A1 v2(192.23,102.25) ; UG7.A1 192.63,101.85 v2(192.23,101.45) ; JDIMM1.210 165.94,52.68 v2(166.3,52.32) 166.6,52.32 166.94,52.66 JDIMM1.214 ; v2(256.99,56.71) UG3.D10 v2(257.99,56.31) UG3.C11 ; CG315.2 264.77,61.28 RG123.2 CG114.2 262.74,61.63 v2(262.74,61.91) 262.68,61.97 261.76,61.97 261.3,61.51 UG3.K14 260.79,61.51 v2(260.39,61.91) UG3.K13 ; v2(272.95,88.56) 273.17,88.78 UG1.N1 ; JDIMM2.15 115.19,49.94 115.53,50.27 v2(116.13,50.27) 116.2,50.21 116.2,49 JDIMM2.19 ; v2(234.79,64.31) 234.39,63.91 UG6.E14 234.21,63.91 v2(233.81,64.31) ; v2(270.55,117.16) 270.15,116.76 UG2.A3 v2(269.75,117.16) ; v2(280.14,96.56) 280.54,96.16 UG1.D10 ; UG8.U1 v2(192.22,72.86) ; v2(251.59,64.31) UG3.N3 ; UG9.BE28 237.83,113.35 237.51,113.68 v2(237.51,113.69) ; JDIMM1.239 173.19,60.3 v2(173.17,60.27) 173.78,60.27 174.19,60.68 JDIMM1.243 ; v2(280.95,89.36) 281.35,88.96 UG1.C1 v2(281.75,88.56) v2(281.75,87.96) 282.14,87.57 CG80.2 ; UG2.E1 273.21,118.5 v2(272.95,118.76) ; v2(204.23,101.45) 203.83,101.85 UG7.R1 203.83,102.45 v2(203.83,102.45) ; UG1.R4 271.75,91.36 v2(271.35,90.96) UG1.R3 ; v2(202.63,82.45) UG8.E14 v2(202.23,83.45) ; UG8.E12 v2(202.63,81.65) ; UG4.R4 v2(281.75,81.36) UG4.R3 v2(281.75,82.16) ; v2(235.59,60.31) 235.19,59.91 UG6.K13 UG6.K14 ; JDIMM2.223 169.19,50.14 v2(169.48,50.42) 169.97,50.42 170.19,50.19 JDIMM2.227 ; v2(280.15,81.36) UG4.N3 v2(280.15,82.16) ; 203.86,84.38 203.86,83.48 v2(203.83,83.45) 203.83,83.45 UG8.C14 v2(203.43,82.45) ; UG7.E12 v2(195.43,93.45) ; 223.39,55.91 UG5.C11 ; 223.39,55.91 v2(222.99,55.51) UG5.B10 222.59,55.11 v2(222.19,54.71) ; 223.39,55.91 v2(222.99,56.31) UG5.D10 ; JDIMM2.61 126.69,50.19 v2(126.58,50.3) 127.41,50.3 127.69,50.02 JDIMM2.65 ; v2(226.79,54.71) v2(226.19,54.71) 225.79,54.31 UG5.A14 v2(225.39,54.71) ; v2(214.84,61.66) 214.99,61.51 UG5.K1 ; v2(275.6,88.41) 275.78,88.77 UG1.K1 ; v2(156.34,63.74) 156.66,63.74 157.19,63.21 JDIMM1.175 ; v2(271.35,118.76) UG2.C1 271.74,118.36 v2(271.34,117.96) ; JSSD3.1 254.02,15.98 254.32,16.27 v2(254.32,16.31) ; UG4.B10 v2(270.55,75.76) ; v2(269.75,109.16) 269.97,109.38 UG2.A12 ; v2(273.75,75.76) UG4.F10 v2(274.55,75.76) UG4.G10 ; CG126.2 248.64,58.14 248.83,57.95 248.84,57.95 248.88,57.91 v2(249.39,57.91) v2(249.99,57.91) ; UG8.C4 203.83,74.85 v2(203.43,74.45) UG8.C3 203.83,74.05 v2(203.43,73.65) ; UH1.C5 194.92,39.3 v2(195.4,39.3) ; v2(311.1,36.57) 311.32,36.34 JWLAN.37 ; UG8.H2 199.83,73.25 v2(199.43,73.65) ; v2(223.19,53.11) 223.33,52.98 CG286.2 ; v2(216.59,64.31) UG5.N3 ; v2(272.95,99.76) UG1.N14 v2(272.95,98.96) ; JSSD3.15 v2(250.53,16.32) ; 155.48,63.27 155.48,63.25 155.19,62.96 JDIMM1.167 ; UG7.L5 v2(201.03,99.05) 201.43,98.65 UG7.M5 ; v2(203.43,100.65) 203.83,100.25 UG7.R3 203.83,100.25 v2(204.23,99.85) UG7.R4 ; v2(215.79,54.71) 215.39,54.31 UG5.A1 ; v2(132.17,52.31) 131.94,52.53 JDIMM1.82 ; v2(198.63,81.65) UG8.K13 UG8.K14 v2(197.83,83.25) ; v2(119.04,45.22) 119.19,45.37 JDIMM2.31 ; CG134.2 248.61,57.27 248.77,57.11 v2(249.39,57.11) v2(249.99,57.11) UG3.E1 ; CG122.2 269.62,71.83 v2(270.15,72.36) 270.15,72.36 UG4.A14 ; JWLAN.67 v2(318.82,36.56) ; JDIMM2.44 122.45,42.06 122.31,42.2 122.31,43.36 122.57,43.63 v2(122.95,43.63) 123.12,43.63 123.58,43.18 123.58,42.51 123.45,42.38 JDIMM2.48 ; JWLAN.43 v2(312.82,36.57) ; UG1.T5 v2(270.55,91.76) ; v2(195.43,91.05) 195.63,91.26 UG7.E14 ; v2(269.75,118.76) 269.96,118.55 UG2.A1 ; UG6.C12 235.99,65.51 v2(236.39,65.91) UG6.C11 UG6.D10 ; UG3.M5 v2(253.19,62.71) UG3.L5 ; v2(222.99,57.91) UG5.F10 v2(222.04,58.31) 222.04,58.56 UG5.G10 ; v2(283.35,109.16) UG2.U12 v2(282.55,109.16) ; v2(129.03,52.31) 129.14,52.31 129.44,52.62 JDIMM1.72 ; JDIMM1.47 123.19,62.83 v2(123.37,63.01) 123.9,63.01 124.19,62.71 JDIMM1.51 ; UG2.C4 271.75,115.96 v2(272.15,116.36) 271.75,116.76 ; UG7.D10 195.04,94.65 v2(195.44,94.25) ; UG7.D10 195.03,95.2 v2(195.03,95.2) ; v2(280.95,109.16) 281.19,109.4 UG2.R12 ; v2(155.34,38.68) 155.44,38.78 JDIMM2.168 ; v2(225.39,65.91) 225.79,65.51 UG5.R14 v2(226.19,65.91) 226.37,65.73 227.15,65.73 ; v2(245.19,64.31) UG6.E1 ; v2(124.72,51.62) 124.83,51.62 125.44,52.24 JDIMM1.56 ; JDIMM2.209 165.69,50.32 165.69,50.32 ; JDIMM2.64 127.45,39.61 127.34,39.5 ; JSSD1.75 327.04,31.41 v2(327.16,31.53) 327.05,31.53 326.68,31.91 JSSD1.73 ; JSSD3.33 246.02,15.46 246.88,16.31 247.09,16.31 247.53,15.87 JSSD3.27 ; JDIMM2.213 166.69,49.87 167.02,50.2 ; v2(280.15,109.16) 279.98,109.33 279.98,109.33 UG2.N12 ; JWLAN.31 309.82,34.15 v2(309.25,33.58) ; v2(279.35,110.76) UG2.M10 v2(278.55,111.56) UG2.L10 ; 181.66,146.5 181.66,147.19 v2(181.68,147.21) ; v2(327.16,32.19) 327.1,32.19 326.88,32.41 JSSD1.71 ; v2(249.99,65.91) UG3.R1 250.39,65.51 v2(250.79,65.91) ; UG8.A12 v2(205.83,81.65) ; JDIMM2.102 136.94,39.67 v2(136.78,39.51) ; JDIMM2.251 176.19,50.47 175.71,50.96 v2(175.39,50.96) ; JDIMM2.18 115.94,39.89 v2(115.58,39.52) 115.37,39.52 114.94,39.94 JDIMM2.14 ; UG4.G5 v2(274.55,80.56) UG4.F5 ; v2(129.03,51.7) 128.88,51.7 128.44,52.13 JDIMM1.68 ; UG8.L10 v2(197.03,79.25) UG8.M10 v2(196.23,80.05) ; UG8.B5 v2(205.03,75.25) ; UG7.C3 v2(193.83,100.65) ; JDIMM2.171 156.2,50.04 155.89,50.35 v2(155.65,50.35) 155.2,49.89 JDIMM2.167 ; v2(259.59,65.11) UG3.R12 259.19,65.51 v2(258.79,65.91) UG3.R11 v2(257.99,65.11) UG3.P10 ; v2(218.19,57.91) UG5.F5 218.99,58.71 v2(219.11,58.71) 218.71,59.11 UG5.G5 ; v2(269.1,82.16) v2(269.75,82.16) UG4.A3 ; 160.69,63.27 160.69,63.27 JDIMM1.189 ; CG155.2 233.12,65.73 233.3,65.91 v2(233.79,65.91) 234.19,65.51 UG6.C14 ; CG101.2 282.28,119.94 v2(281.75,119.41) v2(281.75,118.76) UG2.R1 v2(280.95,117.96) ; v2(251.59,68.11) v2(251.59,67.51) 251.8,67.29 251.8,67.29 UG3.U3 ; UG3.H2 UG3.H1 250.19,59.91 v2(249.84,59.81) ; v2(237.75,150.8) 237.81,150.86 PU6101.23 ; UG5.A1 215.39,54.31 v2(215.79,53.91) ; UG5.A1 v2(214.99,53.91) ; JDIMM1.39 121.19,63.33 v2(121.14,63.38) ; UG3.A1 v2(249.99,53.91) v2(249.39,53.91) 248.88,53.91 248.77,54.02 CG136.2 ; CG83.2 271.52,100.42 271.35,100.24 v2(271.35,99.76) UG1.R14 271.75,99.36 v2(271.35,98.96) ; UG8.R12 194.23,81.25 v2(194.63,81.65) ; CG160.2 234.25,52.83 v2(233.97,53.11) ; JDIMM1.90 133.94,52.36 v2(134.12,52.19) 134.6,52.19 134.94,52.54 JDIMM1.94 ; v2(196.23,76.05) UG8.M5 v2(197.03,76.05) UG8.L5 v2(197.03,75.25) ; UG5.L5 v2(218.19,62.71) UG5.M5 ; UG6.B5 v2(241.99,66.71) ; JDIMM2.78 130.94,39.87 130.69,39.61 v2(130.18,39.61) ; v2(269.75,83.76) UG4.A1 v2(270.55,82.96) ; v2(270.55,110.76) 270.77,110.99 270.77,110.99 UG2.B10 ; v2(324.71,37.32) 324.8,37.41 JSSD1.51 ; JSSD1.57 324.69,35.91 v2(324.66,35.93) ; JDIMM1.227 170.19,62.77 v2(169.86,63.1) 169.32,63.1 169.19,62.97 JDIMM1.223 ; JDIMM2.205 164.69,49.93 164.39,50.24 v2(164.05,50.24) 163.69,49.89 JDIMM2.201 ; v2(195.43,73.65) UG8.N3 v2(195.43,74.45) ; 136.69,52.2 136.69,52.43 136.94,52.69 JDIMM1.102 ; UG1.K13 v2(275.35,98.96) UG1.K14 v2(275.35,99.76) ; v2(227.74,61.91) 226.77,61.91 226.37,61.51 UG5.K14 225.79,61.51 v2(225.39,61.91) UG5.K13 ; UG6.T10 v2(237.19,54.71) ; UG6.T10 237.59,55.11 v2(237.99,54.71) ; UG6.T10 237.19,55.51 v2(237.19,55.51) 236.79,55.91 UG6.R11 ; v2(194.63,72.85) 194.23,72.45 UG8.R1 v2(193.83,72.05) v2(193.83,71.4) 193.83,70.9 193.89,70.84 CG274.2 ; 133.38,50.35 133.69,50.04 JDIMM2.89 ; UG1.G10 278.15,96.01 v2(278.55,95.61) 278.95,96.01 UG1.F10 v2(279.35,96.56) ; v2(132.19,50.4) 131.69,49.91 JDIMM2.81 ; v2(252.39,53.91) 251.99,54.31 UG3.A3 ; v2(269.15,98.16) v2(269.75,98.16) 269.94,97.97 269.94,97.97 UG1.U12 ; v2(234.79,56.31) UG6.R14 234.39,55.91 v2(233.99,55.51) ; UG3.G10 257.44,59.11 v2(257.04,58.71) 257.44,58.31 UG3.F10 v2(257.99,57.91) ; v2(197.98,102.5) 198.23,102.25 UG7.H1 UG7.H2 ; JDIMM1.77 130.69,63.39 130.3,63.79 v2(130.07,63.79) 129.65,63.79 129.49,63.62 129.49,62.92 129.69,62.72 JDIMM1.73 ; v2(124.79,55.41) 124.44,55.06 JDIMM1.52 ; v2(327.16,47.36) 327.16,47.6 326.86,47.91 JSSD1.9 ; v2(272.15,89.36) UG1.R1 v2(271.35,88.56) ; v2(161.74,63.12) 161.69,63.07 JDIMM1.193 ; CG226.2 262.2,53.2 261.95,53.46 261.95,54.55 v2(261.79,54.71) v2(261.19,54.71) 260.79,54.31 UG3.A14 ; JDIMM1.252 176.44,52.6 176.08,52.24 v2(175.42,52.24) 175.44,52.26 JDIMM1.248 ; v2(215.79,55.51) 215.39,55.91 UG5.C1 v2(214.99,55.51) v2(214.39,55.51) ; 248.37,117.1 248.37,116.85 v2(247.97,116.45) ; UG6.H13 v2(234.79,61.91) 234.39,61.51 UG6.H14 233.94,61.51 v2(233.79,61.66) 233.54,61.91 v2(232.64,61.91) 232.55,61.82 232.55,61.53 CG149.2 ; UG14.5 192.03,108.81 v2(191.97,108.87) ; v2(224.6,60.27) 224.63,60.27 UG5.H13 ; JDIMM1.234 171.94,52.68 v2(171.57,52.31) 171.17,52.31 170.94,52.54 JDIMM1.230 ; UG8.P10 195.03,79.65 v2(195.43,79.25) ; UG7.P10 v2(203.43,94.25) UG7.R11 ; UG4.U3 v2(283.31,82.12) ; UG5.A3 216.99,54.31 v2(217.39,53.91) ; UG1.C11 v2(281.75,96.56) UG1.B10 v2(282.55,95.76) ; UG1.C11 v2(280.95,96.56) UG1.D10 ; UG1.C11 v2(281.75,97.36) UG1.C12 ; v2(193.83,82.45) 194.23,82.85 UG8.R14 v2(193.83,83.25) v2(193.83,83.9) ; UG2.K2 UG2.K1 277.35,118.96 v2(277.4,119.01) ; JDIMM2.56 125.45,39.57 v2(125.36,39.49) ; JDIMM1.86 132.94,52.59 132.66,52.31 ; v2(324.74,43.55) 324.88,43.41 JSSD1.27 ; v2(279.35,73.36) 279.75,72.96 UG4.N14 v2(280.15,72.56) v2(280.15,71.91) 280.15,71.43 280.31,71.27 CG120.2 ; UG5.A12 224.19,54.31 v2(223.79,54.71) ; UG5.A12 224.19,54.31 v2(223.79,53.91) ; UG5.A12 224.59,53.91 v2(224.59,53.91) ; JDIMM2.107 138.19,49.99 137.86,50.32 v2(137.42,50.32) 137.19,50.1 JDIMM2.103 ; UG4.U1 282.95,83.45 v2(283.27,83.76) v2(283.27,84.41) ; UG8.C12 v2(204.23,81.65) ; v2(214.99,67.51) UG5.U1 ; UG6.N1 v2(245.19,57.11) ; v2(169.46,52.22) 168.94,52.73 JDIMM1.222 ; JDIMM1.168 155.44,55.28 155,55.73 153.55,55.73 v2(153.48,55.79) ; UG4.N1 v2(280.15,83.76) v2(280.15,84.41) 280.15,84.92 280.18,84.95 CG119.2 ; v2(251.59,65.11) UG3.R3 251.99,65.51 v2(252.39,65.91) UG3.R4 ; UG7.N14 v2(202.63,91.05) 203.2,90.48 CG209.2 ; JDIMM1.244 174.44,52.73 173.26,51.55 v2(173.26,51.54) ; UG6.E12 v2(235.59,64.31) ; UG3.G5 253.66,59.11 253.99,58.78 253.99,58.71 ; JDIMM2.10 113.94,41.69 113.88,41.76 v2(113.88,42.54) ; UG4.T5 v2(282.55,79.76) ; PU6200.23 224.35,150.8 v2(224.16,150.61) ; v2(275.6,107.36) 275.75,107.51 UG2.H14 275.35,108.36 v2(275.35,108.36) UG2.H13 ; v2(282.55,75.76) UG4.T10 ; UG4.T10 v2(282.55,76.56) ; UG4.T10 v2(281.75,75.76) UG4.R11 ; v2(278.55,79.76) UG4.L5 v2(278.55,80.56) UG4.M5 v2(279.35,79.76) ; JDIMM1.27 118.19,62.84 117.95,63.08 v2(117.74,63.08) 117.5,63.08 117.19,62.77 JDIMM1.23 ; UG4.R14 v2(281.75,72.56) v2(281.75,71.91) ; UG7.G5 v2(197.03,98.25) 196.63,98.65 UG7.F5 v2(196.23,99.05) ; UG3.C3 v2(251.59,55.51) ; 253.99,58.71 UG3.F5 v2(253.19,57.91) ; 253.99,58.71 v2(254.01,58.71) ; v2(249.84,61.66) 249.99,61.51 UG3.K1 ; UG4.K2 UG4.K1 277.35,83.96 v2(277.4,84.01) ; JDIMM1.172 156.44,52.25 156.45,52.25 ; UG6.U3 v2(243.59,53.91) ; v2(269.75,88.56) UG1.U1 v2(270.55,89.36) ; JSSD2.51 272.84,13.56 273.06,13.77 273.06,14.2 v2(273.11,14.25) ; v2(193.83,102.9) v2(193.83,102.25) UG7.C1 v2(194.63,101.45) ; UG3.C1 250.39,55.91 v2(249.99,55.51) v2(249.39,55.51) ; JDIMM1.93 134.69,62.94 134.56,63.08 v2(134.41,63.08) 134,63.08 133.69,62.77 JDIMM1.89 ; UG7.R12 203.83,93.05 v2(203.43,92.65) ; UG8.H13 v2(200.23,82.45) UG8.H14 199.83,83.3 v2(199.98,83.45) v2(199.98,84.6) ; UG8.F5 201.43,75.65 v2(201.03,75.25) UG8.G5 ; v2(114.07,56.62) 114.07,55.86 113.94,55.73 JDIMM1.10 ; JDIMM2.217 167.69,50.04 v2(167.53,50.2) ; UG5.N14 v2(226.19,64.31) ; v2(280.95,82.96) UG4.R1 ; UG4.R1 v2(281.75,82.96) ; v2(327.2,38.52) 327.05,38.52 326.66,38.91 JSSD1.45 ; CG98.2 281.75,106.04 v2(281.75,106.91) v2(281.75,107.56) UG2.R14 v2(281.74,108.35) ; JDIMM2.189 160.69,50.28 160.45,50.53 v2(160.34,50.53) 160.21,50.53 159.69,50.02 JDIMM2.185 ; UG1.L10 v2(274.55,96.56) UG1.M10 ; v2(245.19,65.91) UG6.C1 244.79,65.51 v2(244.39,65.91) ; PU6201.23 210.51,150.8 v2(210.51,150.8) ; 231.78,54.79 232.86,54.79 233.74,53.91 v2(233.99,53.91) 234.39,54.31 ; JDIMM2.234 171.94,39.85 171.6,39.51 v2(171.38,39.51) 171.21,39.51 170.94,39.78 JDIMM2.230 ; UG3.N1 v2(249.99,64.31) ; UG5.T5 v2(218.19,66.71) ; JDIMM1.181 158.69,63.7 v2(158.84,63.85) 159.12,63.85 159.69,63.28 JDIMM1.185 ; CG123.2 262.18,59.5 261.97,59.71 v2(261.49,59.71) 261.29,59.91 UG3.H14 UG3.H13 v2(259.59,60.31) ; UG2.R11 v2(281.75,110.76) UG2.T10 ; CG285.2 195.45,70.87 195.43,70.9 v2(195.43,71.4) v2(195.43,72.05) UG8.N1 ; v2(272.15,81.36) 271.75,81.76 UG4.C3 v2(271.35,82.16) ; CG84.2 277.75,100.26 v2(277.55,100.06) 277.35,99.86 UG1.H14 v2(277.75,98.96) UG1.H13 v2(276.95,98.16) ; UG1.E12 v2(280.15,98.16) ; v2(111.41,60.57) 111.69,60.86 JDIMM1.1 ; CG207.2 205.89,90.51 205.83,90.57 v2(205.83,91.05) UG7.U14 ; v2(193.83,91.85) 194.23,91.45 UG7.C14 v2(193.83,91.05) ; JDIMM2.247 175.19,50.13 v2(175.39,50.32) ; v2(169.23,39.51) 169.23,39.66 168.95,39.94 168.95,40.8 JDIMM2.222 ; JDIMM2.36 120.45,39.89 120.05,39.5 v2(119.41,39.5) 118.94,39.97 JDIMM2.30 ; JDIMM1.226 169.94,55.79 170.65,56.49 v2(170.8,56.49) ; CG121.2 271.4,72.01 v2(271.75,72.36) 271.75,72.96 v2(271.35,73.36) ; JTP.7 193.82,11.98 v2(194.06,11.74) 194.32,11.99 JTP.6 ; v2(173.25,39.52) 172.94,39.82 JDIMM2.238 ; v2(271.35,83.76) UG4.C1 v2(272.15,82.96) ; v2(158.12,52.35) 158.44,52.67 JDIMM1.180 ; v2(112.68,60.26) 112.69,60.28 JDIMM1.5 ; JDIMM2.184 159.44,39.8 159.74,39.5 ; v2(269.75,74.16) 270.15,74.56 UG4.A12 ; UG2.F5 v2(274.55,115.56) UG2.G5 ; UG5.T10 v2(222.99,66.71) ; PC579.2 179.41,147.59 179.41,145.41 179.18,145.11 179.18,143.86 ; UG7.L10 v2(201.03,94.25) 201.43,94.65 UG7.M10 v2(201.83,94.25) ; v2(283.35,74.16) 282.95,74.56 UG4.U12 v2(282.55,74.16) ; UG7.U3 205.56,100.39 v2(205.83,100.65) v2(206.43,100.65) ; v2(224.59,57.11) UG5.E12 ; v2(205.43,83.45) 205.43,84.47 206.14,85.18 CG208.2 ; v2(205.43,83.45) v2(206.08,83.45) ; v2(235.59,55.51) 235.99,55.91 UG6.R12 ; JDIMM2.47 123.2,49 123.2,50.07 v2(122.94,50.32) ; v2(176.03,63.87) 175.61,63.87 175.19,63.46 JDIMM1.247 ; UG7.K1 199.83,101.85 199.83,102.51 v2(199.94,102.63) ; JDIMM1.19 116.19,62.75 v2(115.94,63.01) 115.54,63.01 115.37,62.84 115.37,62.81 115.19,62.64 JDIMM1.15 ; JDIMM1.18 115.94,52.69 v2(115.57,52.32) 115.39,52.32 114.94,52.77 JDIMM1.14 ; UG5.E3 216.99,57.51 v2(217.39,57.11) ; 237.43,63.27 v2(237.19,63.51) ; 237.43,63.27 UG6.F10 ; v2(128.45,42.24) JDIMM2.68 ; UG7.E1 v2(195.43,101.45) ; v2(222.97,57.11) 222.59,56.72 UG5.D10 ; v2(237.19,57.91) UG6.M10 v2(237.99,58.71) 237.59,59.11 UG6.L10 ; v2(193.03,99.85) UG7.A3 192.63,100.25 v2(192.23,99.85) ; v2(167.9,39.52) 167.94,39.56 JDIMM2.218 ; JDIMM1.36 120.44,52.76 119.98,52.3 v2(119.64,52.3) 119.24,52.3 118.94,52.59 JDIMM1.30 ; v2(244.53,15.99) JSSD3.39 ; UG4.C12 v2(271.35,74.96) 271.75,75.36 UG4.C11 271.75,75.36 v2(272.15,75.76) UG4.D10 ; JDIMM2.244 174.44,39.86 v2(174.1,39.51) ; JDIMM1.251 176.19,63.08 v2(176.06,63.22) ; JDIMM1.44 122.44,54.68 122.31,54.82 122.31,56.16 122.57,56.43 v2(122.95,56.43) 123.12,56.43 123.51,56.04 123.51,54.82 123.44,54.75 JDIMM1.48 ; UG6.E3 v2(243.59,63.51) ; 271.75,116.76 v2(272.15,117.16) ; 271.75,116.76 UG2.C3 ; v2(269.15,90.16) v2(269.75,90.16) 270.15,90.56 UG1.U3 ; v2(261.19,65.91) UG3.R14 260.79,65.51 v2(260.39,65.91) ; JDIMM2.69 128.69,50.09 129.03,50.42 v2(129.03,50.66) ; v2(271.35,108.36) UG2.C14 271.75,107.36 v2(271.75,107.36) v2(271.75,106.71) 271.75,106.23 271.71,106.19 CG88.2 ; UG8.E1 v2(202.63,72.05) ; UG5.U3 v2(216.59,67.51) v2(216.59,68.11) ; JDIMM2.210 165.95,40.8 165.95,39.88 v2(166.3,39.52) 166.55,39.52 166.95,39.91 166.95,40.8 JDIMM2.214 ; UG5.U14 v2(226.19,67.51) ; JWLAN.55 315.82,36.11 316.28,36.57 v2(316.74,36.57) ; UG3.C11 258.39,55.91 v2(257.99,55.51) UG3.B10 257.59,55.11 v2(257.19,54.71) ; UG3.C11 v2(258.79,55.51) 259.19,55.91 UG3.C12 v2(259.59,56.31) ; v2(132.64,63.06) 132.69,63.01 JDIMM1.85 ; JDIMM1.81 131.69,63.36 132.16,63.83 v2(132.64,63.83) ; JDIMM2.86 132.94,39.82 132.68,39.55 v2(132.66,39.55) 132.34,39.55 131.94,39.94 JDIMM2.82 ; JDIMM1.107 138.19,62.95 v2(137.99,63.15) 137.56,63.15 137.19,62.79 JDIMM1.103 ; v2(233.99,57.11) 234.39,57.51 UG6.N14 ; UG8.D10 v2(203.43,80.05) UG8.C11 ; UG1.T10 v2(270.55,96.56) ; UG6.A1 v2(245.19,67.51) ; UG6.A12 v2(235.59,67.51) ; UG3.C4 253.19,55.51 v2(253.19,55.51) 253.19,55.51 UG3.B5 253.59,55.11 v2(253.99,54.71) ; UG8.H1 199.91,72.37 199.91,71.92 v2(200.03,71.8) ; v2(206.08,102.45) v2(205.43,102.45) UG7.U1 ; UG4.H13 275.75,73.76 v2(275.35,73.36) 275.75,72.96 UG4.H14 275.75,72.66 v2(275.46,72.37) 275.46,71.35 v2(275.6,71.21) ; v2(272.95,74.16) UG4.E12 ; JDIMM2.94 134.94,41.65 134.57,42.03 v2(134.12,42.03) 134.07,42.03 133.94,41.9 JDIMM2.90 ; v2(201.83,73.65) 202.23,74.05 UG8.E3 ; UG5.U12 224.37,67.29 v2(224.59,67.51) v2(224.59,68.11) ; JDIMM2.188 160.44,39.63 v2(160.32,39.51) ; v2(242.79,57.11) 243.19,57.51 UG6.N3 v2(243.59,57.11) ; UG8.K2 UG8.K1 198.23,71.85 v2(198.18,71.8) ; JDIMM1.206 164.94,52.44 164.69,52.18 164.07,52.18 v2(164.07,52.18) 163.94,52.3 JDIMM1.202 ; v2(216.59,55.51) UG5.C3 v2(216.59,56.31) ; JDIMM1.171 156.19,62.95 v2(156.34,63.1) ; v2(160.32,52.31) 160.44,52.43 JDIMM1.188 ; v2(156.23,39.55) 156.44,39.77 JDIMM2.172 ; JSSD2.71 272.94,8.56 v2(273.12,8.37) 272.8,8.06 JSSD2.73 ; v2(126.63,39.51) 126.45,39.69 JDIMM2.60 ; v2(120.59,43.63) 120.77,43.63 121.45,42.96 JDIMM2.40 ; UG1.M5 274.38,91.93 v2(274.55,91.76) UG1.L5 ; v2(155.65,50.97) 156.64,50.97 157.2,50.41 JDIMM2.175 ; v2(282.55,114.76) UG2.T5 v2(281.75,115.56) ; v2(273.75,110.76) UG2.F10 v2(274.55,110.76) UG2.G10 ; JDIMM1.2 111.94,52.33 v2(112.13,52.15) ; v2(204.23,72.05) UG8.C1 203.83,72.45 v2(204.23,72.85) ; JDIMM1.184 159.44,52.6 159.74,52.3 ; JDIMM1.9 113.69,62.65 v2(114.11,63.07) ; v2(215.79,65.91) 215.39,65.51 UG5.R1 v2(214.99,65.91) ; UG2.L5 278.55,114.76 v2(278.55,114.66) ; v2(259.59,54.71) 259.19,54.31 UG3.A12 259.19,54.31 v2(258.79,53.91) ; UG1.D10 v2(280.55,95.61) ; UG3.U1 v2(249.99,67.51) ; 134.69,50.22 JDIMM2.93 ; v2(327.05,46.41) JSSD1.15 ; UG8.F10 201.43,79.65 v2(201.03,80.05) UG8.G10 ; PU6100.23 251.59,150.93 v2(251.53,150.87) ; UG6.U12 v2(235.59,53.91) ; CG280.2 261.76,64.89 v2(261.19,64.31) UG3.N14 ; v2(205.03,92.65) 205.43,93.05 UG7.U12 205.43,93.05 v2(205.83,92.65) v2(206.43,92.65) ; UG6.H2 v2(243.59,61.11) ; UG2.T10 v2(282.55,111.56) ; UG2.T10 v2(282.55,110.76) ; JDIMM2.85 132.69,50.61 v2(132.24,51.07) ; JDIMM1.218 167.94,52.71 v2(167.55,52.32) ; v2(225.39,57.11) 225.79,57.51 UG5.E14 v2(225.39,57.91) ; UG5.D10 v2(222.04,56.71) ; JDIMM2.231 171.19,50.04 171.44,50.29 v2(171.71,50.29) 171.93,50.29 172.19,50.03 JDIMM2.235 ; UG2.H1 275.78,118.55 v2(275.55,119.01) ; v2(216.59,61.11) 216.19,61.51 UG5.K2 ; UG7.R14 203.83,91.45 v2(204.23,91.85) ; JSSD1.1 326.94,49.91 v2(327.16,49.68) 326.89,49.41 JSSD1.3 ; CG104.2 280.31,87.2 280.15,87.36 v2(280.15,87.96) v2(280.15,88.56) UG1.E1 v2(279.35,89.36) ; v2(273.12,7.56) JSSD2.75 ; JDIMM2.73 129.69,50.78 129.9,50.99 v2(130.31,50.99) 130.85,50.44 130.85,50.01 130.69,49.85 JDIMM2.77 ; v2(244.39,56.31) UG6.R1 v2(245.19,55.51) ; v2(243.59,55.51) UG6.R3 243.19,55.91 v2(242.79,55.51) UG6.R4 UG6.T5 241.59,55.11 v2(241.19,54.71) ; v2(137.41,52.31) 137.41,52.31 137.64,52.31 137.94,52.61 JDIMM1.106 ; v2(196.23,100.65) 195.83,100.25 UG7.E3 ; JDIMM1.26 117.94,52.71 117.54,52.31 v2(117.52,52.31) 117.32,52.31 116.94,52.68 JDIMM1.22 ; UG5.C12 224.19,55.91 v2(223.79,55.51) ; v2(129.56,42.6) 129.45,42.49 JDIMM2.72 ; UG5.R4 v2(217.39,65.91) 216.99,65.51 UG5.R3 v2(216.59,65.11) ; JDIMM1.205 164.69,62.95 v2(164.54,63.11) 164,63.11 163.69,62.8 JDIMM1.201 ; v2(136.02,52.28) 135.94,52.36 JDIMM1.98 ; UC1.AF14 154.78,103.91 ; v2(193.03,81.65) 192.63,81.25 UG8.U12 v2(192.23,81.65) ; 234.39,54.31 UG6.U14 ; 234.39,54.31 v2(234.79,54.71) ; JTP.14 v2(190.32,11.69) ; UG2.D10 272.35,110.96 272.35,110.96 v2(272.15,110.76) 271.75,110.36 UG2.C11 271.75,110.36 v2(271.35,109.96) UG2.C12 ; JDIMM2.22 116.94,39.87 117.31,39.51 v2(117.52,39.51) 117.94,39.93 JDIMM2.26 ; UG6.F5 v2(241.99,62.71) UG6.G5 ; JDIMM2.202 163.95,40.8 163.95,39.95 164.38,39.51 v2(164.51,39.51) 164.64,39.51 164.95,39.81 164.95,40.8 JDIMM2.206 ; JDIMM2.176 157.44,39.91 157.62,39.74 v2(157.62,39.55) ; v2(327.29,41.91) JSSD1.33 ; 172.19,62.95 JDIMM1.235 ; JDIMM2.35 120.2,49 120.2,49.99 120.47,50.27 121.03,50.27 v2(121.04,50.28) 121.2,50.13 121.2,49 JDIMM2.39 ; UG4.B5 v2(270.55,80.56) ; UG6.A3 v2(243.59,66.71) ; CG268.2 263.09,55.62 262.4,56.31 v2(261.79,56.31) v2(261.19,56.31) UG3.C14 260.79,55.91 v2(260.39,55.51) ; UG7.G10 197.43,94.8 v2(197.03,95.2) 196.63,94.8 UG7.F10 v2(196.23,94.25) ; v2(249.69,16.31) 249.69,16.25 249.02,15.58 JSSD3.21 ; CG224.2 283.66,71.05 283.35,71.36 v2(283.35,71.91) v2(283.35,72.56) UG4.U14 ; UG2.B5 v2(270.55,115.56) ; UG5.C4 217.79,55.91 v2(218.19,55.51) UG5.B5 218.59,55.11 v2(218.99,54.71) ; v2(283.48,98) 283.24,97.76 UG1.A12 v2(282.55,97.36) ; v2(158.19,50.34) 158.69,49.84 JDIMM2.181 ; v2(282.55,98.96) UG1.A14 v2(282.55,99.76) 283.39,100.61 283.39,101.94 QG2.3 ; v2(300.32,36.52) JWLAN.1 ; v2(193.03,98.25) 193.43,98.65 UG7.B5 193.43,98.65 v2(193.83,99.05) UG7.C4 ; v2(122.94,51.02) 122.76,51.02 122.2,50.46 122.2,49 JDIMM2.43 ; v2(161.62,50.23) 161.69,50.15 JDIMM2.193 ; UG7.A14 v2(192.23,91.05) ; v2(157.19,52.31) 157.44,52.57 JDIMM1.176 ; JDIMM2.243 174.19,47.88 173.79,47.47 v2(173.11,47.47) 173.11,47.89 173.19,47.98 JDIMM2.239 ; JWLAN.25 308.32,36.39 v2(308.47,36.53) ; v2(301.63,36.52) 301.82,36.33 JWLAN.7 ; UG1.N3 273.35,90.56 v2(272.95,90.16) ; v2(127.94,63.7) 128.23,63.7 128.69,63.23 JDIMM1.69 ; v2(282.55,92.56) UG1.B5 v2(281.75,91.76) UG1.C4 v2(281.75,90.96) UG1.C3 ; v2(193.03,76.05) UG8.T5 v2(193.83,75.25) UG8.R4 v2(193.83,74.45) 194.23,74.05 UG8.R3 v2(193.83,73.65) ; v2(270.53,14.66) 270.53,14.75 270.84,15.06 JSSD2.45 ; UG7.T10 204.63,94.65 v2(205.03,94.25) ; UG7.E3 v2(195.43,99.85) ; UG7.E3 v2(195.43,100.65) ; UG5.L10 v2(222.99,62.71) UG5.M10 v2(222.99,63.51) ; JDIMM2.51 124.2,49 124.2,50.05 124.43,50.29 v2(124.79,50.29) 125.39,50.29 125.69,49.98 JDIMM2.57 ; UG7.A12 v2(193.03,93.45) ; UG3.T5 v2(253.19,66.71) ; v2(241.19,57.91) 241.59,58.31 UG6.M5 v2(241.99,58.71) UG6.L5 241.51,59.11 v2(241.11,58.71) ; JDIMM2.252 176.44,39.88 176.06,39.5 v2(175.73,39.5) 175.44,39.79 JDIMM2.248 ; UG8.N12 v2(195.43,81.65) ; UG2.H2 275.94,117.37 v2(276.15,117.16) ; UG4.H2 v2(276.15,82.16) ; v2(120.59,56.43) 120.77,56.43 121.44,55.76 JDIMM1.40 ; v2(279.35,117.96) UG2.N1 v2(280.15,118.76) v2(280.15,119.41) 280.5,119.76 CG100.2 ; UG4.E3 v2(273.75,82.16) ; v2(253.53,16.31) JSSD3.3 ; UG2.U3 v2(283.35,117.16) ; 241.84,15.97 241.53,15.65 JSSD3.51 241.53,13.99 241.2,13.67 240.33,13.67 240.02,13.98 JSSD3.57 ; UG9.BE27 v2(237.47,113.05) ; UG3.E14 v2(260.39,57.91) ; JDIMM1.6 112.94,52.72 113.35,52.32 v2(113.42,52.32) ; JSSD3.45 243.02,13.96 242.2,13.13 v2(242.2,12.88) ; UG4.E1 v2(272.95,83.76) ; v2(277.81,121.28) CG86.2 ; JDIMM1.192 161.44,52.42 v2(161.51,52.36) 162.14,52.36 162.44,52.66 JDIMM1.196 ; UG4.N12 v2(280.15,74.16) ; UG6.U1 v2(245.19,53.91) ; UG1.N12 v2(273.75,98.16) ; UG1.E14 v2(280.15,98.96) ; v2(280.15,76.56) UG4.P10 ; UG8.B10 v2(205.03,80.05) ; v2(252.02,16.31) JSSD3.9 ; UG4.R12 v2(280.95,74.16)
  BOTTOM w0.356: v2(232.82,31.6) 232.84,31.62 232.84,31.93 RE401.2 ; v2(123.71,159.68) 123.95,159.92 RM87.2 ; v2(236.48,34.73) 236.74,34.47 RE397.2 ; v2(225.94,25.07) 225.71,25.3 RG22.2 ; RG3.1 200.33,124.92 v2(200.13,125.11) ; RA52.2 36.12,13.68 ; v2(175.5,153.15) 175.52,153.15 175.45,153.23 CT57.2 ; RV669.2 191.86,134.36 v2(192.41,134.91) ; RE465.2 227.15,28.46 v2(227.52,28.09) ; v2(192.36,132.71) 192.29,132.64 RV670.2 ; RG26.2 230.98,122.08 v2(231.4,121.65) ; v2(233.49,24.91) 233.43,24.91 233.05,25.29 RE485.2 ; CV1069.2 223.19,172.49 223.21,172.52 223.21,172.55 v2(223.22,172.55) ; v2(227.83,21.4) 227.83,21.58 227.15,22.27 RE453.2 ; v2(227.44,31.31) 227.44,31.32 227.15,31.61 RE472.2 ; RG518.2 v2(232.37,122.08) ; v2(236.17,166.74) 236.1,166.81 RV15.1 ; v2(205.53,170.04) 205.53,169.92 RT65.2 ; v2(179.97,153.16) 179.97,153.34 RT78.2 ; v2(233.23,21.89) 233.05,22.06 RE491.2 ; RT22.2 201.56,159.34 v2(201.59,159.31) ; CT59.2 181.24,166.37 180.77,166.37 v2(180.65,166.26) ; v2(227.76,158.91) 227.82,158.97 RV17.2 ; v2(210.51,126.5) 210.54,126.47 210.6,126.47 211.15,125.92 RG519.2 ; RG501.2 v2(216.05,110.86) ; RE479.2 v2(233.05,28.07)
  BOTTOM w0.381: CT153.2 182.53,165.59 CT72.2 181.98,166.23 v2(181.95,166.26) ; v2(34.49,3.25) 34.07,3.25 RA75.2 ; v2(175.29,161.06) 175.35,161.12 175.35,161.75 174.99,162.11 CM17.2 ; v2(231.28,34.79) 231.28,34.5 230.83,34.05 RE473.2 230.54,34 230.26,33.72 QE42.4 ; 196.16,45.58 196.16,45.63 196.23,45.7 ; RM75.1 139.84,154.66 v2(139.99,154.82) ; CT59.2 CT79.2 ; v2(179.21,175) 178.96,174.76 178.96,174.15 RT42.2 RT45.2 ; 185.05,13.97 184.64,13.57 184.64,12.55 184.45,12.36 QT2.1 ; 185.05,13.97 185.36,13.66 QT2.4 186.44,13.66 CT116.2 ; 185.05,13.97 185.05,14.51 185.25,14.71 v2(185.51,14.71) ; QM2.1 152.31,168.22 v2(152.31,168.22) ; CG219.2 227.77,65.73 227.15,65.73 ; v2(178.05,166.91) 178.01,166.95 CT62.2 ; v2(236.44,25.14) 236.74,24.85 RE490.2 236.58,24.29 236.51,24.21 236.43,24.21 236.24,24.02 236.24,24.01 QE45.4 ; 235.97,172.5 235.97,171.12 v2(235.66,170.81) ; QE39.1 227.6,22.71 227.46,22.57 227.22,22.57 RE453.2 ; v2(181.59,172.33) 181.56,172.3 CT69.2 ; QE43.1 233.56,29.19 233.29,28.91 RE479.2 ; RT39.2 177.78,161.72 177.78,159.85 176.84,158.92 176.84,158.47 v2(176.79,158.42) ; CT157.1 196.95,159.31 v2(196.58,159.31) 196.27,159.01 CT156.2 ; CT86.2 182.4,168.71 181.95,168.26 v2(181.95,168.21) ; CT80.2 CT54.2 180.65,166.26 v2(180.65,166.26) ; CG220.2 269.74,102.56 CG87.2 ; JDP.8 234.18,171.42 v2(233.86,171.1) ; v2(278.91,164.53) 278.91,165.01 CL9.2 279.12,166.15 YL1.2 ; CG132.2 249.69,52.81 v2(249.99,53.11) ; RT64.2 203.84,169.73 v2(203.15,170.42) ; v2(227.74,61.91) 227.78,61.86 227.78,61.53 CG148.2 RG134.2 ; RH30.2 219.19,33.23 v2(218.96,33.46) 219.35,33.85 RH26.2 ; CV35.2 238.1,169.12 CV34.2 v2(237.82,168.2) ; RH590.1 202.57,43.35 203.02,43.79 v2(203.02,44.38) ; UV3.8 228.79,165.52 228.27,165 228.27,164.93 227.95,164.61 227.87,164.61 v2(227.85,164.58) ; CT82.2 182.65,172.3 v2(182.62,172.34) ; v2(227.58,24.72) 227.54,24.72 227.15,25.11 RE458.2 227.43,25.48 227.9,25.95 QE40.1 ; QE29.1 233.74,32.42 233.46,32.15 RE401.2 ; v2(230.83,31.55) RE468.2 230.54,30.76 230.26,30.49 QE41.4 ; v2(169.62,157.47) 168.92,157.47 167.94,156.49 UM4.6 ; v2(180.98,172.18) 180.98,172.17 CT66.2 CT64.2 ; JLAN.15 v2(262.86,183.49) ; v2(210.94,122.7) 210.94,123.32 210.51,123.75 QG500.1 ; QG508.4 289.09,82.59 v2(289.02,82.65) ; CG1.2 197.8,106.45 197.92,106.57 198.46,106.57 v2(198.67,106.35) ; v2(239.87,34.29) 240.09,34.29 240.51,33.87 240.51,33.32 239.72,32.53 PQ8202.1 ; RT22.2 202.21,159.88 CT90.2 ; v2(191.92,47.75) 191.92,47.56 192.93,46.55 YH2.4 ; CG283.2 205.89,88.33 CG207.2 ; CU86.2 21.46,49.87 v2(21.99,49.34) ; v2(185.2,164.97) 185.15,165.01 CT55.2 ; CT48.2 175.42,172.96 v2(175.42,173.33) ; CT71.2 184.51,166.86 v2(184.56,166.9) ; v2(178.05,163.66) 178.41,163.66 178.51,163.76 CT46.2 CT78.2 ; CT47.2 178.11,168.27 v2(178.05,168.21) ; QE39.4 230.26,24.01 230.54,24.29 RE456.2 v2(230.83,25.07) ; v2(170.7,160.39) 170.54,160.55 UM4.19 ; v2(139.58,158.93) 139.35,159.16 RM64.2 ; CT38.2 189.44,166.17 v2(189.8,165.81) ; JPK.8 145.08,2.31 145.87,3.1 ; v2(281.75,73.36) 281.75,73.36 UG4.R14 ; RT19.2 184.79,163.26 v2(184.55,163.02) ; v2(186.76,168.05) 186.61,168.2 RT43.2 ; v2(183.74,172.33) 183.54,172.13 CT81.2 ; 145.87,3.1 145.58,3.39 JPK.7 JPK.9 ; 145.87,3.1 v2(145.96,3.1) ; QE40.4 230.26,27.25 230.54,27.52 RE462.2 v2(230.83,28.31) ; CT45.2 188.31,154.37 188.34,154.4 188.34,154.46 188.49,154.61 v2(188.92,154.61) ; DU20.3 14.61,66.58 14.89,66.86 14.89,67.47 15.15,67.72 v2(15.4,67.72) ; v2(202.89,17.77) 203.08,17.59 UH1.AA49 ; QE44.4 236.17,27.25 236.44,27.52 RE484.2 237.02,27.8 v2(237.02,28.25) ; CH232.2 222.49,22.44 v2(222.83,22.79) ; RE485.2 233.49,25.67 233.76,25.95 QE44.1 ; QE41.1 227.6,29.19 227.38,28.97 RE465.2 ; v2(206.74,164.2) RT63.2 ; v2(176.35,153.16) 176.83,153.16 RT24.2 ; QG507.1 v2(289.53,87.33) ; v2(213.84,160.47) 213.83,160.46 212.63,160.46 UX2.3 ; v2(181.3,163.66) 181.39,163.74 CT60.2 ; 203.86,84.38 203.86,85.03 CG243.2 ; QE29.4 236.17,33.72 236.44,34 RE397.2 ; CG81.2 v2(284.27,112.39) ; v2(198.63,92.65) 198.23,92.25 UG7.H13 ; RE491.2 233.13,22.51 233.36,22.51 233.56,22.71 QE45.1 ; RT131.1 170.75,167.14 170.57,167.31 v2(170.57,167.76) ; RM82.1 RM23.1 139.33,161.92 v2(139.71,162.3) ; 195.79,170.23 RT75.2 196.74,169.9 RT73.2 ; v2(179.35,165.61) 179.38,165.64 CT61.2 ; RT72.2 198.04,169.83 RT71.2 RT69.2 RT68.2 199.72,170.61 199.21,171.13 198.99,171.35 198.44,171.35 v2(198.41,171.38) ; v2(176.77,168.2) 176.73,168.24 RT80.2 ; v2(167.52,160.46) 167.94,160.87 UM4.15 ; RT44.2 185.36,168.87 v2(184.56,168.87) 184.11,168.87 CT84.2 ; v2(131.15,103.37) 130.69,103.37 130.43,103.1 C11.2 ; v2(170.19,8.06) 170.19,8.5 169.82,8.87 JKBBL.1 ; CT58.2 CT57.2 ; CM9.2 134.06,163.16 133.07,163.16 v2(133.03,163.12) ; v2(94.37,48.19) 94.37,48.63 94.1,48.9 PR207.2 93.93,48.95 93.02,49.85 PC210.2 ; v2(148.64,167.32) 148.65,167.31 148.73,167.31 149.12,166.92 QM2.4 ; QE43.4 236.17,30.49 236.44,30.76 RE478.2 237.05,31.08 v2(237.05,31.55) ; v2(180.76,153.16) 180.76,154.44 RT79.2 ; RM72.2 124.9,161.41 v2(124.86,161.45) ; JLAN.17 v2(243.51,183.49) ; CT37.2 v2(188.91,168.14) ; CG117.2 274.05,102.9 RG112.2 CG78.2 275.94,101.86 v2(276.49,101.31) ; v2(184.55,167.56) 184.46,167.47 CT85.2 ; QG507.4 v2(290.83,86.85) ; RE472.2 227.43,32.21 227.64,32.42 QE42.1 ; DT10.3 192.81,174.65 v2(192.88,174.59) ; CG241.2 v2(212.43,112.18) ; v2(169.22,8.56) 169.32,8.46 JKBBL.2 ; CG287.2 CG284.2 ; v2(238.06,36.3) 237.59,35.83 237.59,34.78 237.8,34.56 PQ8202.4 ; CG282.2 252.93,52.85 v2(253.19,53.11) ; CU20.2 v2(11.69,63.15) ; CG271.2 v2(248.61,52.89)
  BOTTOM w0.4: UG7.E14 195.62,91.66 195.62,91.66 v2(195.43,91.85) ; UG4.C14 271.75,72.96 ; v2(259.59,63.51) UG3.N12 v2(259.59,64.31) ; UG2.E14 273.35,107.96 UG2.E14 ; UG2.E14 v2(272.95,108.36) ; QG4.3 227.19,54.31 v2(226.79,54.71) ; UG2.E12 v2(272.95,109.16)
  BOTTOM w0.406: UM3.3 159.82,173.83 v2(159.48,173.49) ; JPK.12 143.08,2.53 142.99,2.61 v2(142.99,2.96) 142.99,3.22 142.58,3.64 JPK.13 ; RG562.2 204.15,124.9 203.44,124.18 201.9,124.18 201.41,123.69 UG10.3 201.41,122.9 v2(201.35,122.85) ; v2(151.58,176.84) 151.32,176.84 150.91,176.43 UM7.3
  BOTTOM w0.432: QG500.4 208.97,124.99 v2(208.83,124.85)
  BOTTOM w0.457: RM42.2 152.04,175.56 151.58,176.01 v2(151.58,176.14) ; v2(211.7,16.14) 211.7,15.82 211.51,15.64 CH45.2 ; v2(66.11,19.42) 65.9,19.64 C258.2 ; v2(165.88,164.84) 165.65,164.61 RM38.2 ; RG36.2 243.71,122.52 v2(243.75,122.48) ; CA12.2 36.99,33.77 36.84,33.77 v2(36.8,33.81) ; PU9000.2 30.81,17.9 v2(31.56,18.66) ; v2(193.98,112.8) 193.51,113.27 193.51,113.39 193.05,113.85 CG292.2 ; v2(192.92,60.19) 192.21,60.19 191.72,59.69 CG488.2 ; v2(191.88,46.83) 191.78,46.73 CH47.2 ; v2(191.55,121.36) 191.51,121.33 UG11.3 ; v2(201.6,158.73) 202.31,158.73 CT91.2 ; v2(197.46,107.01) CG385.2 CG323.2 196.57,106.76 CG322.2
  BOTTOM w0.508: C2507.2 65.2,12.51 v2(65.67,12.04) 66.07,12.45 C2524.2 ; v2(8.58,57.52) 8.58,57.84 9.15,58.41 10.16,58.41 CU21.2 ; JPK.21 v2(151.77,2.98) ; v2(129.6,151.74) CM35.2 ; CG288.2 192.79,113.86 CG292.2 ; PC309.2 v2(259.15,19.1) ; v2(249.46,47.36) 249.21,47.11 PC802.2 ; PC207.1 v2(93.61,41.9) ; CG388.2 199.28,85.37 v2(199.06,85.14) ; C263.2 v2(69.6,20.07) ; PR105.1 57.14,50.37 58.45,50.37 v2(58.54,50.29) ; v2(243.33,52.76) CG159.2 ; v2(37.28,18.79) 37.43,18.64 CA65.2 ; CV37.2 167.8,166.34 v2(166.69,165.23) ; v2(246.08,52.76) CG273.2 ; v2(229.95,16.94) 230.01,16.89 CH49.2 230.01,14.42 CH52.2 ; v2(211.44,156.8) 211.45,156.78 211.65,156.78 212.23,156.2 PC6214.2 212.73,156.6 212.33,157 CV1056.2 ; PC6442.2 277.72,68.57 v2(277.4,68.89) ; QX1.3 222.5,164.25 v2(221.78,163.53) ; CG116.2 285.25,72.38 v2(285.99,72.38) ; PC2.2 v2(85.2,41.2) ; PR1302.2 PC1301.2 v2(100.12,54.12) ; PC8211.2 243.2,32.17 v2(243.4,32.38) ; C633.2 258.45,16.25 v2(258.26,16.44) ; CA34.2 38.05,38.48 v2(38.05,38.22) 38.05,38.09 37.68,37.72 CA35.2 ; DU11.1 11.86,61.48 12.73,60.61 12.73,59.89 v2(12.71,59.87) ; PC578.2 PC579.2 ; PC1004.2 175.46,127.4 v2(175.46,127.78) ; v2(50.8,48.56) 50.8,48.73 49.97,49.56 PR106.1 ; PR815.1 225.17,41.96 225.17,41.29 PR808.2 PC811.2 226.65,41.28 v2(226.89,41.52) ; JTP.18 187.17,11.09 v2(187.67,11.6) ; JKB3.8 v2(60.65,6.73) ; v2(45.55,49.86) 45.3,49.61 CE84.2 ; v2(268.99,172.46) 268.27,173.18 CL40.2 ; PC101.2 54.16,51.96 v2(54.75,51.96) 55.19,51.52 PR103.1 ; PR6058.1 v2(283.96,139.75) ; PR6019.2 v2(271.28,144.77) ; v2(196.43,109.22) 196.16,109.49 CG64.2 ; v2(209.98,147.85) 209.62,148.2 PC6216.2 ; CV1068.2 223.66,171.57 223.91,171.82 v2(223.91,172.52) ; v2(105.42,29.44) 104.99,29.01 CE65.2 CE64.2 ; DA5.1 v2(22.45,18.91) ; PC806.2 235.15,45.63 235.15,44.89 v2(234.86,44.59) ; CM18.2 168.8,164.09 168.9,164.19 RM25.1 170.18,164.19 v2(170.51,164.52) ; RX1.2 v2(224.67,164.2) 223.22,162.75 CV20.2 ; JSPK.6 45.93,17.09 v2(45.58,17.43) ; CG76.1 213,117.45 v2(213.18,117.28) 214,116.45 RG98.2 214.63,116.3 214.12,115.79 213.4,115.79 v2(213.36,115.83) ; v2(123.71,158.3) 124.11,157.89 CM33.2 CM30.2 ; 237.75,52.06 238.01,52.31 v2(238.51,52.31) ; PC801.2 236.81,41.65 v2(236.55,41.91) ; UG15.4 v2(208.94,112.13) ; RT5.2 178.04,164.32 v2(178.05,164.31) ; v2(318.99,37.65) 319.92,36.72 JWLAN.69 ; PR8206.1 249.37,33.96 v2(249.82,33.51) ; CV19.2 v2(165.4,173.7) ; v2(194.67,160.87) 194.5,160.87 194.07,161.3 UT2.4 ; YG1.2 v2(210.79,116.89) ; JTRONR.14 284.87,31.65 v2(285.22,31.99) 285.45,32.23 CE86.2 ; v2(97.48,45.77) 97.48,45.84 96.97,46.35 PC213.2 PC214.2 ; PC591.2 118.44,108.58 v2(119.04,109.18) ; v2(164.22,174.5) RM6.1 ; 194.83,167.82 194.83,167.24 v2(194.69,167.1) ; 192.48,166.3 192.47,166.31 YT1.2 ; JDIMM2.261 v2(113.48,32.9) ; RM29.2 v2(165.74,163.48) ; JRTC1.4 288.89,34.64 v2(289.38,34.14) ; v2(171.9,124.67) 171.95,124.67 RH469.2 ; PR6038.1 v2(283.35,140.92) ; v2(128.33,151.74) RM70.1 ; v2(199.34,46.17) 198.76,46.17 RH581.2 RH580.2 ; v2(217.37,52.33) 217.58,52.12 CG161.2 ; CH48.2 196.15,45.57 196.16,45.58 ; v2(198.22,109.5) 197.77,109.95 CG65.2 ; CG391.2 192.76,88.7 QG8.3 192.38,87.49 v2(192.37,87.48) ; v2(208.34,121.06) 209.09,120.31 YG1.4 ; JSSD1.77 326.61,30.31 324.57,30.31 v2(324.55,30.33) ; RH472.2 152.84,123.79 v2(153.16,123.47) 153.73,124.04 RH466.2 ; RH109.2 189.47,42.93 189.46,42.92 R185.1 188.83,42.58 188.83,41.58 188.61,41.36 v2(188.61,41.11) 189.14,41.11 189.65,41.62 CH82.2 ; Q2410.3 201.19,5.94 200.36,5.11 v2(200.36,4.35) ; C2516.2 267.66,20.58 267.66,21 v2(267.64,21.02) 267.64,21.19 267.43,21.39 C2515.2 ; v2(39.06,10.6) 39.01,10.54 CA71.1 38.38,10.53 RA62.1 ; v2(161.48,175.57) 162.06,175.57 CM23.2 RM17.1 ; RG65.1 195.92,120.58 v2(196,120.66) ; v2(195.03,169.93) 195.33,170.23 195.79,170.23 ; QG3.3 282.95,67.13 v2(282.58,67.49) ; JPK.14 142.08,3.08 v2(142.06,3.1) ; v2(236.55,40.85) 236.64,40.76 PR802.2 ; v2(168.34,152.58) CM20.2 164.8,153.24 164.51,153.53 CM19.2 ; v2(131.02,139.6) 131,139.58 131,139.27 130.49,138.76 PR528.1 ; v2(285.35,84.51) 285.12,84.28 CG225.2 ; v2(213.37,107.37) CG66.2 ; DU1.1 19.76,38.15 19.25,38.66 v2(19.25,38.83) ; PR586.2 155.38,151.31 155.38,151.3 PH503.2 156.18,150.95 v2(156.55,151.31) ; v2(48.15,47.29) 48.15,47.94 48.51,48.3 PR107.2 ; JHDD.33 122.4,9.58 v2(123.07,9.58) ; CG284.2 194.59,103.65 194.03,103.09 194.02,103.09 v2(193.83,102.9) ; JHDD.31 v2(109.95,9.8) ; v2(17.24,3.6) 16.14,4.69 11.44,4.69 10.82,5.31 JACK1.7 ; UX3.2 242.64,166.34 v2(242.64,167.44) ; v2(254.32,16.31) 255.12,15.51 JSSD3.76 ; v2(24.48,51.27) 23.78,51.97 CU65.2 ; CG228.2 263.03,52 v2(263.09,52.06) ; CA2.2 v2(34.77,27.41) ; v2(239.86,46.29) 240.34,46.29 PC817.2 ; JELC1.8 v2(171.9,28.12) ; JSPK.8 42.43,11.04 v2(41.66,11.8) ; v2(284.11,110.39) 284.53,109.97 CG221.2 ; 190.89,168.29 190.89,167.66 YT1.4 ; v2(125.5,121.15) 125.49,121.14 PR5008.2 125.5,120.39 PC590.2 ; v2(43.53,53.47) 44.05,52.95 JTRONL.13 ; v2(227.95,45.4) 228.2,45.15 PC822.2 ; v2(200.92,109.08) 201.32,108.69 RG89.1 ; RH213.2 220.56,42.35 RH216.2 220.53,42.06 UH3.3 220.02,41.28 220.08,41.21 220.18,41.21 220.55,40.84 v2(220.55,40.12) 220.55,39.04 CH36.2 ; JSPK.7 v2(55.03,8.75) ; CG368.2 228.61,65.65 CG219.2 ; v2(101.09,28.95) CE20.2 ; PC6009.2 v2(272.42,145.09) ; v2(212.86,46.42) 212.86,45.81 CH175.2 ; C265.2 58.53,18.76 C264.2 v2(58.53,17.02) ; PC5003.2 v2(125.93,114.53) ; UG13.4 209.56,106.1 208.86,106.8 v2(208.86,106.96) ; CM17.2 CM16.2 ; v2(269.1,170.24) UL2.2 ; v2(240.04,52.31) 240.55,52.31 CG223.2 ; v2(232.82,56.98) 232.82,57.73 232.46,58.09 CG382.2 ; v2(243.25,39.73) 243.21,39.69 PC8216.2 ; CG392.2 206.14,87.54 CG283.2 ; CG240.2 190.94,107.18 v2(190.19,107.92) ; v2(172.16,90.8) 172.79,91.43 172.79,91.47 172.88,91.56 RH148.1 ; PC3.2 v2(75.57,32.73) ; v2(217.24,157.4) 216.92,157.4 216.42,156.89 PC6222.2 ; C260.2 73,13.41 C261.2 73,11.71 72.2,10.91 v2(71.45,10.91) ; v2(114.94,9.26) 114.94,8.52 JHDD.32 ; v2(197.32,85.14) RG154.2 CG265.2 ; v2(208.99,8.35) JKB.32 ; CL42.2 v2(266.15,171.17) ; CT103.2 195.03,164.09 v2(194.75,164.37) 194.36,163.97 CT98.2 ; v2(42.3,8.94) 42.12,8.94 RA73.2 ; PC111.2 v2(55.13,43.3) ; CG383.2 232,62.55 v2(232.64,61.91) ; CA4.2 31.72,36.89 v2(31.71,36.88) ; PC1003.2 PC1006.2 179.27,127.4 v2(179.27,127.78) ; v2(256.17,53.2) 255.91,52.95 CG227.2 ; CG115.2 284.19,75.56 283.98,75.76 v2(283.4,75.76) ; JTRONR.6 278.77,31.58 v2(279.11,31.23) 279.57,31.68 JTRONR.7 ; PC824.2 PC820.2 225.37,49.48 v2(225.37,49.9) ; UE9.2 101.76,30.53 v2(101.98,30.75) ; v2(126.09,135.56) 126.09,136.17 PR512.1 ; v2(215.15,15.18) 215.15,14.57 CH53.2 214.38,14.23 CH46.2 ; v2(37.43,16.06) CA64.2 ; v2(11.92,67.06) 11.92,66.95 11.9,66.92 11.9,66.49 11.27,65.87 CU18.2 ; v2(161.39,166.69) 161.39,166.41 160.98,166.01 CV372.2 ; v2(294.54,38.03) 295.24,37.32 JRTC1.3 ; CU40.2 12.12,51.51 v2(10.93,52.7) ; v2(242.24,36.54) 241.68,36.54 PC8205.2 ; CG61.2 193.21,123.19 193.85,122.56 v2(193.85,122.14) ; CE19.2 105.14,27.21 v2(105.52,27.59) ; CL7.2 266.4,161.39 266.4,160.46 v2(266.71,160.15) ; RV664.2 227.73,160.46 227.73,161.88 v2(227.76,161.9) ; C3.2 126.9,105.66 PC599.2 v2(125.51,105.66) ; CT92.2 CT93.2 206.33,163.16 206.84,162.65 v2(206.84,162.56) ; v2(273.04,32.12) 273.47,31.69 JTRONR.13 ; CG98.2 282.84,105.46 v2(283.07,105.69) ; C2525.2 61.26,19.4 v2(60.74,18.88) ; CG281.2 284.81,78.41 v2(284.81,78.1) ; JDIMM1.262 176.12,69.7 v2(175.09,70.73) ; PR805.2 236.93,43.42 v2(236.48,43.87) ; v2(213.18,120.26) 212.91,120.53 CG75.1 ; v2(99.82,17.24) UE2.4 ; PR811.2 223.47,45.09 PC813.2 PC812.2 224.86,44.25 PC821.2 224.16,43.55 224.16,42.92 v2(224.04,42.79) ; JKBBL.21 v2(171.47,10.4) ; RV665.2 223.97,160.46 223.47,159.95 v2(223.47,158.61) ; CG133.2 258.45,52.78 258.64,52.97 v2(258.64,53.2) ; v2(150.12,171) 149.61,171.51 CM70.2 ; v2(249.56,37.77) 249.56,36.97 249.37,36.78 PC8200.2 ; JTRONL.14 v2(33.37,54.16) ; RH149.1 RH150.1 167.88,91.65 v2(167.59,91.94) ; PC807.2 v2(123.53,115.88) ; RG92.1 v2(214.07,118.23) ; JHDD.34 127.07,9.26 v2(126.69,9.64) ; PC6443.2 277.66,67.36 v2(277.4,67.62) ; v2(51.83,51.88) 51.83,51.44 PR104.2 ; CA12.2 CA13.2 ; CA41.2 38.99,31.48 v2(39.01,31.46) ; CT99.2 195.27,160.23 v2(194.73,160.23) ; CLRP1.2 v2(174.67,36.35) ; PC4.2 v2(74.68,32.74) ; v2(196.28,46.47) 196.28,45.82 196.25,45.79 196.25,45.72 196.23,45.7 ; DT15.1 v2(207.53,170.49) ; 19,13.64 15.25,17.39 11.31,17.39 10.82,17.88 JACK2.7 ; CG387.2 199.25,89.39 v2(199.13,89.5) ; C2523.2 63.39,12.46 v2(63.85,12) 64.28,12.44 C2506.2 ; PC8222.2 239.72,31.55 239.78,31.61 v2(239.79,31.61) ; PC6227.2 211.62,143.95 v2(211.98,144.31) ; v2(121.23,104.86) PC596.2 PC597.2 ; JKB3.10 v2(66.86,9.73) ; PC1303.2 99.7,40.24 100.21,39.73 v2(100.31,39.73) ; JRTC1.2 291.44,37.74 v2(291.66,37.52) ; QV2.3 149.63,163.16 149.63,163.88 149.51,164 v2(149.51,164.34) ; CM36.2 130.69,163.06 v2(130.09,163.06) ; CL41.2 271.29,173.93 v2(271.73,174.36) ; PR5015.2 v2(122.83,122.78) ; v2(300.3,37.52) 299.73,37.52 299.22,37.01 JWLAN.68 ; RG87.1 202.51,111.24 203.04,110.71 v2(203.27,110.71) ; v2(35.11,3.55) 35.11,4.38 34.92,4.58 CA255.2 ; v2(290.94,80.37) 290.62,80.04 QG508.1 ; PC6001.2 268.89,139.44 PR6005.1 268.3,139.44 v2(268.11,139.25) ; v2(207.49,162.83) 207.76,162.83 208.14,163.21 CX2.2 ; v2(26.3,16.69) 26.55,16.95 27.38,16.95 27.83,16.49 PC9002.2 PC9001.2 ; C262.2 v2(69.71,19.01) ; v2(125.99,125.03) 125.82,124.87 PR5018.1 ; PR5034.1 125.79,117.3 125.91,117.3 126.53,116.68 126.73,116.68 126.73,116.23 126.69,116.2 126.69,116.17 v2(126.56,116.04) ; PC212.2 v2(94.94,41.9) ; v2(114.25,69.27) 113.81,69.7 JDIMM1.261 ; RG576.2 198.27,117.02 v2(198.13,116.88) 197.66,116.41 CG386.2 ; v2(226.51,9.2) 226.51,9.13 225.73,8.35 JKB.31 ; v2(215.53,159.41) 215.01,159.41 RX8.2 ; v2(198.07,11.36) 198.97,10.45 JTP.17 ; v2(31.28,38.59) CA7.2 32.07,38.48 RA22.2 ; CE61.2 v2(220.8,166.65) ; v2(328.65,50.52) 328.17,51.01 JSSD1.76 ; CG256.2 v2(194,86.03) ; JPK.22 v2(135.91,2.98) ; v2(36.52,28.69) 37.41,28.69 CA258.2 ; PR6060.1 v2(278.44,136.07) ; v2(182.38,49.72) 182.38,49.71 182.67,49.71 182.85,49.53 C2498.2 ; CE87.2 v2(276.35,35.06) ; CG276.2 191,78.08 191.58,78.65 v2(191.58,79.62) ; JDIMM2.262 176.52,32.9 v2(175.97,33.46) ; PC6012.1 v2(274.2,147.44) ; PR6062.1 v2(283.96,136.06) ; CM34.2 v2(140.03,157.34) ; CH181.2 v2(202.89,14.41) ; v2(131.36,151.5) 131.12,151.74 CM32.2 ; 187,166.3 187,166.59 v2(186.57,167.03) ; v2(234.07,169.54) 234.07,168.71 233.84,168.48 RV18.1 CX1.2 ; YL1.4 v2(282.49,167.92) ; JKB3.7 v2(61.43,8.5) ; v2(124.38,151.73) RM84.1 ; CG208.2 CG390.2 ; UH4.4 221.99,19.73 v2(222.06,19.66) ; PR6000.2 v2(267.92,144.21) ; JKBBL.22 v2(158.67,10.15) ; PR6059.1 v2(283.96,137.9) ; PC598.2 v2(126.18,107.79) ; CA1.2 34.77,25.78 34.5,25.51 v2(34.5,25.07) ; v2(131.14,11.67) 130.32,10.86 JHDD.35 ; v2(274.39,6.46) JSSD2.77 ; PR6056.1 279.66,135.98 v2(279.52,136.12) ; v2(35.19,18.79) 34.74,18.34 RA67.2 CA74.2 ; YH2.2 v2(194.08,48.25) ; PC6008.2 v2(271.28,136.74) ; v2(274.41,27.16) JSSD2.76 ; DA6.1 v2(21.94,34.88) ; v2(164.28,27.3) 164.69,26.89 JELC1.7 ; PR6057.1 v2(280.87,136.07) ; PC6000.1 v2(267.92,145.1) ; PR6427.1 v2(247.34,120.89) ; CT104.2 v2(203.15,170.42) ; CE22.2 v2(103.4,30.57) ; PC1.2 v2(84.1,41.22) ; v2(137.6,151.41) RM62.1 ; v2(171.26,152.63) RM21.1
  vias: v1(173.45,141.41) v2(1.5,73.63) v2(1.5,72.36) v2(1.5,69.82) v2(1.53,47.55) v2(1.72,49.46) v2(1.91,55.01) v2(2.46,74.47) v2(2.49,32.4) v2(2.71,68.15) v2(2.68,46.94) v2(2.96,71.6) v2(3.14,54.69) v2(3.14,49.91) v2(3.73,74.47) v2(3.7,53.55) v2(3.7,51.05) v2(3.95,32.4) v2(4.02,73.43) v2(4.02,69.77) v2(4.14,46.94) v2(4.46,52.6) v2(5.52,54.43) v2(5.52,50.77) v2(6.12,73.43) v2(6.12,69.77) v2(7.18,71.6) v2(7.62,54.43) v2(7.62,50.77) v2(8.68,52.6) v2(8.9,46.94) v2(9.15,32.46) v2(9.23,62.72) v2(9.25,61.27) v2(10.36,46.94) v2(10.61,32.46) v2(12.63,74.17) v2(13.28,43.84) v2(13.28,42.57) v2(13.28,41.3) v2(13.28,40.03) v2(13.28,38.76) v2(13.28,37.49) v2(13.28,36.22) v2(13.41,45.11) v2(13.47,57.14) v2(13.47,56.44) v2(14.21,72.65) v2(15.27,71.59) v2(15.58,65.89) v2(16.4,53.74) v2(16.4,52.54) v2(16.7,58.73) v2(16.7,2.23) v2(17,69.72) v2(17.14,67.19) v2(17.14,65.92) v2(17.14,64.65) v2(17.14,63.38) v2(17.14,62.11) v2(17.18,60.84) v2(17.79,59.64) v2(18.17,54.91) v2(18.17,53.74) v2(18.17,52.54) v2(18.17,51.37) v2(19.24,2.23) v2(19.66,13.3) v2(19.88,58.86) v2(19.94,53.74) v2(19.94,52.54) v2(19.96,6) v2(20.51,2.23) v2(20.86,15.39) v2(20.86,11.21) v2(21.02,7.83) v2(21.02,4.17) v2(21.78,2.23) v2(21.92,58.86) v2(22.58,45.11) v2(23.05,2.23) v2(23.1,48.51) v2(23.12,7.83) v2(23.12,4.17) v2(23.28,15.39) v2(23.28,11.21) v2(23.95,58.86) v2(24.2,6) v2(24.32,2.23) v2(24.51,13.31) v2(25.01,2.23) v2(25.96,55.8) v2(26.08,49.29) v2(26.08,48.22) v2(26.08,47.15) v2(26.42,42.6) v2(26.73,41.55) v2(26.86,2.23) v2(27.02,57.63) v2(27.02,53.97) v2(27.23,49.29) v2(27.23,48.22) v2(27.23,47.15) v2(28.03,43.04) v2(28.13,2.23) v2(29.12,57.63) v2(29.12,53.97) v2(29.4,2.23) v2(29.71,49.98) v2(30.15,34.38) v2(30.18,55.8) v2(30.67,2.23) v2(30.83,57.13) v2(31.76,46.16) v2(31.76,45.52) v2(31.94,2.23) v2(31.98,13.68) v2(31.98,11.61) v2(31.98,9.54) v2(32.22,32.31) v2(33.22,46.16) v2(33.22,45.52) v2(33.21,2.23) v2(33.54,51.24) v2(34.05,13.68) v2(34.05,11.61) v2(34.05,9.54) v2(34.29,34.38) v2(34.29,30.24) v2(34.48,2.23) v2(35.44,55.36) v2(35.75,2.23) v2(35.81,28.82) v2(36.12,13.68) v2(36.12,11.61) v2(36.12,9.54) v2(37.02,2.23) v2(37.47,55.36) v2(37.6,21.58) v2(37.6,20.95) v2(38.13,26.34) v2(38.24,21.58) v2(38.24,20.95) v2(38.29,2.23) v2(38.68,52.38) v2(38.87,21.58) v2(38.87,20.95) v2(38.98,2.23) v2(39.38,52.38) v2(39.51,55.36) v2(39.55,2.38) v2(40.07,3.53) v2(40.4,4.28) v2(41.1,5.86) v2(41.54,55.36) v2(42.04,6.71) v2(42.53,29.7) v2(42.53,29.06) v2(42.53,28.43) v2(42.81,17.73) v2(43.16,29.7) v2(43.16,29.06) v2(43.16,28.43) v2(43.27,55.07) v2(43.31,6.73) v2(44.58,6.73) v2(44.97,54.54) v2(45.85,6.73) v2(46.47,53.83) v2(47.12,6.73) v2(47.66,52.91) v2(47.57,34.28) v2(47.98,34.71) v2(48.27,36.45) v2(48.23,35.87) v2(48.23,35.28) v2(48.37,34.26) v2(48.39,6.73) v2(48.8,36.69) v2(48.8,36.06) v2(48.82,35.43) v2(48.8,34.73) v2(49.26,52.86) v2(49.31,37.65) v2(49.31,37.01) v2(49.31,36.38) v2(49.31,35.74) v2(49.31,35.04) v2(49.31,34.41) v2(49.66,6.73) v2(49.86,38.03) v2(49.86,37.39) v2(49.86,36.76) v2(49.86,36.12) v2(49.86,35.42) v2(49.86,34.79) v2(49.97,45.49) v2(50.46,6.73) v2(51.16,52.86) v2(51.15,6.73) v2(52.2,6.73) v2(53.07,52.86) v2(53.04,44.48) v2(53.24,47.48) v2(53.47,6.73) v2(53.86,48.1) v2(53.86,47.48) v2(53.86,46.85) v2(54.49,47.48) v2(54.74,6.73) v2(54.97,52.86) v2(56.22,11.95) v2(56.22,11.37) v2(56.27,45.06) v2(56.37,25.1) v2(56.37,22.96) v2(56.8,5.67) v2(56.88,52.86) v2(57.44,24.03) v2(57.99,5.23) v2(58.51,25.1) v2(58.51,22.96) v2(58.78,52.86) v2(59.16,22.37) v2(59.26,5.23) v2(59.75,22.37) v2(60.21,44.96) v2(60.53,5.23) v2(60.69,52.86) v2(60.79,27.08) v2(61.48,27.42) v2(61.48,26.79) v2(61.8,5.23) v2(61.93,22.08) v2(62.11,27.42) v2(62.11,26.79) v2(62.11,26.15) v2(62.59,52.86) v2(62.75,27.42) v2(62.75,26.79) v2(62.75,26.15) v2(63.07,5.23) v2(63.75,53.06) v2(64.34,5.23) v2(65.61,5.23) v2(65.69,53.34) v2(66.87,7.17) v2(66.87,6.4) v2(66.88,5.23) v2(67.6,53.34) v2(67.82,50.03) v2(67.95,52.25) v2(67.95,51.62) v2(68.15,5.23) v2(68.59,52.25) v2(68.59,51.62) v2(69.22,52.25) v2(69.22,51.62) v2(69.42,5.23) v2(69.5,53.34) v2(69.86,52.25) v2(69.86,51.62) v2(70.28,6.16) v2(70.49,52.25) v2(70.49,51.62) v2(71.11,7.12) v2(71.23,53.34) v2(71.19,52.25) v2(71.19,51.62) v2(71.83,52.25) v2(71.83,51.62) v2(71.82,7.23) v2(72.46,52.25) v2(72.46,51.62) v2(73.14,53.34) v2(73.1,52.25) v2(73.1,51.62) v2(73.62,20.02) v2(73.65,7.23) v2(73.73,52.25) v2(73.73,51.62) v2(74.37,52.25) v2(74.37,51.62) v2(74.92,7.23) v2(75.04,53.34) v2(75,52.25) v2(75,51.62) v2(75.22,20.42) v2(75.64,52.25) v2(75.64,51.62) v2(75.82,50.02) v2(76.19,7.23) v2(76.44,20.3) v2(76.7,20.87) v2(76.82,19.73) v2(76.95,53.34) v2(77.08,20.3) v2(77.33,20.87) v2(77.46,19.73) v2(77.46,7.23) v2(77.71,20.3) v2(77.97,20.87) v2(78.1,19.73) v2(78.35,20.3) v2(78.6,20.87) v2(78.73,19.73) v2(78.73,7.23) v2(78.85,53.34) v2(78.98,20.3) v2(79.24,20.87) v2(79.37,19.73) v2(79.44,7.23) v2(79.62,20.3) v2(80.76,53.34) v2(80.78,21.67) v2(81.21,22.1) v2(81.27,7.23) v2(82.54,7.23) v2(82.66,53.34) v2(83.81,7.23) v2(84.02,35.65) v2(84.46,35.21) v2(84.57,53.34) v2(84.53,36.03) v2(84.91,35.59) v2(84.91,34.76) v2(85.08,7.23) v2(85.35,35.14) v2(85.35,34.32) v2(85.8,34.7) v2(86.35,7.23) v2(86.47,53.34) v2(86.7,42.14) v2(86.7,41.13) v2(86.7,40.11) v2(86.7,39.09) v2(87.62,7.23) v2(88.27,51.62) v2(88.33,7.23) v2(88.38,53.34) v2(88.91,51.62) v2(89.8,58.43) v2(89.91,59.7) v2(90.16,7.23) v2(90.76,58.7) v2(90.88,28.82) v2(90.88,28.12) v2(91.43,7.23) v2(91.58,28.82) v2(91.58,28.12) v2(91.82,60.53) v2(91.82,56.87) v2(92.07,45.8) v2(92.27,28.82) v2(92.27,28.12) v2(92.69,46.42) v2(92.69,45.18) v2(92.7,7.23) v2(92.97,28.82) v2(92.97,28.12) v2(93.32,45.8) v2(93.92,60.53) v2(93.92,56.87) v2(93.97,7.23) v2(93.99,34.53) v2(93.99,33.9) v2(93.99,33.26) v2(94.31,36.31) v2(94.31,35.68) v2(94.31,35.04) v2(94.62,34.53) v2(94.62,33.9) v2(94.62,33.26) v2(94.94,36.31) v2(94.94,35.68) v2(94.94,35.04) v2(94.98,58.7) v2(95.26,34.53) v2(95.26,33.9) v2(95.26,33.26) v2(95.24,7.23) v2(96.45,6.85) v2(96.73,61.95) v2(96.92,5.66) v2(98.61,62.36) v2(98.69,43.04) v2(98.69,42.35) v2(99.05,71.54) v2(99.05,70.27) v2(99.05,67.73) v2(99.05,66.46) v2(99.05,65.19) v2(99.05,63.92) v2(99.08,72.81) v2(99.93,73.76) v2(99.96,8.3) v2(100.78,74.69) v2(100.88,48.22) v2(101.02,10.13) v2(101.02,6.47) v2(101.62,75.65) v2(101.92,5.23) v2(102.43,76.63) v2(103.12,10.13) v2(103.13,6.47) v2(103.19,5.23) v2(103.96,78.65) v2(104.18,8.3) v2(105.39,80.75) v2(105.8,15.17) v2(106.06,81.83) v2(106.7,82.93) v2(107,5.23) v2(107.31,84.04) v2(107.58,17.66) v2(107.68,15.19) v2(107.89,85.17) v2(108.27,5.23) v2(108.96,87.48) v2(109.45,88.65) v2(109.54,5.23) v2(109.9,89.83) v2(110.33,91.03) v2(110.72,92.24) v2(110.81,5.23) v2(111.08,93.46) v2(111.41,94.68) v2(111.96,97.16) v2(112.06,46.56) v2(112.06,45.29) v2(112.08,5.23) v2(112.19,98.41) v2(112.39,99.67) v2(112.55,100.93) v2(112.77,103.46) v2(112.67,102.19) v2(112.68,58.97) v2(112.68,57.7) v2(112.68,56.43) v2(112.85,164.41) v2(112.85,163.14) v2(112.85,161.87) v2(112.85,160.6) v2(112.85,159.33) v2(112.85,158.06) v2(112.85,155.52) v2(112.85,154.25) v2(112.85,152.98) v2(112.85,151.71) v2(112.85,150.44) v2(112.85,149.17) v2(112.85,147.9) v2(112.85,145.36) v2(112.85,142.82) v2(112.85,141.55) v2(112.85,140.28) v2(112.85,139.01) v2(112.85,137.74) v2(112.85,135.2) v2(112.85,133.93) v2(112.85,132.66) v2(112.85,131.39) v2(112.85,130.12) v2(112.85,128.85) v2(112.85,127.58) v2(112.85,125.04) v2(112.85,123.77) v2(112.85,122.5) v2(112.85,121.23) v2(112.85,119.96) v2(112.85,118.69) v2(112.85,117.42) v2(112.85,114.88) v2(112.85,113.61) v2(112.85,112.34) v2(112.85,111.07) v2(112.85,109.8) v2(112.85,108.53) v2(112.85,107.26) v2(112.83,104.73) v2(113.35,5.23) v2(113.9,165.46) v2(114.01,46.49) v2(114.01,44.59) v2(114.07,59.29) v2(114.07,57.39) v2(114.62,5.23) v2(115.34,58.97) v2(115.34,57.7) v2(115.34,56.43) v2(115.34,46.17) v2(115.34,44.9) v2(115.34,43.63) v2(115.39,5.23) v2(115.81,165.46) v2(117.16,5.23) v2(117.38,58.97) v2(117.38,57.7) v2(117.38,56.43) v2(117.63,46.17) v2(117.63,44.9) v2(117.63,43.63) v2(117.71,165.46) v2(118,117.35) v2(118.43,5.23) v2(118.59,117.35) v2(119.04,43.32) v2(119.19,56.12) v2(119.62,165.46) v2(119.7,5.23) v2(120.01,113.6) v2(120.59,58.97) v2(120.59,57.7) v2(120.59,46.17) v2(120.59,44.9) v2(120.89,122.98) v2(120.89,122.39) v2(120.89,121.81) v2(120.97,5.23) v2(121.31,120.46) v2(121.52,165.46) v2(121.61,118.1) v2(121.68,115.74) v2(121.89,120.48) v2(122.02,144.82) v2(122.02,142.7) v2(122.02,140.58) v2(122.24,5.23) v2(122.92,164.77) v2(122.95,58.97) v2(122.95,57.7) v2(122.95,46.17) v2(122.95,44.9) v2(123,134.45) v2(123.51,5.23) v2(123.81,134.45) v2(124.13,164.17) v2(124.14,144.82) v2(124.14,142.7) v2(124.14,140.58) v2(124.63,46.49) v2(124.63,44.59) v2(124.69,59.29) v2(124.69,57.39) v2(124.78,5.23) v2(125.4,164.17) v2(125.55,5.23) v2(126.26,144.82) v2(126.26,142.7) v2(126.26,140.58) v2(126.18,100.68) v2(126.51,58.97) v2(126.51,57.7) v2(126.51,56.43) v2(126.63,101.13) v2(126.63,46.17) v2(126.63,44.9) v2(126.63,43.63) v2(126.67,164.17) v2(127.32,5.23) v2(127.94,164.17) v2(127.9,107.31) v2(128.34,156.46) v2(128.28,107.78) v2(128.35,102.85) v2(128.59,5.23) v2(128.99,109.76) v2(129.02,58.97) v2(129.02,57.7) v2(129.02,56.43) v2(129.02,46.17) v2(129.02,44.9) v2(129.02,43.63) v2(129.21,164.17) v2(129.28,24.3) v2(129.86,5.23) v2(130.29,58.02) v2(130.29,56.12) v2(130.48,164.17) v2(130.51,95.11) v2(130.57,96) v2(130.82,47.62) v2(130.8,45.22) v2(130.8,43.32) v2(131.13,5.23) v2(131.75,164.17) v2(131.86,91.94) v2(132.09,162.47) v2(132.17,58.97) v2(132.17,57.7) v2(132.17,56.43) v2(132.17,46.17) v2(132.17,44.9) v2(132.17,43.63) v2(132.29,149.69) v2(132.4,5.23) v2(133.02,164.17) v2(132.99,93.3) v2(133.17,5.17) v2(133.79,148.72) v2(134.29,164.17) v2(134.38,94.42) v2(135.02,0.43) v2(135.11,150.87) v2(135.1,91.7) v2(135.08,89.9) v2(135.25,43.69) v2(135.38,159.5) v2(135.38,156.46) v2(135.56,164.17) v2(136.07,93.31) v2(136.18,163.53) v2(136.29,0.43) v2(136.66,46.16) v2(136.66,44.84) v2(136.66,43.57) v2(136.83,164.17) v2(136.99,162.69) v2(137.09,91.61) v2(137.5,161.17) v2(137.56,0.43) v2(137.62,59.25) v2(137.61,57.96) v2(137.61,56.5) v2(137.61,55.16) v2(137.99,104.62) v2(138.1,164.17) v2(138.13,46.12) v2(138.12,44.83) v2(138.4,92.89) v2(138.57,105.8) v2(138.83,0.43) v2(139.08,115.11) v2(139.3,117.13) v2(139.28,112.13) v2(139.37,164.17) v2(139.72,115.11) v2(139.72,90.94) v2(139.72,46.05) v2(139.72,44.75) v2(139.72,43.38) v2(139.85,58.85) v2(139.85,57.55) v2(140.06,117.14) v2(140.03,92.76) v2(140.16,108.38) v2(140.16,107.11) v2(140.1,0.43) v2(140.49,106.08) v2(140.64,164.27) v2(141.13,106.08) v2(141.37,0.43) v2(141.55,169.01) v2(141.55,167.74) v2(141.55,166.47) v2(141.5,165.2) v2(141.56,115.11) v2(141.54,112.13) v2(141.59,185.98) v2(141.59,184.08) v2(141.59,182.17) v2(141.59,180.27) v2(141.59,178.36) v2(141.64,117.14) v2(141.59,46.19) v2(141.59,44.81) v2(141.61,43.59) v2(141.72,58.99) v2(141.69,57.61) v2(142.19,115.11) v2(142.35,146.2) v2(142.46,173.3) v2(142.4,117.15) v2(142.66,187.07) v2(142.64,0.43) v2(142.86,170.59) v2(142.82,148.56) v2(142.83,105.8) v2(143.07,90.22) v2(143.07,88.95) v2(143.2,147.42) v2(143.2,145.85) v2(143.52,175.13) v2(143.52,171.47) v2(143.85,187.1) v2(143.91,0.43) v2(144.03,125.54) v2(143.97,117.14) v2(144.03,115.11) v2(143.97,111.62) v2(143.98,108.52) v2(143.98,107.25) v2(144.04,59.03) v2(144.04,57.76) v2(144.04,56.52) v2(144.04,55.25) v2(143.98,46.23) v2(143.98,44.96) v2(143.98,43.72) v2(144.13,170.59) v2(144.45,93.76) v2(144.43,91.16) v2(144.5,147.42) v2(144.5,145.85) v2(144.61,125.54) v2(144.67,115.11) v2(144.79,117.14) v2(145.2,125.54) v2(145.18,0.43) v2(145.43,105.8) v2(145.62,175.13) v2(145.62,171.47) v2(145.62,58.02) v2(145.62,56.75) v2(145.62,54.84) v2(145.62,46.87) v2(145.62,44.96) v2(145.62,43.69) v2(145.75,187.1) v2(145.8,147.42) v2(145.8,145.85) v2(145.78,125.54) v2(146.07,105.8) v2(146.16,89.29) v2(146.16,87.38) v2(146.4,117.14) v2(146.45,115.11) v2(146.41,111.52) v2(146.45,0.43) v2(146.57,144.89) v2(146.57,144.31) v2(146.57,143.72) v2(146.57,143.14) v2(146.57,142.56) v2(146.72,175.83) v2(146.72,174.56) v2(146.68,173.3) v2(147.05,150.55) v2(147.02,108.45) v2(147.02,107.18) v2(147.17,145.57) v2(147.16,144.89) v2(147.16,144.31) v2(147.16,143.72) v2(147.16,143.14) v2(147.16,142.56) v2(147.13,117.15) v2(147.15,115.14) v2(147.3,92.02) v2(147.3,90.05) v2(147.46,16.14) v2(147.46,15.51) v2(147.66,187.1) v2(147.66,185.57) v2(147.63,150.55) v2(147.75,145.57) v2(147.74,144.89) v2(147.74,144.31) v2(147.74,143.72) v2(147.74,143.14) v2(147.74,142.56) v2(147.74,141.97) v2(147.74,141.39) v2(147.72,0.43) v2(147.84,105.84) v2(147.95,119.73) v2(147.95,118.41) v2(147.96,117.15) v2(148.22,16.14) v2(148.22,15.51) v2(148.28,145.85) v2(148.27,145.19) v2(148.27,144.6) v2(148.27,144.02) v2(148.37,143.13) v2(148.37,142.54) v2(148.37,141.96) v2(148.37,141.38) v2(148.44,105.84) v2(148.47,46.74) v2(148.47,45.21) v2(148.47,43.69) v2(148.73,117.14) v2(148.86,59.54) v2(148.86,58.01) v2(148.86,56.49) v2(148.86,54.96) v2(148.93,185.57) v2(148.93,111.89) v2(148.93,110.34) v2(149.01,113.24) v2(148.99,0.43) v2(149.46,126.04) v2(149.39,108.45) v2(149.39,107.18) v2(149.37,81.27) v2(149.37,80.03) v2(149.37,78.76) v2(149.5,117.13) v2(149.6,114.01) v2(149.92,146.2) v2(150,129.78) v2(150.2,185.57) v2(150.26,105.84) v2(150.26,0.43) v2(150.39,148.56) v2(150.58,129.78) v2(150.77,147.42) v2(150.77,145.86) v2(150.81,81.18) v2(150.81,80.59) v2(150.81,80.01) v2(150.81,79.43) v2(150.81,76.92) v2(150.81,76.34) v2(150.81,75.76) v2(150.81,75.17) v2(150.89,105.84) v2(150.91,57.76) v2(150.91,56.23) v2(151.01,107.8) v2(151.06,94.22) v2(151.04,92.33) v2(150.99,46.74) v2(150.99,45.21) v2(150.99,43.69) v2(151.1,117.14) v2(151.2,133.98) v2(151.2,89.52) v2(151.21,87.72) v2(151.47,185.57) v2(151.37,114.01) v2(151.53,0.43) v2(151.79,133.98) v2(151.85,117.14) v2(151.82,107.11) v2(152.07,147.42) v2(152.07,145.86) v2(152.04,115.18) v2(152.05,4.5) v2(152.14,112.23) v2(152.14,110.9) v2(152.14,109.63) v2(152.29,93.49) v2(152.3,91.66) v2(152.4,89.77) v2(152.74,185.57) v2(152.85,58.01) v2(152.85,56.49) v2(152.85,46.74) v2(152.85,45.21) v2(152.85,43.69) v2(152.8,0.43) v2(152.99,171.35) v2(153.36,147.42) v2(153.36,145.86) v2(153.44,117.1) v2(153.49,0.43) v2(153.61,43.05) v2(153.83,104.37) v2(153.83,4.47) v2(153.91,144.84) v2(153.91,144.26) v2(153.91,143.67) v2(153.91,143.09) v2(153.91,142.51) v2(153.93,133.4) v2(153.93,132.82) v2(154.01,185.57) v2(154.13,115.56) v2(154.25,117.14) v2(154.38,110.29) v2(154.45,105.56) v2(154.5,144.84) v2(154.5,144.26) v2(154.5,143.67) v2(154.5,143.09) v2(154.5,142.51) v2(154.64,159.68) v2(154.64,0.98) v2(154.68,172.7) v2(154.84,93.64) v2(154.82,92.33) v2(154.84,91.02) v2(154.84,89.79) v2(154.96,2.21) v2(155.09,146.1) v2(155.08,145.43) v2(155.08,144.84) v2(155.08,144.26) v2(155.08,143.67) v2(155.08,143.09) v2(155.08,142.51) v2(155.08,141.92) v2(155.28,185.57) v2(155.53,159.68) v2(155.72,143.69) v2(155.72,143.1) v2(155.72,142.52) v2(155.72,141.93) v2(155.97,115.56) v2(156.12,2.73) v2(156.23,105.46) v2(156.34,59.02) v2(156.34,57.75) v2(156.34,56.48) v2(156.38,172.23) v2(156.42,163.12) v2(156.46,46.22) v2(156.46,44.95) v2(156.46,43.68) v2(156.55,185.57) v2(156.55,159.68) v2(156.61,117.15) v2(156.61,115.56) v2(156.86,105.46) v2(156.9,158.89) v2(156.88,129.93) v2(156.88,129.34) v2(156.88,128.76) v2(156.88,128.17) v2(157.29,169.78) v2(157.3,93.1) v2(157.43,173.24) v2(157.43,110.29) v2(157.39,2.73) v2(157.74,174.43) v2(157.72,143.08) v2(157.82,185.57) v2(157.79,158.89) v2(157.84,46.53) v2(157.84,44.63) v2(158.07,110.29) v2(158.09,59.4) v2(158.09,57.43) v2(158.19,145.44) v2(158.18,117.14) v2(158.26,91.36) v2(158.39,115.56) v2(158.53,28.24) v2(158.5,27.23) v2(158.57,144.29) v2(158.57,142.73) v2(158.64,105.46) v2(158.66,2.73) v2(158.96,117.14) v2(159.02,115.56) v2(159.09,185.57) v2(159.14,89.87) v2(159.27,105.46) v2(159.55,164.34) v2(159.63,46.23) v2(159.63,44.96) v2(159.63,43.69) v2(159.7,59.03) v2(159.7,57.76) v2(159.7,56.49) v2(159.87,144.29) v2(159.87,142.73) v2(159.86,92.74) v2(159.93,2.73) v2(160.36,185.57) v2(160.52,117.14) v2(160.81,169.25) v2(160.82,168.66) v2(160.8,115.56) v2(161.05,110.29) v2(161.05,105.46) v2(161.16,144.29) v2(161.16,142.73) v2(161.21,91.39) v2(161.2,2.73) v2(161.33,117.15) v2(161.43,115.56) v2(161.4,111.66) v2(161.63,185.57) v2(161.65,105.46) v2(161.66,59.1) v2(161.66,57.83) v2(161.66,56.56) v2(161.66,46.3) v2(161.66,45.03) v2(161.66,43.76) v2(161.67,141.9) v2(161.67,141.31) v2(161.67,140.73) v2(161.67,140.14) v2(161.67,139.56) v2(161.69,110.29) v2(162,172.4) v2(161.98,111.66) v2(162.12,148.27) v2(162.12,147.69) v2(162.26,141.9) v2(162.26,141.31) v2(162.26,140.73) v2(162.26,140.14) v2(162.26,139.56) v2(162.45,142.65) v2(162.47,2.73) v2(162.57,111.66) v2(162.51,90.09) v2(162.84,141.9) v2(162.84,141.31) v2(162.84,140.73) v2(162.84,140.14) v2(162.84,139.56) v2(162.9,185.57) v2(162.93,117.15) v2(163.03,143.23) v2(163.03,142.65) v2(163.15,111.66) v2(163.21,115.56) v2(163.27,93.08) v2(163.42,141.9) v2(163.42,141.31) v2(163.42,140.73) v2(163.42,140.14) v2(163.42,139.56) v2(163.47,110.29) v2(163.44,105.46) v2(163.51,58.14) v2(163.51,56.24) v2(163.51,45.34) v2(163.51,43.44) v2(163.61,143.23) v2(163.61,142.65) v2(163.66,117.16) v2(163.74,2.73) v2(163.85,115.05) v2(163.85,114.47) v2(163.81,111.26) v2(164.04,105.46) v2(164.17,185.57) v2(164.23,107.68) v2(164.5,177.47) v2(164.55,91.83) v2(164.83,106.35) v2(165.01,2.73) v2(165.12,107.68) v2(165.36,172.58) v2(165.33,143.03) v2(165.34,59.03) v2(165.34,57.76) v2(165.34,56.49) v2(165.34,46.23) v2(165.34,44.96) v2(165.34,43.69) v2(165.44,185.57) v2(165.57,110.21) v2(165.54,109.02) v2(165.8,145.39) v2(165.85,115.04) v2(165.88,105.46) v2(166.04,170.75) v2(166,90.41) v2(166.18,144.25) v2(166.18,142.68) v2(166.23,93.26) v2(166.28,2.73) v2(166.42,113.15) v2(166.42,112.56) v2(166.63,170.75) v2(166.71,185.57) v2(167.22,170.77) v2(167.25,59.1) v2(167.25,57.83) v2(167.25,56.56) v2(167.18,46.3) v2(167.18,45.03) v2(167.18,43.76) v2(167.55,174.45) v2(167.47,144.25) v2(167.47,142.68) v2(167.55,2.73) v2(167.98,185.57) v2(168.28,93.73) v2(168.84,174.43) v2(168.77,144.25) v2(168.77,142.68) v2(168.82,2.73) v2(169.02,59.41) v2(169.02,57.51) v2(169.02,46.61) v2(169.02,44.71) v2(169.25,185.57) v2(169.47,141.9) v2(169.47,141.31) v2(169.47,140.73) v2(169.87,129.15) v2(170,142.21) v2(170,141.63) v2(170,141.04) v2(170,140.46) v2(170.09,2.73) v2(170.19,149.27) v2(170.46,129.15) v2(170.52,185.57) v2(170.59,142.21) v2(170.59,141.63) v2(170.59,141.04) v2(170.59,140.46) v2(170.59,139.88) v2(170.78,149.27) v2(170.8,59.03) v2(170.8,57.76) v2(170.8,46.23) v2(170.8,44.96) v2(170.96,81.14) v2(170.96,80.56) v2(170.96,79.59) v2(170.96,79.01) v2(170.97,77.33) v2(170.97,76.75) v2(170.97,76.16) v2(170.97,75.58) v2(171.04,129.15) v2(171.08,165.28) v2(171.26,144.05) v2(171.19,142.8) v2(171.17,142.21) v2(171.17,141.63) v2(171.17,141.04) v2(171.17,140.46) v2(171.17,139.88) v2(171.36,2.73) v2(171.62,129.15) v2(171.72,143.47) v2(171.76,142.21) v2(171.76,141.63) v2(171.76,141.04) v2(171.76,140.46) v2(171.76,139.88) v2(171.79,185.57) v2(171.84,144.12) v2(171.79,142.89) v2(172.16,45.08) v2(172.33,142.53) v2(172.33,141.95) v2(172.33,141.36) v2(172.33,140.78) v2(172.33,140.19) v2(172.55,177.09) v2(172.63,2.73) v2(173.06,185.57) v2(173.14,177.09) v2(173.15,59.03) v2(173.15,57.76) v2(173.15,56.49) v2(173.15,46.23) v2(173.15,44.96) v2(173.15,43.69) v2(173.72,177.09) v2(173.85,167.95) v2(173.9,2.73) v2(174.09,142.7) v2(174.19,159.66) v2(174.32,185.68) v2(174.43,177.42) v2(174.43,176.84) v2(174.44,175.57) v2(174.56,145.06) v2(174.74,58.08) v2(174.74,56.18) v2(174.74,45.28) v2(174.74,43.37) v2(174.94,143.92) v2(174.94,142.35) v2(175.17,2.73) v2(175.22,186.58) v2(175.26,107.72) v2(175.47,105.89) v2(175.85,98.73) v2(175.78,96.76) v2(175.97,129.59) v2(176,148.72) v2(175.98,109.96) v2(176.04,104.38) v2(176.01,102.9) v2(176.24,143.92) v2(176.24,142.35) v2(176.25,3.4) v2(176.28,187.1) v2(176.36,118.77) v2(176.44,100.95) v2(176.56,129.91) v2(176.56,129.28) v2(176.58,148.72) v2(176.71,59.03) v2(176.71,57.76) v2(176.77,164.96) v2(176.83,46.23) v2(176.83,44.96) v2(176.83,43.69) v2(176.92,117.38) v2(176.92,116.36) v2(177.17,129.93) v2(177.17,129.29) v2(177.53,143.92) v2(177.53,142.35) v2(177.56,8.3) v2(177.75,104.38) v2(177.73,102.91) v2(177.93,129.29) v2(177.87,38.28) v2(178.19,187.1) v2(178.27,141.15) v2(178.27,140.56) v2(178.38,175) v2(178.44,45.5) v2(178.62,10.13) v2(178.62,6.47) v2(178.76,175.44) v2(178.72,5.23) v2(178.85,141.73) v2(178.85,141.15) v2(178.85,140.56) v2(179,186.85) v2(179.03,112.15) v2(179.16,142.3) v2(179.08,139.65) v2(179.08,139.06) v2(179.27,40.82) v2(179.27,39.49) v2(179.33,172.96) v2(179.3,5.23) v2(179.46,141.74) v2(179.44,141.15) v2(179.44,140.56) v2(179.62,139.98) v2(179.62,139.39) v2(179.64,138.75) v2(179.97,172.96) v2(180,170.16) v2(179.99,5.23) v2(180.2,175.57) v2(180.5,184.82) v2(180.57,5.23) v2(180.72,10.13) v2(180.74,6.44) v2(181.11,181.9) v2(181.3,168.21) v2(181.3,167.56) v2(181.39,142.72) v2(181.74,184.56) v2(181.86,145.08) v2(181.78,8.3) v2(181.95,170.14) v2(181.95,167.56) v2(182,175.57) v2(182.17,183.73) v2(182.17,180.07) v2(182.24,143.94) v2(182.24,142.37) v2(182.6,164.31) v2(182.91,156.85) v2(182.94,75.26) v2(182.97,184.89) v2(183.25,163.65) v2(183.24,25.28) v2(183.54,143.94) v2(183.54,142.37) v2(183.68,3.25) v2(183.82,128.92) v2(183.9,162.99) v2(184.23,184.72) v2(184.26,129.37) v2(184.27,183.73) v2(184.27,180.07) v2(184.84,143.94) v2(184.84,142.37) v2(184.95,3.23) v2(185.33,181.9) v2(185.33,139.86) v2(185.33,139.22) v2(185.33,138.59) v2(185.33,137.95) v2(185.33,137.32) v2(185.33,128.88) v2(185.49,184.56) v2(185.53,174.31) v2(185.68,129.35) v2(185.7,3.23) v2(185.78,158.05) v2(185.84,139.55) v2(185.84,138.92) v2(185.84,138.28) v2(185.84,137.65) v2(185.84,137.01) v2(185.86,29.62) v2(186.18,156.36) v2(186.34,139.88) v2(186.34,139.25) v2(186.34,138.61) v2(186.34,137.98) v2(186.34,137.34) v2(186.36,23.24) v2(186.36,20.25) v2(186.97,3.23) v2(187.32,174.3) v2(187.51,59.82) v2(187.51,58.61) v2(187.56,30.03) v2(187.74,156.42) v2(187.85,21.74) v2(187.97,25.64) v2(188.24,3.23) v2(188.31,39.49) v2(188.78,162.66) v2(188.88,63.05) v2(189.09,147.48) v2(189.11,145.7) v2(189.24,174.58) v2(189.24,172.83) v2(189.35,23.24) v2(189.51,3.23) v2(189.62,160.14) v2(189.62,159.5) v2(190.08,30.1) v2(190.1,29.01) v2(190.53,25.17) v2(190.66,27.56) v2(190.78,3.23) v2(190.94,26.29) v2(191.03,39.37) v2(191.25,165.12) v2(191.32,164.13) v2(191.6,40.92) v2(191.93,139.65) v2(192.13,169.09) v2(192.41,141.28) v2(192.57,3.23) v2(192.69,156.75) v2(192.72,145.98) v2(192.72,144.22) v2(193.02,165.01) v2(193.32,3.23) v2(193.49,157.79) v2(194.14,169.47) v2(194.09,155.86) v2(194.47,159.11) v2(194.59,3.23) v2(195.76,57.4) v2(195.86,3.23) v2(196.1,167.44) v2(196.28,162.26) v2(196.66,113.59) v2(196.68,32.24) v2(196.82,59.23) v2(196.82,55.57) v2(196.99,183.38) v2(197.1,127.03) v2(197.13,3.23) v2(197.85,62.16) v2(197.92,13.72) v2(198.38,32.16) v2(198.4,3.23) v2(198.95,127.44) v2(198.92,59.23) v2(198.92,55.57) v2(198.92,30.61) v2(199.08,13.72) v2(199.2,162.97) v2(199.45,184.29) v2(199.67,3.23) v2(199.98,57.4) v2(200.11,181.9) v2(200.39,158.65) v2(200.7,184.48) v2(200.92,171.06) v2(200.94,3.23) v2(201.17,183.73) v2(201.17,180.07) v2(201.35,127.42) v2(201.56,162.84) v2(201.72,44.83) v2(201.8,138.85) v2(201.81,17.58) v2(201.91,184.88) v2(201.88,142.74) v2(202.03,165.85) v2(202.12,164.64) v2(202.14,164.06) v2(202.14,163.47) v2(202.14,162.89) v2(202.17,16.18) v2(202.56,50.3) v2(202.76,141.47) v2(202.76,130.61) v2(202.73,3.23) v2(202.83,142.69) v2(202.83,140.14) v2(203.17,184.74) v2(203.2,136.91) v2(203.27,183.73) v2(203.27,180.07) v2(203.48,3.23) v2(203.81,52.48) v2(203.81,48.12) v2(204.1,136.35) v2(204.36,184.29) v2(204.34,181.89) v2(204.45,141.79) v2(204.5,139.42) v2(204.75,3.23) v2(205.18,105.72) v2(205.63,184.29) v2(205.81,105.72) v2(206.02,3.23) v2(206.1,67.9) v2(206.17,66.79) v2(206.14,65.62) v2(206.33,52.48) v2(206.33,48.12) v2(207.3,115.32) v2(207.29,3.23) v2(207.65,180.39) v2(207.58,50.3) v2(208.01,37.04) v2(208.43,178.97) v2(208.47,176.85) v2(208.56,3.23) v2(208.57,171.25) v2(209.05,115.04) v2(209.46,166.57) v2(209.44,133.33) v2(209.56,176.19) v2(209.5,132.43) v2(209.5,29.53) v2(209.66,131.03) v2(209.72,67.97) v2(209.71,66.87) v2(209.72,65.69) v2(209.83,3.23) v2(210.19,22.03) v2(210.52,121.11) v2(210.73,176.67) v2(211.1,3.23) v2(211.67,166.6) v2(212.08,169.76) v2(212.23,172.08) v2(212.24,164.35) v2(212.29,151.73) v2(212.94,100.05) v2(212.89,3.23) v2(213.14,150.59) v2(213.14,149.81) v2(213.14,149.03) v2(213.26,151.73) v2(213.19,142.74) v2(213.19,142.1) v2(213.61,153.91) v2(213.64,3.23) v2(213.78,142.74) v2(213.78,142.1) v2(213.93,123.77) v2(214.07,172.08) v2(214.01,150.59) v2(214.01,149.81) v2(214.01,149.03) v2(214.17,100.04) v2(214.34,169.84) v2(214.36,142.74) v2(214.36,142.1) v2(214.41,166.6) v2(214.39,57.91) v2(214.77,165.59) v2(214.87,150.59) v2(214.87,149.81) v2(214.87,149.03) v2(214.94,142.74) v2(214.94,142.1) v2(214.91,3.23) v2(215.53,142.74) v2(215.53,142.1) v2(215.73,150.59) v2(215.73,149.81) v2(215.73,149.03) v2(216.24,88.17) v2(216.18,3.23) v2(216.44,166.04) v2(216.57,100.1) v2(216.63,83.62) v2(216.82,102.85) v2(217.15,166.93) v2(217.4,88.18) v2(217.45,3.23) v2(217.5,155.06) v2(217.5,154.42) v2(217.64,147.16) v2(217.69,147.76) v2(218.13,155.06) v2(218.13,154.42) v2(218.27,147.76) v2(218.52,116.92) v2(218.52,82.65) v2(218.63,83.65) v2(218.77,155.06) v2(218.77,154.42) v2(218.72,3.23) v2(218.8,166.91) v2(218.86,147.76) v2(218.96,118.86) v2(219.22,118) v2(219.29,82.88) v2(219.4,155.06) v2(219.4,154.42) v2(219.44,147.76) v2(219.44,120.58) v2(219.93,164.67) v2(219.89,118.73) v2(220.04,155.06) v2(220.04,154.42) v2(220.02,147.76) v2(220.03,120.58) v2(219.99,3.23) v2(220.13,146.49) v2(220.13,145.22) v2(220.09,107.63) v2(220.09,105.56) v2(220.1,103.43) v2(220.08,97.35) v2(220.12,93.2) v2(220.12,91.05) v2(220.26,144.01) v2(220.26,143.37) v2(220.26,142.74) v2(220.26,142.1) v2(220.26,141.47) v2(220.26,140.83) v2(220.23,136.58) v2(220.23,135.94) v2(220.19,99.51) v2(220.27,95.15) v2(220.24,86.96) v2(220.43,113.94) v2(220.53,157.38) v2(220.61,147.76) v2(220.61,120.58) v2(220.65,107.63) v2(220.65,105.53) v2(220.65,99.2) v2(220.63,86.53) v2(220.67,155.06) v2(220.67,154.42) v2(220.71,146.49) v2(220.71,145.22) v2(220.75,85.02) v2(220.85,144.01) v2(220.85,143.37) v2(220.85,142.74) v2(220.85,142.1) v2(220.85,141.47) v2(220.85,140.83) v2(220.86,136.58) v2(220.86,135.94) v2(220.77,96.95) v2(220.77,94.85) v2(220.78,80.53) v2(221.12,157.38) v2(221.18,172.27) v2(221.19,147.76) v2(221.26,3.23) v2(221.31,155.06) v2(221.31,154.42) v2(221.29,146.49) v2(221.29,145.22) v2(221.43,144.01) v2(221.43,143.37) v2(221.43,142.74) v2(221.43,142.1) v2(221.43,141.47) v2(221.43,140.83) v2(221.42,109.45) v2(221.4,85.67) v2(221.37,84.35) v2(221.5,136.58) v2(221.5,135.94) v2(221.48,99.64) v2(221.47,90.75) v2(221.47,83.65) v2(221.47,82.95) v2(221.94,155.06) v2(221.94,154.42) v2(221.88,146.49) v2(221.88,145.22) v2(221.94,130.62) v2(221.94,130.04) v2(222.02,144.01) v2(222.04,143.37) v2(222.04,142.74) v2(222.04,142.1) v2(222.04,141.47) v2(222.04,140.83) v2(222.03,103.33) v2(222.02,91.15) v2(222.02,87) v2(222.13,136.58) v2(222.13,135.94) v2(222.12,112.25) v2(222.07,111.65) v2(222.07,95.45) v2(222.11,93.38) v2(222.26,29.14) v2(222.31,36.93) v2(222.46,146.49) v2(222.46,145.22) v2(222.64,144.01) v2(222.63,143.37) v2(222.63,142.74) v2(222.63,142.1) v2(222.63,141.47) v2(222.63,140.83) v2(222.77,108.05) v2(222.77,105.95) v2(222.85,103.84) v2(222.82,99.01) v2(222.77,90.6) v2(222.86,87.05) v2(222.87,86.35) v2(223.05,3.23) v2(223.08,146.49) v2(223.08,145.22) v2(223.22,144.01) v2(223.21,143.37) v2(223.21,142.74) v2(223.21,142.1) v2(223.21,141.47) v2(223.21,140.83) v2(223.3,93.29) v2(223.32,90.8) v2(223.47,147.18) v2(223.67,146.49) v2(223.67,145.22) v2(223.57,109.55) v2(223.57,105.35) v2(223.57,94.85) v2(223.86,142.1) v2(223.85,141.47) v2(223.85,140.83) v2(223.8,3.23) v2(223.91,30.99) v2(224.17,109.45) v2(224.27,107.45) v2(224.17,103.25) v2(224.2,99.67) v2(224.23,90.66) v2(224.44,142.1) v2(224.43,141.47) v2(224.43,140.83) v2(224.47,130.6) v2(224.48,130.02) v2(224.67,81.2) v2(224.82,185.5) v2(224.82,182.63) v2(224.82,180.72) v2(224.82,178.82) v2(224.82,176.91) v2(224.77,95.35) v2(224.87,108.15) v2(224.92,105.93) v2(224.92,103.89) v2(224.97,85.75) v2(224.97,82.95) v2(225.03,142.1) v2(225.01,141.47) v2(225.01,140.83) v2(225.07,3.23) v2(225.37,84) v2(225.61,142.1) v2(225.6,141.47) v2(225.6,140.83) v2(225.57,114.45) v2(225.57,87.15) v2(226.2,142.1) v2(226.18,141.47) v2(226.18,140.83) v2(226.34,3.23) v2(226.6,118.93) v2(226.77,141.47) v2(226.77,140.83) v2(226.78,185.5) v2(226.79,150.59) v2(226.79,149.81) v2(226.79,149.03) v2(226.78,142.1) v2(226.97,84.35) v2(227.01,157.43) v2(227.05,85.71) v2(227.08,130.67) v2(227.08,130.04) v2(227.13,116.58) v2(227.08,88.48) v2(227.25,117.12) v2(227.2,83.81) v2(227.35,141.47) v2(227.35,140.83) v2(227.34,137.98) v2(227.34,137.34) v2(227.38,153.93) v2(227.4,142.1) v2(227.52,85.06) v2(227.64,170.81) v2(227.66,150.59) v2(227.66,149.81) v2(227.66,149.03) v2(227.67,88.55) v2(227.65,87.78) v2(227.61,3.23) v2(227.68,87.07) v2(227.99,142.1) v2(227.97,141.47) v2(227.97,140.83) v2(227.97,137.98) v2(227.97,137.34) v2(228.04,120.7) v2(228.2,184.99) v2(228.42,108.85) v2(228.42,91.95) v2(228.52,150.59) v2(228.52,149.81) v2(228.52,149.03) v2(228.61,137.98) v2(228.61,137.34) v2(228.57,37.51) v2(228.79,183.29) v2(228.88,3.23) v2(229.12,108.85) v2(229.12,91.95) v2(229.15,37.51) v2(229.26,160.41) v2(229.39,150.59) v2(229.39,149.81) v2(229.39,149.03) v2(229.56,130.67) v2(229.56,130.04) v2(229.72,87.05) v2(229.87,85.75) v2(229.96,8.99) v2(229.96,8.36) v2(229.92,3.96) v2(230.23,182.6) v2(230.23,180.7) v2(230.26,155.31) v2(230.26,154.68) v2(230.36,177.02) v2(230.36,166.94) v2(230.52,108.85) v2(230.52,101.05) v2(230.52,91.95) v2(230.82,4.86) v2(230.89,155.31) v2(230.89,154.68) v2(231.32,85.66) v2(231.42,83.8) v2(231.53,155.31) v2(231.53,154.68) v2(231.61,147.83) v2(231.61,147.25) v2(231.92,108.85) v2(231.92,107.45) v2(231.87,87.15) v2(232.06,177.04) v2(232.16,155.31) v2(232.16,154.68) v2(232.16,130.67) v2(232.16,130.04) v2(232.19,147.83) v2(232.19,147.25) v2(232.53,5.23) v2(232.81,155.1) v2(233.05,155.63) v2(233.1,144.71) v2(233.1,143.75) v2(233.14,142.57) v2(233.12,141.85) v2(233.12,140.83) v2(233.21,164.29) v2(233.32,108.85) v2(233.32,107.45) v2(233.32,91.95) v2(233.3,5.23) v2(233.45,155.1) v2(233.37,143.17) v2(233.42,85.6) v2(233.52,86.56) v2(233.52,83.8) v2(233.69,155.63) v2(233.72,142.57) v2(233.7,141.85) v2(233.7,140.83) v2(233.97,177.04) v2(233.96,143.17) v2(233.97,88.55) v2(233.97,87.75) v2(234.08,155.1) v2(234.2,15.87) v2(234.32,155.63) v2(234.31,142.57) v2(234.32,141.85) v2(234.32,140.83) v2(234.51,130.61) v2(234.51,129.98) v2(234.58,143.17) v2(234.57,5.23) v2(234.72,155.1) v2(234.72,108.85) v2(234.72,91.95) v2(234.77,100.45) v2(234.82,15.87) v2(234.96,166.17) v2(234.96,155.63) v2(234.9,144.71) v2(234.9,143.75) v2(234.93,142.57) v2(234.91,141.85) v2(234.91,140.83) v2(235.16,143.17) v2(235.35,155.1) v2(235.42,108.85) v2(235.42,91.95) v2(235.4,15.87) v2(235.48,144.71) v2(235.48,143.75) v2(235.51,142.57) v2(235.54,141.85) v2(235.57,140.9) v2(235.7,147.82) v2(235.7,146.61) v2(235.72,145.6) v2(235.84,5.23) v2(235.87,177.04) v2(235.97,155.31) v2(235.97,154.68) v2(235.99,15.87) v2(236.1,144.71) v2(236.1,143.75) v2(236.14,142.57) v2(236.15,140.9) v2(236.18,141.85) v2(236.28,147.82) v2(236.28,146.61) v2(236.43,145.6) v2(236.48,138.04) v2(236.48,137.4) v2(236.52,80.15) v2(236.52,78.9) v2(236.61,155.26) v2(236.61,154.68) v2(236.69,144.71) v2(236.69,143.75) v2(236.72,142.57) v2(236.74,140.9) v2(236.86,147.82) v2(236.86,146.61) v2(236.81,141.85) v2(236.82,108.85) v2(236.77,100.45) v2(236.82,91.95) v2(237.07,145.6) v2(237.12,138.04) v2(237.12,137.4) v2(237.12,130.61) v2(237.12,129.98) v2(237.11,5.23) v2(237.26,169.85) v2(237.32,144.71) v2(237.32,143.75) v2(237.36,142.57) v2(237.45,147.82) v2(237.45,146.61) v2(237.44,141.85) v2(237.37,140.9) v2(237.69,145.6) v2(237.75,138.04) v2(237.75,137.4) v2(237.78,177.04) v2(237.93,142.68) v2(238.02,141.85) v2(238.06,140.96) v2(238.22,108.85) v2(238.22,107.45) v2(238.22,106.05) v2(238.22,98.95) v2(238.22,96.15) v2(238.22,91.95) v2(238.31,49.09) v2(238.38,5.23) v2(238.51,142.68) v2(238.52,80.86) v2(238.64,141.85) v2(238.64,140.96) v2(238.57,79.1) v2(238.92,108.85) v2(238.92,107.45) v2(238.92,106.05) v2(238.92,96.15) v2(238.92,91.95) v2(238.9,49.09) v2(239.1,142.68) v2(239.23,141.85) v2(239.25,140.96) v2(239.48,49.09) v2(239.66,151.8) v2(239.65,5.23) v2(239.72,142.68) v2(239.72,130.61) v2(239.72,129.98) v2(239.86,141.85) v2(239.84,140.96) v2(239.96,181.89) v2(239.96,179.99) v2(240.06,49.09) v2(240.23,168.08) v2(240.23,166.55) v2(240.34,183.01) v2(240.32,108.85) v2(240.32,96.15) v2(240.32,91.95) v2(240.51,150.65) v2(240.51,149.87) v2(240.51,149.09) v2(240.62,80.45) v2(240.62,78.65) v2(240.62,77.49) v2(240.65,49.09) v2(240.97,76.57) v2(241.37,150.65) v2(241.37,149.87) v2(241.37,149.09) v2(241.41,81.49) v2(241.41,80.69) v2(241.47,78.56) v2(241.42,5.23) v2(241.51,79.65) v2(241.75,183.8) v2(241.72,108.85) v2(241.72,103.25) v2(241.72,96.15) v2(241.72,91.95) v2(241.82,42.85) v2(241.85,40.3) v2(241.85,39.72) v2(241.92,83.8) v2(242.24,150.65) v2(242.24,149.87) v2(242.24,149.09) v2(242.19,5.23) v2(242.27,184.92) v2(242.46,40.45) v2(242.46,39.87) v2(242.53,15.94) v2(243.1,150.65) v2(243.1,149.87) v2(243.12,108.85) v2(243.12,103.25) v2(243.12,99.75) v2(243.12,96.15) v2(243.12,91.95) v2(243.46,5.23) v2(243.73,154.74) v2(243.75,121.85) v2(243.85,85.72) v2(243.9,184.94) v2(244.01,87.95) v2(244.01,83.74) v2(244.04,40.5) v2(244.1,35.33) v2(244.1,34.09) v2(244.15,21.78) v2(244.15,19.84) v2(244.37,154.74) v2(244.46,181.79) v2(244.43,178.13) v2(244.38,122.48) v2(244.38,121.85) v2(244.46,87.14) v2(244.47,84.35) v2(244.52,91.95) v2(244.47,88.55) v2(244.48,86.38) v2(244.75,20.81) v2(244.73,5.23) v2(245,154.74) v2(245.22,108.85) v2(245.22,107.45) v2(245.22,91.95) v2(245.27,147.89) v2(245.27,147.26) v2(245.35,35.33) v2(245.35,34.09) v2(245.34,21.78) v2(245.34,19.84) v2(245.64,154.74) v2(245.91,147.89) v2(245.91,147.26) v2(245.97,87.12) v2(246,5.23) v2(246.12,83.8) v2(246.24,155.07) v2(246.2,40.5) v2(246.29,33.23) v2(246.42,88.25) v2(246.57,87.15) v2(246.87,155.07) v2(246.88,144.9) v2(246.88,144.26) v2(246.88,143.63) v2(246.88,142.99) v2(246.9,142.36) v2(246.9,141.72) v2(247.27,5.23) v2(247.47,142.99) v2(247.51,155.07) v2(247.48,142.36) v2(247.48,141.72) v2(248.05,142.99) v2(248.14,155.07) v2(248.1,142.36) v2(248.12,141.74) v2(248.22,83.8) v2(248.54,5.23) v2(248.67,144.9) v2(248.67,144.26) v2(248.67,143.63) v2(248.67,142.99) v2(248.69,142.36) v2(248.7,141.74) v2(248.78,155.07) v2(248.77,90.79) v2(248.92,89.37) v2(249.26,144.9) v2(249.26,144.26) v2(249.26,143.63) v2(249.26,142.99) v2(249.26,10.57) v2(249.32,142.36) v2(249.34,141.74) v2(249.51,155.03) v2(249.87,145.53) v2(249.88,144.9) v2(249.88,144.26) v2(249.88,143.63) v2(249.88,142.99) v2(249.96,142.36) v2(249.97,141.74) v2(250.08,154.74) v2(250.25,88.67) v2(250.32,83.8) v2(250.31,5.23) v2(250.45,145.53) v2(250.47,144.9) v2(250.47,144.26) v2(250.47,143.63) v2(250.47,142.99) v2(250.59,142.36) v2(250.61,141.74) v2(250.62,28.19) v2(250.71,159.39) v2(250.71,130.74) v2(250.71,126.65) v2(250.77,47.36) v2(250.87,103.15) v2(250.87,89.15) v2(250.87,88.55) v2(250.94,23.19) v2(250.94,22.61) v2(250.94,22.03) v2(250.94,21.44) v2(251.04,145.53) v2(251.04,10.67) v2(251.1,144.9) v2(251.1,144.26) v2(251.1,143.63) v2(251.1,142.99) v2(251.08,5.23) v2(251.21,142.36) v2(251.23,141.74) v2(251.2,28.19) v2(251.34,130.74) v2(251.34,126.65) v2(251.41,47.36) v2(251.53,103.22) v2(251.63,88.6) v2(251.57,85.65) v2(251.9,23.83) v2(251.98,130.74) v2(251.98,126.65) v2(252.02,103.73) v2(252.07,89.05) v2(252.11,95.32) v2(252.1,47.36) v2(252.17,85.65) v2(252.27,84.35) v2(252.28,34.28) v2(252.35,5.23) v2(252.48,159.36) v2(252.48,23.83) v2(252.74,47.36) v2(252.78,27.61) v2(252.92,109.53) v2(252.91,94.8) v2(252.92,88.58) v2(252.87,84.35) v2(252.97,87.04) v2(253.27,82.1) v2(253.44,151.86) v2(253.41,27.61) v2(253.5,89.01) v2(253.52,86.55) v2(253.67,84.27) v2(253.62,5.23) v2(253.69,24.95) v2(254.05,27.61) v2(254.29,150.72) v2(254.29,149.94) v2(254.29,149.15) v2(254.34,83.58) v2(254.32,82.2) v2(254.33,24.95) v2(254.42,82.8) v2(254.54,124.51) v2(254.54,123.88) v2(254.54,122.74) v2(254.54,122.1) v2(254.58,6.85) v2(254.68,27.61) v2(254.79,110) v2(254.96,24.95) v2(254.96,24.31) v2(254.89,5.23) v2(254.99,82.93) v2(255.15,150.72) v2(255.15,149.94) v2(255.15,149.15) v2(255.11,84.27) v2(255.22,6.85) v2(255.27,88.1) v2(255.32,27.61) v2(255.42,83.74) v2(255.63,100.83) v2(255.6,24.95) v2(255.6,24.31) v2(255.85,6.85) v2(255.95,27.61) v2(256.02,150.72) v2(256.02,149.94) v2(256.07,94.45) v2(256.16,5.23) v2(256.32,90.25) v2(256.45,17.09) v2(256.43,16.49) v2(256.72,113.54) v2(256.88,150.72) v2(257.04,17.09) v2(257.02,16.49) v2(257.33,86.52) v2(257.5,154.8) v2(257.53,112.55) v2(257.64,114.19) v2(257.62,17.09) v2(257.6,16.49) v2(258.02,92.35) v2(258.14,154.8) v2(258.17,94.45) v2(258.23,88.43) v2(258.26,17.07) v2(258.34,115.12) v2(258.7,5.23) v2(258.77,154.8) v2(259.03,31.93) v2(259.13,147.34) v2(259.41,154.8) v2(259.76,147.34) v2(259.77,92.2) v2(259.96,8.3) v2(260.07,155.13) v2(260.04,125.78) v2(260.04,125.2) v2(260.04,124.58) v2(260.04,123.99) v2(259.97,94.87) v2(260.31,142.43) v2(260.31,141.8) v2(260.47,5.23) v2(260.7,155.13) v2(260.75,143.65) v2(260.75,143.07) v2(260.89,142.43) v2(260.89,141.8) v2(261.02,10.13) v2(261.02,6.47) v2(261.17,27.77) v2(261.24,5.23) v2(261.34,155.13) v2(261.39,143.65) v2(261.39,143.07) v2(261.48,142.43) v2(261.48,141.8) v2(261.82,161.47) v2(261.81,27.77) v2(261.96,182.1) v2(261.98,184.94) v2(261.97,155.13) v2(262.02,143.65) v2(262.02,143.07) v2(262.06,142.43) v2(262.06,141.8) v2(262.13,177.38) v2(262.44,161.47) v2(262.44,27.77) v2(262.51,5.23) v2(262.61,155.77) v2(262.61,155.13) v2(262.66,143.65) v2(262.66,143.07) v2(262.68,142.43) v2(262.68,141.8) v2(263.03,161.47) v2(263.12,10.13) v2(263.12,6.47) v2(263.22,155.45) v2(263.27,142.43) v2(263.27,141.8) v2(263.29,143.65) v2(263.29,143.07) v2(263.37,16.13) v2(263.66,161.47) v2(263.66,146.68) v2(263.66,146.04) v2(263.76,184.94) v2(263.86,155.44) v2(263.85,154.82) v2(263.79,125.85) v2(263.79,125.21) v2(263.79,124.58) v2(263.79,123.94) v2(263.78,5.23) v2(263.93,143.65) v2(263.93,143.07) v2(263.9,142.43) v2(263.9,141.8) v2(263.97,16.13) v2(264.11,18.22) v2(264.18,8.3) v2(264.42,128.39) v2(264.42,127.75) v2(264.42,127.12) v2(264.42,126.48) v2(264.42,125.85) v2(264.42,125.21) v2(264.42,124.58) v2(264.42,123.94) v2(264.61,17.9) v2(265.06,128.39) v2(265.06,127.75) v2(265.06,127.12) v2(265.06,126.48) v2(265.05,5.23) v2(265.19,33.59) v2(265.2,17.91) v2(265.57,184.94) v2(265.57,34.16) v2(265.83,33.59) v2(265.95,18.41) v2(265.92,14.66) v2(265.98,184.03) v2(265.98,182.5) v2(265.98,180.98) v2(265.98,179.45) v2(265.98,177.93) v2(266,176.41) v2(266,174.88) v2(266,173.36) v2(266.2,36.82) v2(266.2,36.19) v2(266.2,34.15) v2(266.32,5.23) v2(266.55,175.48) v2(266.56,152.3) v2(266.72,10.57) v2(266.76,6.09) v2(266.84,36.82) v2(266.84,36.19) v2(266.84,34.15) v2(267.06,165.94) v2(267.04,164.16) v2(267.16,33.59) v2(267.59,5.23) v2(267.75,167.19) v2(267.71,14.68) v2(267.82,175.47) v2(267.81,154.48) v2(267.81,150.12) v2(267.79,33.58) v2(268.42,33.58) v2(268.74,14.63) v2(268.86,5.23) v2(269.09,175.47) v2(269.21,10.56) v2(269.18,6.09) v2(269.53,167.21) v2(269.57,59.55) v2(269.57,58.92) v2(269.75,75.76) v2(270.2,59.55) v2(270.2,58.92) v2(270.36,175.47) v2(270.33,154.48) v2(270.33,150.12) v2(270.66,8.27) v2(270.63,5.23) v2(270.98,164.86) v2(270.98,163.44) v2(270.98,162.02) v2(271,133.33) v2(271.4,5.23) v2(271.63,175.47) v2(271.58,152.3) v2(271.94,170.13) v2(272.02,157) v2(272.4,164.86) v2(272.4,163.44) v2(272.4,162.02) v2(272.41,132.76) v2(273.17,5.23) v2(273.44,45.39) v2(273.52,46.21) v2(273.52,44.66) v2(273.82,164.86) v2(273.82,163.44) v2(273.82,162.02) v2(273.8,43.89) v2(273.88,141.6) v2(273.88,140.07) v2(273.88,138.55) v2(273.92,46.92) v2(273.95,16.67) v2(273.94,5.23) v2(274.06,172.4) v2(274.06,157.01) v2(274.05,133.45) v2(274.52,42.98) v2(274.65,47.62) v2(274.93,133.45) v2(274.89,14.25) v2(275.12,174.23) v2(275.12,170.57) v2(275.24,42.6) v2(275.21,5.23) v2(275.44,175.47) v2(275.41,141.6) v2(275.41,140.07) v2(275.41,138.55) v2(275.47,47.96) v2(275.51,18.88) v2(276.16,42.5) v2(276.39,48.03) v2(276.48,5.23) v2(276.71,175.47) v2(276.93,141.6) v2(276.93,140.07) v2(276.93,138.55) v2(277.22,174.23) v2(277.22,170.57) v2(277.31,42.92) v2(277.38,47.68) v2(277.75,5.23) v2(278.04,43.49) v2(278.11,47.07) v2(278.28,172.4) v2(278.55,116.36) v2(278.6,46.23) v2(278.6,44.35) v2(278.84,45.33) v2(279.02,5.23) v2(280.03,48.1) v2(280.03,47.51) v2(280.52,175.47) v2(280.62,48.1) v2(280.62,47.51) v2(280.62,46.93) v2(280.62,46.35) v2(280.62,45.76) v2(280.62,45.18) v2(280.62,44.59) v2(280.76,51.44) v2(280.79,5.23) v2(281.56,5.23) v2(281.79,175.47) v2(281.8,44.2) v2(282.52,66.35) v2(282.52,65.72) v2(282.52,65.13) v2(282.83,5.23) v2(283.1,66.35) v2(283.19,175.39) v2(283.47,174.35) v2(283.47,173.46) v2(283.49,172.49) v2(283.79,171.55) v2(283.85,46.16) v2(283.85,45.52) v2(284.16,170.64) v2(284.1,5.23) v2(284.36,40.44) v2(284.56,169.7) v2(284.93,168.79) v2(285,39.04) v2(285,38.46) v2(285.31,167.87) v2(285.34,51.55) v2(285.37,5.23) v2(285.7,166.93) v2(286.08,166.02) v2(286.39,165.23) v2(286.44,51.54) v2(286.64,5.23) v2(286.75,164.37) v2(287.13,163.48) v2(287.46,162.69) v2(287.83,161.83) v2(287.91,5.23) v2(288.25,160.84) v2(288.3,52.2) v2(288.95,159.15) v2(288.98,158.19) v2(288.98,156.67) v2(288.98,155.15) v2(288.98,153.62) v2(288.98,152.1) v2(288.98,150.57) v2(288.98,149.05) v2(288.98,147.53) v2(288.98,146) v2(288.98,144.48) v2(288.98,142.95) v2(288.98,141.43) v2(288.98,139.91) v2(288.98,138.38) v2(288.98,136.86) v2(288.98,135.33) v2(288.98,133.81) v2(288.98,132.29) v2(288.98,130.76) v2(288.98,129.24) v2(288.98,127.79) v2(288.98,126.27) v2(288.98,124.74) v2(288.98,123.22) v2(288.98,121.69) v2(288.98,120.17) v2(288.98,118.65) v2(288.98,117.12) v2(288.98,115.6) v2(288.98,114.07) v2(288.98,112.55) v2(288.98,111.03) v2(288.98,109.5) v2(288.98,107.98) v2(288.98,106.45) v2(288.98,104.93) v2(288.98,103.41) v2(288.98,101.88) v2(288.98,100.36) v2(288.98,98.83) v2(289.18,5.23) v2(289.3,97.41) v2(289.54,40.34) v2(289.67,96.29) v2(290.03,95.33) v2(290.33,61.33) v2(290.33,60.7) v2(290.33,60.06) v2(290.33,59.43) v2(290.33,58.79) v2(290.33,58.16) v2(290.33,57.52) v2(290.38,94.39) v2(290.52,40.06) v2(290.52,39.42) v2(290.74,93.53) v2(290.97,61.33) v2(290.97,60.7) v2(290.97,60.06) v2(290.97,59.43) v2(290.97,58.79) v2(290.97,58.16) v2(290.97,57.52) v2(290.95,5.23) v2(291.14,92.61) v2(291.58,91.67) v2(291.66,72.25) v2(291.66,71.62) v2(291.6,61.33) v2(291.6,60.7) v2(291.6,60.06) v2(291.6,59.43) v2(291.6,58.79) v2(291.6,58.16) v2(291.6,57.52) v2(291.72,5.23) v2(292.03,90.73) v2(292.24,46.35) v2(292.24,45.71) v2(292.3,61.33) v2(292.3,60.7) v2(292.3,60.06) v2(292.3,59.43) v2(292.3,58.79) v2(292.3,58.16) v2(292.3,57.52) v2(292.54,89.74) v2(292.93,62.6) v2(292.93,61.97) v2(292.93,61.33) v2(292.93,60.7) v2(292.93,60.06) v2(292.93,59.43) v2(292.93,58.79) v2(292.93,58.16) v2(292.93,57.52) v2(292.93,56.89) v2(292.93,56.25) v2(292.93,55.62) v2(292.93,54.98) v2(292.93,54.35) v2(292.93,53.71) v2(293.02,88.85) v2(292.99,5.23) v2(293.54,87.94) v2(293.57,62.6) v2(293.57,61.97) v2(293.57,61.33) v2(293.57,60.7) v2(293.57,60.06) v2(293.57,59.43) v2(293.57,58.79) v2(293.57,58.16) v2(293.57,57.52) v2(293.57,56.89) v2(293.57,56.25) v2(293.57,55.62) v2(293.57,54.98) v2(293.57,54.35) v2(293.57,53.71) v2(293.48,40.26) v2(294.04,46.1) v2(294.09,87.05) v2(294.2,62.6) v2(294.2,61.97) v2(294.2,61.33) v2(294.2,60.7) v2(294.2,60.06) v2(294.2,59.43) v2(294.2,58.79) v2(294.2,58.16) v2(294.2,57.52) v2(294.2,56.89) v2(294.2,56.25) v2(294.2,55.62) v2(294.2,54.98) v2(294.2,54.35) v2(294.2,53.71) v2(294.26,5.23) v2(294.28,65.27) v2(294.28,64.68) v2(294.28,64.05) v2(294.28,63.47) v2(294.61,86.21) v2(294.84,62.6) v2(294.9,61.97) v2(294.9,61.33) v2(294.9,60.7) v2(294.9,60.06) v2(294.9,59.43) v2(294.9,58.79) v2(294.9,58.16) v2(294.9,57.52) v2(294.9,56.89) v2(294.9,56.25) v2(294.9,55.62) v2(294.9,54.98) v2(294.9,54.35) v2(294.9,53.71) v2(295.26,85.25) v2(295.53,5.23) v2(295.66,69.38) v2(295.66,68.79) v2(295.66,68.17) v2(295.66,67.59) v2(295.66,49.9) v2(295.66,49.27) v2(295.66,48.63) v2(295.76,78.05) v2(295.93,84.28) v2(296.36,49.9) v2(296.36,49.27) v2(296.36,48.63) v2(296.63,83.32) v2(296.82,79.88) v2(296.82,76.22) v2(296.8,5.23) v2(297,50.54) v2(297,49.9) v2(297,49.27) v2(297,48.63) v2(297.7,49.9) v2(297.7,49.27) v2(297.7,48.63) v2(298.07,5.23) v2(298.42,80.14) v2(298.92,76.22) v2(299.34,5.23) v2(299.98,78.05) v2(300.49,19.76) v2(300.92,73.08) v2(300.92,71.56) v2(300.92,70.03) v2(300.92,68.51) v2(300.92,66.98) v2(300.92,65.46) v2(301.11,5.23) v2(301.28,64.11) v2(301.46,19.76) v2(301.88,5.23) v2(302.47,63.6) v2(302.87,55.45) v2(303.15,5.23) v2(303.44,56.02) v2(303.44,54.88) v2(304,63.6) v2(304.02,55.45) v2(304.42,5.23) v2(305.47,50.32) v2(305.47,39.53) v2(305.47,36.53) v2(305.52,63.6) v2(305.69,5.23) v2(306.97,38.03) v2(306.96,5.23) v2(307.04,63.6) v2(308.23,5.23) v2(308.47,39.53) v2(308.57,63.6) v2(309.5,5.23) v2(310.09,63.6) v2(311.27,5.23) v2(311.51,38.65) v2(311.62,63.6) v2(312.04,5.23) v2(312.43,45.08) v2(313.06,45.08) v2(313.14,63.6) v2(313.31,5.23) v2(314.56,21.65) v2(314.66,63.6) v2(314.58,5.23) v2(315.85,5.23) v2(315.88,38.9) v2(316.19,63.6) v2(316.52,60.56) v2(316.52,58.57) v2(317.12,5.23) v2(317.53,63.6) v2(317.51,59.57) v2(318.39,5.23) v2(318.5,60.56) v2(318.5,58.57) v2(319.06,63.6) v2(319.66,5.23) v2(320.58,63.6) v2(321.43,5.23) v2(321.99,63.05) v2(321.99,61.78) v2(321.99,60.51) v2(321.99,59.24) v2(321.99,57.97) v2(321.99,56.7) v2(321.99,55.43) v2(322.02,54.26) v2(322.2,5.23) v2(322.36,26.06) v2(322.36,25.48) v2(322.37,24.9) v2(322.82,53.29) v2(322.84,13.74) v2(323.47,5.23) v2(324.47,12.47) v2(324.75,53.17) v2(324.74,5.23) v2(326.01,5.23) v2(326.27,53.17) v2(327.28,5.23) v2(327.8,53.17) v2(328.55,5.23) v2(329.29,53.17) v2(329.38,40.27) v2(329.82,5.23) v2(330.21,37.95) v2(330.3,45.57) v2(330.3,43.59) v2(330.56,53.17) v2(331.29,44.58) v2(331.59,5.23) v2(331.94,53.17) v2(332.28,43.59) v2(332.36,5.23) v2(333.46,53.17) v2(333.63,5.23) v2(334.9,5.23) v2(334.98,53.17) v2(335.28,33.51) v2(335.28,31.73) v2(336.17,5.23) v2(336.91,53.17) v2(337.44,5.23) v2(337.99,52.5) v2(337.98,51.39) v2(337.98,49.86) v2(337.98,48.34) v2(337.98,46.82) v2(337.98,45.29) v2(337.99,43.61) v2(337.99,42.34) v2(337.98,41.1) v2(337.98,39.58) v2(337.98,38.05) v2(337.99,35.99) v2(337.99,33.45) v2(337.98,32.13) v2(337.99,30.91) v2(337.98,29.7) v2(337.98,28.17) v2(337.98,26.65) v2(337.98,25.12) v2(337.99,23.29) v2(337.99,22.02) v2(337.98,20.88) v2(337.98,19.36) v2(337.98,17.83) v2(337.98,16.31) v2(337.98,14.79) v2(337.99,13.13) v2(337.99,11.86) v2(337.98,10.65) v2(337.98,9.12) v2(337.98,7.6) v2(337.98,6.07) v3(13.88,30.86) v3(55.63,22.79) v3(80.65,21.07) v3(86.27,32.99) v3(88.11,50) v3(94.65,32.36) v3(123.87,141.77) v3(141.49,145.35) v3(187.05,141.34) v3(187.64,137.01) v3(190.27,160.04) v3(214.03,146.08) v3(216.23,104.05) v3(216.37,86.35) v3(220.72,45.39) v3(230.56,122.42) v3(234.68,154.14) v3(240.13,146.5) v3(242.46,119.73) v3(254.16,142.37) v3(254.92,29.91) v3(256.46,151.57) v3(259.41,120.39) v3(261.15,154.24) v3(265.35,18.79) v3(265.77,123.84) v3(266.11,130.11) v3(267.47,31.26) v3(279.66,49.48) v3(292.05,42.93) v3(292.13,71.95) v3(293.11,51.73) v3(296.08,70.36) v3(297.3,44.66) v3(297.75,61.09) v3(298.32,52.06)
