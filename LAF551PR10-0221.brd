# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FB_A_WCK67: length 40.7
  IN2 w0.089: v2(249.47,106.05) 249.47,106.12 249.57,106.22 249.64,106.22 249.88,106.46 253.96,106.46 254.8,105.62 275.84,105.62 277.22,107 277.22,108.42 277.5,108.7 277.5,111.04 278.4,111.94 279.04,111.94 281.37,114.28 281.37,115.14 v2(280.95,115.56)
  BOTTOM w0.102: UG9.AR45 v2(249.47,106.05)
  BOTTOM w0.119: UG2.P4 280.59,115.96 280.95,115.6 v2(280.95,115.56)
FB_A_WCK#01: length 27
  IN2 w0.089: 262.77,95.69 262.75,95.69 262.73,95.66 259.39,95.66 258.83,95.11 254.83,95.11 254.01,94.29 249.76,94.29 249.36,93.89 249.21,93.89 v2(248.77,93.45)
  IN2 w0.102: v2(272.15,91.76) 272.15,91.85 271.51,92.49 266.34,92.49 263.15,95.69 262.77,95.69
  BOTTOM w0.102: UG9.U44 v2(248.77,93.45)
  BOTTOM w0.119: UG1.P5 v2(272.15,91.76)
FB_A_WCK#23: length 39
  IN2 w0.089: v2(248.77,97.65) 248.96,97.65 249.18,97.88 249.18,98.16 249.42,98.4 249.42,98.4 249.47,98.45 249.47,98.45 249.61,98.59 256.21,98.59 258.25,100.63 275.27,100.63 277.82,98.07 277.82,95 279.95,92.87 279.95,92.76 v2(280.15,92.56)
  BOTTOM w0.102: UG9.AC44 v2(248.77,97.65)
  BOTTOM w0.119: v2(280.15,92.56) UG1.D5
FB_A_WCK#45: length 29.8
  IN2 w0.089: v2(272.95,115.56) 273.06,115.56 273.16,115.46 273.16,115.1 272.53,114.47 272.41,114.47 272.4,114.46 266.32,114.46 266.18,114.31 266.16,114.31 264.97,113.12 256.47,113.12 255.71,112.37 255.71,109.54 255.17,108.99 251.46,108.99 250.98,108.51 250.72,108.51 250.51,108.3 250.51,108.15 250.42,108.06 250.26,108.06 v2(250.17,108.15)
  BOTTOM w0.102: UG9.AV46 250.47,108.31 250.31,108.15 v2(250.17,108.15)
  BOTTOM w0.119: v2(272.95,115.56) 272.89,115.62 272.57,115.62 272.42,115.47 272.42,115.29 UG2.D5
FB_A_WCK#67: length 40.8
  IN2 w0.089: v2(248.77,106.05) 248.96,106.05 249.32,106.41 249.58,106.41 249.81,106.64 254.03,106.64 254.87,105.8 275.77,105.8 277.05,107.08 277.05,108.49 277.32,108.77 277.32,111.14 278.32,112.13 278.96,112.13 281.18,114.35 281.18,114.62 281.04,114.76 v2(280.95,114.76)
  BOTTOM w0.102: v2(248.77,106.05) 248.77,106.23 248.89,106.35 UG9.AR44
  BOTTOM w0.119: UG2.P5 280.44,115.06 280.44,114.88 280.67,114.66 280.84,114.66 v2(280.95,114.76)
FB_B_CLK0: length 40.2
  IN6 w0.102: 247.33,87.11 v2(247.97,87.75)
  IN6 w0.107: v2(259.59,61.11) 259.79,60.91 259.83,60.91 260.04,60.7 260.55,60.7 261.69,61.83 261.69,62.75 262.18,63.24 262.4,63.24 262.5,63.34 262.5,63.83 v2(262.74,64.06) 262.74,63.54 262.85,63.43 263.41,63.43 263.7,63.72 263.7,67.52 247.33,83.89 247.33,87.11
  BOTTOM w0.102: UG9.H42 v2(247.97,87.75)
  BOTTOM w0.119: RG113.1 262.91,63.88 v2(262.74,64.06) ; UG3.J12 259.19,61.03 259.27,61.11 v2(259.59,61.11)
FB_B_CLK1: length 39.7
  TOP w0.102: RG114.1 273.99,70.58 273.99,71 273.78,71.21 v2(273.45,71.21)
  IN1 w0.102: v2(250.87,85.75) 250.87,85.55 251.15,85.27 251.15,84.69
  IN1 w0.107: v2(276.15,74.16) 276.36,73.96 276.36,73.94 276.53,73.76 276.53,72.91 275.5,71.87 274.76,71.87 274.1,71.21 v2(273.45,71.21) 273.65,71.01 273.73,71.01 274,70.74 274,70.59 273.7,70.29 271.59,70.29 260.35,81.53 253.05,81.53 251.6,82.98 251.6,84.24 251.15,84.69
  BOTTOM w0.102: UG9.F47 251.17,85.85 251.07,85.75 v2(250.87,85.75)
  BOTTOM w0.119: v2(276.15,74.16) 276.15,74.44 276.27,74.56 276.55,74.56 UG4.J12
FB_B_CLK#0: length 40
  IN6 w0.102: v2(247.97,87.05) 247.85,87.17 247.67,87.17 247.53,87.03
  IN6 w0.107: v2(258.79,61.11) 259.46,60.71 259.75,60.71 259.96,60.51 260.64,60.51 261.88,61.75 261.88,62.67 262.26,63.04 262.46,63.04 v2(262.74,62.76) 262.74,63.01 262.96,63.23 263.49,63.23 263.9,63.64 263.9,63.8 263.89,63.8 263.89,67.6 247.53,83.97 247.53,87.03
  BOTTOM w0.102: UG9.G42 v2(247.97,87.05)
  BOTTOM w0.119: v2(258.79,61.11) 258.57,60.9 258.57,60.89 UG3.J11 ; v2(262.74,62.76) 262.95,62.97 RG525.1
FB_B_CLK#1: length 39.7
  TOP w0.102: 274.2,71.05 274.37,71.21 v2(274.75,71.21)
  TOP w0.119: RG526.1 274.2,70.67 274.2,71.05
  IN1 w0.102: 250.91,84.66 250.91,84.93 v2(250.75,85.08)
  IN1 w0.107: 250.91,84.66 251.41,84.16 251.41,82.9 252.97,81.33 260.27,81.33 271.51,70.09 273.78,70.09 273.78,70.1 273.84,70.1 274.25,70.51 274.25,70.85 274.61,71.21 v2(274.75,71.21) 274.66,71.3 274.66,71.49 274.84,71.68 275.58,71.68 276.73,72.82 276.73,73.84 276.55,74.02 276.55,74.48 276.15,74.88 v2(276.15,74.96)
  BOTTOM w0.102: v2(250.75,85.08) 250.9,85.08 UG9.E47
  BOTTOM w0.119: UG4.J11 v2(276.15,74.96)
FB_B_CMD0: length 30.7
  BOTTOM w0.102: 242.3,78.4 242.42,78.53 242.42,82.75 242.77,83.1 UG9.B35
  BOTTOM w0.185: UG3.G3 251.59,59.51 250.14,59.51 249.99,59.36 249.63,59.36 249.37,59.62 248.87,59.62 247.77,60.71 247.77,68.6 244.81,71.56 243.57,71.56 242.3,72.83 242.3,78.4
FB_B_CMD1: length 29.6
  TOP w0.102: RG49.2 251.48,60.2 v2(251.59,60.31)
  BOTTOM w0.102: UG3.J3 251.82,60.54 v2(251.59,60.31) ; UG9.A35 242.77,78.38 242.72,78.33 242.72,75.5 242.84,75.38
  BOTTOM w0.185: 242.84,75.38 242.84,73.05 243.8,72.1 245.04,72.1 248.31,68.82 248.31,60.93 248.99,60.26 250.03,60.26 250.08,60.31 v2(251.59,60.31)
FB_B_CMD2: length 29.1
  TOP w0.102: RG56.1 250.69,61.2 v2(250.79,61.11)
  BOTTOM w0.102: UG9.D35 243.12,84.3 243.12,75.21 ; v2(250.79,61.11) 251.02,60.87 UG3.J2
  BOTTOM w0.142: 250.76,61.14 v2(250.79,61.11)
  BOTTOM w0.185: 243.12,75.21 244.55,73.78 244.55,73.35 248.86,69.04 248.93,68.97 248.93,61.46 249.18,61.21 249.75,61.21 249.82,61.14 250.76,61.14
FB_B_CMD3: length 25.5
  BOTTOM w0.102: UG9.A36 243.47,75.36
  BOTTOM w0.185: 243.47,75.36 244.93,73.9 244.93,73.74 249.4,69.27 249.51,69.16 249.51,62.4 249.83,62.08 250.01,62.08 250.19,61.91 251.59,61.91 UG3.L3
FB_B_CMD4: length 27.3
  BOTTOM w0.102: UG9.B36 243.47,83.05 243.82,82.7 243.82,75.61
  BOTTOM w0.185: 243.82,75.61 250.85,68.58 252.67,68.58 254.01,67.24 254.01,61.93 253.59,61.51 UG3.K5
FB_B_CMD5: length 29.5
  BOTTOM w0.102: UG9.C36 243.47,83.71 243.82,83.36 243.82,83.05 244.07,82.8 244.07,80.21 244.21,80.07 244.21,75.99
  BOTTOM w0.185: 244.21,75.99 251.33,68.87 252.79,68.87 254.3,67.36 254.3,67.12 254.3,61.67 253.74,61.11 253.19,61.11 UG3.K4
FB_B_CMD6: length 29
  BOTTOM w0.102: 244.63,76.33 244.63,80.07 244.3,80.4 244.3,82.88 244.52,83.1 244.52,83.6 UG9.C38
  BOTTOM w0.185: 244.63,76.33 251.81,69.15 252.91,69.15 254.58,67.48 254.58,67 254.58,67 254.58,61.36 253.94,60.71 UG3.J5
FB_B_CMD7: length 29.6
  BOTTOM w0.102: 244.98,76.92 244.98,80.13 244.52,80.59 244.52,82.75 244.87,83.1 UG9.B38
  BOTTOM w0.185: UG3.J4 253.19,60.31 254.24,60.31 254.87,60.94 254.87,66.88 254.87,67.59 253.02,69.44 252.46,69.44 244.98,76.92
FB_B_CMD8: length 28.1
  BOTTOM w0.102: UG9.A38 244.87,80.72 245.35,80.24 245.35,77.32
  BOTTOM w0.185: 245.35,77.32 252.94,69.73 253.14,69.73 255.16,67.71 255.16,66.76 255.16,60.78 254.29,59.91 UG3.H5
FB_B_CMD9: length 31.8
  BOTTOM w0.102: UG9.D38 245.22,84.3 245.22,80.95 245.69,80.48 245.69,77.77
  BOTTOM w0.185: UG3.H4 253.19,59.51 254.39,59.51 255.44,60.57 255.44,66.64 255.44,68.19 253.37,70.27 253.19,70.27 245.69,77.77
FB_B_CMD10: length 30.6
  BOTTOM w0.102: UG9.A39 245.57,81.05 246.08,80.54 246.08,77.91
  BOTTOM w0.185: 246.08,77.91 250.36,73.63 250.6,73.63 253.42,70.81 253.59,70.81 255.73,68.67 255.73,66.52 255.73,60.42 256.64,59.51 258.79,59.51 UG3.G12
FB_B_CMD11: length 29.1
  BOTTOM w0.102: UG9.B39 245.57,83.05 245.92,82.7 245.92,81.34 246.38,80.87 246.38,79 246.51,78.87 246.51,78.18
  BOTTOM w0.185: UG3.H10 256.74,59.91 256.02,60.63 256.02,66.4 256.02,69.15 253.82,71.35 253.64,71.35 251.04,73.95 250.74,73.95 246.51,78.18
FB_B_CMD12: length 30.3
  BOTTOM w0.102: UG9.C39 245.57,83.8 245.92,83.45 245.92,83.05 246.17,82.8 246.17,81.86 246.75,81.27 246.75,79.06 246.86,78.95 246.86,78.55
  BOTTOM w0.185: UG3.H11 257.99,60.31 256.84,60.31 256.31,60.84 256.31,66.28 256.31,69.63 254.04,71.89 253.86,71.89 251.53,74.22 251.19,74.22 246.86,78.55
FB_B_CMD13: length 30.6
  BOTTOM w0.102: UG9.C41 246.62,83.6 246.62,83.1 246.39,82.87 246.39,82.12 247.02,81.49 247.02,79.3 247.27,79.05 247.27,78.85 251.56,74.56 253.86,74.56
  BOTTOM w0.185: UG3.K11 257.99,61.11 257.34,61.11 257.24,61.21 256.89,61.21 256.59,61.5 256.59,66.16 256.59,66.17 256.59,67.79 256.8,68 256.8,71.62 253.86,74.56
FB_B_CMD14: length 28.6
  BOTTOM w0.102: 254.52,74.92 251.9,74.92 247.33,79.49 247.33,81.64 246.62,82.35 246.62,82.75 246.97,83.1 UG9.B41
  BOTTOM w0.185: 254.52,74.92 257.37,72.06 257.37,68.06 256.89,67.57 256.89,61.81 257.19,61.51 UG3.K10
FB_B_CMD15: length 29.2
  BOTTOM w0.102: UG9.A41 247.57,81.95 247.57,79.71 251.24,76.05 251.47,76.05 252.15,75.37 254.84,75.37
  BOTTOM w0.185: 254.84,75.37 257.95,72.26 257.95,68.13 257.19,67.37 257.19,62.16 257.44,61.91 258.79,61.91 UG3.L12
FB_B_CMD16: length 31.9
  BOTTOM w0.102: UG9.B49 252.92,82.9 252.92,82.35 252.77,82.2 252.77,81.96 253.18,81.55 254.72,81.55 256.74,83.57
  BOTTOM w0.185: 256.74,83.57 260.88,83.57 262.26,84.95 267.47,84.95 268.23,85.72 276.68,85.72 277.85,84.54 277.85,83.66 277.75,83.56 277.75,82.16 UG4.L3
FB_B_CMD17: length 33.2
  TOP w0.102: v2(276.95,82.16) 276.55,81.76 276.55,80.33 RG50.2
  BOTTOM w0.102: 256.73,82.9 255.1,81.27 252.91,81.27 252.32,81.86 252.32,82.3 UG9.A49 ; UG4.J3 v2(276.95,82.16)
  BOTTOM w0.185: 256.73,82.9 261.04,82.9 262.33,84.19 267.79,84.19 268.83,85.23 276.4,85.23 276.95,84.68 v2(276.95,82.16)
FB_B_CMD18: length 32.5
  TOP w0.102: v2(276.15,82.96) 275.73,82.54 275.73,80.31 RG55.1
  BOTTOM w0.102: 256.92,82.4 255.46,80.94 252.8,80.94 252.02,81.72 252.02,82.4 UG9.A48 ; v2(276.15,82.96) 276.37,82.74 UG4.J2
  BOTTOM w0.185: 256.92,82.4 261.23,82.4 262.25,83.41 267.62,83.41 267.97,83.76 268.18,83.76 269.16,84.73 275.63,84.73 276.05,84.31 276.05,83.86 276.15,83.76 v2(276.15,82.96)
FB_B_CMD19: length 31.1
  BOTTOM w0.102: UG9.D47 251.52,84.3 251.52,81.74 252.59,80.67 255.77,80.67 257,81.9
  BOTTOM w0.185: UG4.G3 275.35,82.16 275.35,83.56 274.67,84.24 269.43,84.24 268.23,83.05 267.79,83.05 267.38,82.64 262.36,82.64 261.62,81.9 257,81.9
FB_B_CMD20: length 28.1
  BOTTOM w0.102: UG9.A47 251.17,81.57 252.36,80.38 256.07,80.38 256.96,81.27
  BOTTOM w0.185: 256.96,81.27 261.57,81.27 262.16,81.87 268.39,81.87 269.44,80.82 269.44,80.25 269.95,79.75 275.33,79.75 UG4.H5
FB_B_CMD21: length 30.4
  BOTTOM w0.102: UG9.B47 251.17,83.1 250.82,82.75 250.82,81.49 252.25,80.06 253.73,80.06 253.86,79.94 256.3,79.94 257.1,80.74
  BOTTOM w0.185: 257.1,80.74 261.92,80.74 262.28,81.1 267.99,81.1 269.63,79.46 275.6,79.46 276.15,80.01 276.15,80.56 UG4.H4
FB_B_CMD22: length 31.1
  BOTTOM w0.102: 261.87,79.58 253.72,79.58 253.55,79.75 252.18,79.75 250.56,81.37 250.56,82.85 250.82,83.1 250.82,83.6 UG9.C47
  BOTTOM w0.185: 261.87,79.58 262.62,80.33 267.29,80.33 267.47,80.51 268.11,80.51 269.44,79.17 275.96,79.17 276.55,79.76 UG4.J5
FB_B_CMD23: length 33.3
  BOTTOM w0.102: UG9.C45 249.77,83.8 250.12,83.45 250.12,83.05 250.32,82.85 250.32,82.78 250.32,82.12 250.32,82.12 250.32,81.19 252.08,79.43 253.4,79.43 253.74,79.09 262.2,79.09
  BOTTOM w0.185: 262.2,79.09 262.67,79.56 267.22,79.56 267.6,79.94 268.23,79.94 269.28,78.89 276.52,78.89 276.95,79.31 276.95,80.56 UG4.J4
FB_B_CMD24: length 32.5
  BOTTOM w0.102: UG9.B45 249.77,83.05 250.12,82.7 250.12,82.21 250.03,82.11 250.03,80.98 251.89,79.11 253.28,79.11 253.69,78.7 262.5,78.7 262.59,78.79 262.82,78.79
  BOTTOM w0.185: 262.82,78.79 267.27,78.79 267.66,79.18 268.42,79.18 269,78.6 277.04,78.6 277.35,78.91 UG4.K5
FB_B_CMD25: length 33.5
  BOTTOM w0.102: UG9.A45 249.77,80.79 251.77,78.79 253.07,78.79 253.59,78.28 262.18,78.28
  BOTTOM w0.185: 262.18,78.28 262.44,78.02 267.33,78.02 267.57,78.26 277.1,78.26 277.64,78.79 277.64,78.8 277.75,78.91 277.75,80.56 UG4.K4
FB_B_CMD26: length 37.2
  BOTTOM w0.102: 261.82,77.8 253.49,77.8 252.81,78.48 251.61,78.48 249.42,80.67 249.42,84.3 UG9.D44
  BOTTOM w0.185: 261.82,77.8 262.37,77.24 267.51,77.24 268.23,77.97 276.84,77.97 277.75,77.06 277.75,74.96 UG4.L12
FB_B_CMD27: length 33.8
  BOTTOM w0.102: 260.91,77.35 253.47,77.35 252.72,78.1 251.45,78.1 249.07,80.48 UG9.A44
  BOTTOM w0.185: UG4.K10 277.35,76.96 276.63,77.68 268.58,77.68 267.17,76.27 261.99,76.27 260.91,77.35
FB_B_CMD28: length 36
  BOTTOM w0.102: UG9.B44 249.07,83.1 248.72,82.75 248.72,81.94 248.77,81.89 248.77,80.3 251.26,77.81 252.57,77.81 253.36,77.02 259.86,77.02
  BOTTOM w0.185: UG4.K11 276.95,75.76 276.95,76.91 276.47,77.39 268.99,77.39 267.03,75.43 261.45,75.43 259.86,77.02
FB_B_CMD29: length 36.6
  BOTTOM w0.102: 257.12,76.57 253.13,76.57 252.44,77.26 251.41,77.26 248.52,80.15 248.52,82.9 248.72,83.1 248.72,83.6 UG9.C44
  BOTTOM w0.185: UG4.H11 276.15,75.76 276.15,76.36 276.05,76.46 276.05,76.86 275.8,77.11 269.4,77.11 266.96,74.67 259.03,74.67 257.12,76.57
FB_B_CMD30: length 36.1
  BOTTOM w0.102: UG9.C42 247.67,83.8 248.02,83.45 248.02,83.05 248.27,82.8 248.27,82.05 248.22,82 248.22,80.01 251.29,76.94 252.07,76.94 252.87,76.13 256.42,76.13
  BOTTOM w0.185: UG4.H10 275.75,76.5 275.43,76.82 269.75,76.82 266.71,73.78 258.77,73.78 256.42,76.13
FB_B_CMD31: length 38.4
  BOTTOM w0.102: UG9.B42 247.67,83.05 248.02,82.7 248.02,82.35 247.89,82.22 247.89,79.91 251.25,76.55 251.74,76.55 252.48,75.81 256,75.81
  BOTTOM w0.185: 256,75.81 259.11,72.7 267.41,72.7 268.87,74.16 268.87,75.49 269.91,76.53 275.13,76.53 275.35,76.31 275.35,74.96 UG4.G12
FB_B_D0: length 25.8
  IN6 w0.102: v2(240.37,87.15) 241.29,86.23 241.29,84.52 241.28,84.51 241.28,84.19 241.29,84.18 241.29,83.86 242.39,82.76 242.39,82.35 243.98,80.76
  IN6 w0.13: 243.98,80.76 243.98,78.35 253.07,69.26 253.07,67.89 v2(252.83,67.66)
  BOTTOM w0.102: v2(252.83,67.66) 252.79,67.61 252.79,67.11 UG3.U4 ; UG9.H32 v2(240.37,87.15)
FB_B_D1: length 22.3
  IN6 w0.102: 242.49,75.62 241.02,77.09 241.02,80.6 241.01,80.61 241.01,80.62 240.79,80.84 240.78,80.84 v2(240.62,81)
  IN6 w0.13: v2(250.79,67.51) 250.67,67.51 249.98,68.2 249.91,68.2 242.49,75.62
  BOTTOM w0.102: UG3.U2 251,67.29 v2(250.79,67.51) ; UG9.D32 241.02,84.3 241.02,81.4 v2(240.62,81)
FB_B_D2: length 21.3
  IN6 w0.102: 242.71,80.73 241.42,82.01 v2(241.42,82.1)
  IN6 w0.13: 242.71,80.73 242.71,77.06 251.26,68.5 251.75,68.5 251.98,68.27 251.98,68.27 252.04,68.21 252.04,67.06 v2(252.39,66.71)
  BOTTOM w0.102: v2(252.39,66.71) 252.62,66.48 UG3.T4 ; UG9.A33 241.37,82.15 v2(241.42,82.1)
FB_B_D3: length 22.3
  IN6 w0.102: v2(240.62,81.55) 240.78,81.39 240.79,81.39 241.01,81.17 241.01,81.16 241.09,81.08 241.55,81.08 242.07,80.56
  IN6 w0.13: v2(250.79,66.71) 251.19,67.11 251.19,67.78 242.07,76.9 242.07,80.56
  BOTTOM w0.102: UG3.T2 250.99,66.51 v2(250.79,66.71) ; UG9.B32 240.67,83.1 240.34,82.77 240.34,82.35 240.24,82.25 240.24,81.93 v2(240.62,81.55)
FB_B_D4: length 30.3
  IN6 w0.102: v2(240.23,84.2) 240.27,84.16 240.27,83.43 239.65,82.82 239.65,76.76 240.74,75.68 240.74,75.62
  IN6 w0.13: 240.74,75.62 240.74,75.46 246.52,69.67 246.52,66.28 249.69,63.11 251.99,63.11 v2(252.39,63.51)
  BOTTOM w0.102: v2(240.23,84.2) 240.31,84.28 240.31,84.79 240.67,85.15 UG9.E32 ; v2(252.39,63.51) 252.61,63.74 252.61,63.74 UG3.N4
FB_B_D5: length 30.1
  IN6 w0.102: v2(240.29,86.44) 240.93,85.8 240.93,83.35 241.94,82.34 241.94,82.16 243.28,80.83
  IN6 w0.13: v2(250.79,64.31) 251.18,64.7 252.66,64.7 252.79,64.84 252.79,67.01 252.36,67.44 252.36,68.7 243.28,77.78 243.28,80.83
  BOTTOM w0.102: UG9.G32 240.6,86.75 v2(240.29,86.44) ; v2(250.79,64.31) UG3.N2
FB_B_D6: length 34.9
  IN6 w0.102: 240.17,75.72 239.19,76.7 239.19,83.37 239.03,83.53 239.03,87.91 v2(239.57,88.45)
  IN6 w0.13: 240.17,75.72 240.17,75.24 245.96,69.44 245.96,65.66 249.41,62.21 251.89,62.21 v2(252.39,62.71)
  BOTTOM w0.102: UG9.J30 v2(239.57,88.45) ; UG3.M4 252.61,62.94 v2(252.39,62.71)
FB_B_D7: length 28.4
  IN6 w0.102: 241.37,75.62 240.71,76.28 240.61,76.28 240.12,76.78 240.12,82.58 240.62,83.08 240.62,85.5 v2(240.37,85.75)
  IN6 w0.13: v2(250.79,63.51) 250.39,63.91 249.71,63.91 247.09,66.53 247.09,69.9 241.37,75.62
  BOTTOM w0.102: v2(250.79,63.51) 251.04,63.26 251.04,63.26 UG3.M2 ; UG9.F32 v2(240.37,85.75)
FB_B_D8: length 28.7
  IN1 w0.13: v2(258.79,67.51) 258.69,67.51 257.81,68.39 256.66,68.39 250.79,74.26 250.79,74.71 244.77,80.73 244.77,81.74 242.87,83.64 242.87,87.45 v2(243.17,87.75)
  BOTTOM w0.102: UG3.U11 258.58,67.3 258.58,67.3 v2(258.79,67.51) ; v2(243.17,87.75) UG9.H36
FB_B_D9: length 29.2
  IN1 w0.102: v2(243.77,87.05) 244.06,86.76 245.02,86.76
  IN1 w0.13: 245.02,86.76 245.48,86.3 245.48,83.84 246.33,82.99 246.33,81.58 252.48,75.43 252.48,74.95 256.99,70.44 258.6,70.44 260.7,68.34 260.7,67.82 v2(260.39,67.51)
  BOTTOM w0.102: UG3.U13 260.17,67.29 260.17,67.29 v2(260.39,67.51) ; UG9.G36 v2(243.77,87.05)
FB_B_D10: length 30.3
  IN1 w0.13: v2(258.79,66.71) 259.18,67.1 259.18,67.67 259.18,67.68 259.18,67.72 257.63,69.27 256.58,69.27 256,69.85 251.35,74.5 251.35,74.94 245.33,80.96 245.33,81.79 243.26,83.86 243.26,87.19 243.61,87.55 243.61,88.29 v2(243.77,88.45)
  BOTTOM w0.102: UG3.T11 258.57,66.5 v2(258.79,66.71) ; UG9.J36 v2(243.77,88.45)
FB_B_D11: length 28.9
  IN1 w0.13: v2(243.77,86.35) 243.79,86.35 244.14,86 244.82,86 245.07,85.75 245.07,83.66 245.78,82.95 245.78,81.31 251.91,75.17 251.91,74.73 256.87,69.78 258.26,69.78 258.92,69.12 259.17,69.12 259.98,68.31 259.98,67.11 v2(260.39,66.71)
  BOTTOM w0.102: UG3.T13 260.19,66.51 v2(260.39,66.71) ; UG9.F36 v2(243.77,86.35)
FB_B_D12: length 31.1
  IN1 w0.102: v2(241.77,86.45) 241.53,86.21 241.53,85.37 241.28,85.12 241.28,83.85
  IN1 w0.13: v2(258.79,64.31) 258.59,64.31 258.19,64.71 257.74,64.71 256.42,66.03 256.42,67.05 249.67,73.8 249.67,74.24 243.61,80.3 243.61,81.52 241.28,83.85
  BOTTOM w0.102: UG9.F33 v2(241.77,86.45) ; v2(258.79,64.31) UG3.N11
FB_B_D13: length 30.1
  IN1 w0.13: v2(241.67,84.35) 242.18,84.35 242.48,84.05 242.48,83.33 244.19,81.62 244.19,80.52 250.23,74.48 250.23,74.03 257.04,67.22 257.04,66.24 257.77,65.51 258.21,65.51 258.39,65.33 258.39,64.93 258.61,64.71 259.99,64.71 v2(260.39,64.31)
  BOTTOM w0.102: UG9.D33 v2(241.67,84.35) ; v2(260.39,64.31) UG3.N13
FB_B_D14: length 34.9
  IN1 w0.102: 240.85,83.36 240.85,85.33 241.1,85.58 241.1,87.72 v2(240.37,88.45)
  IN1 w0.13: v2(258.79,63.51) UG3.M11 257.75,63.11 254.91,65.96 254.91,66.66 248.55,73.02 248.55,73.78 242.29,80.03 242.29,81.92 240.85,83.36
  BOTTOM w0.102: v2(258.79,63.51) UG3.M11 ; UG9.J32 v2(240.37,88.45)
FB_B_D15: length 34.1
  IN1 w0.102: v2(241.67,87.05) 241.31,86.69 241.31,85.47 241.07,85.23 241.07,83.64
  IN1 w0.13: 241.07,83.64 242.98,81.73 242.98,80.14 249.11,74.01 249.11,73.57 255.56,67.11 255.56,66.13 257.78,63.91 259.99,63.91 v2(260.39,63.51)
  BOTTOM w0.102: v2(260.39,63.51) UG3.M13 ; UG9.G33 v2(241.67,87.05)
FB_B_D16: length 49.2
  IN1 w0.13: v2(250.07,85.05) 250.56,84.56 250.56,84.16 250.77,83.95 250.77,82.77 252.71,80.83 253.6,80.83 259.13,75.29 259.15,75.29 259.27,75.17 260.22,75.17 266.62,68.77 266.62,55.62 263.61,52.61 258.64,52.61 257.99,53.26 v2(257.99,53.91)
  BOTTOM w0.102: UG3.A11 258.15,54.08 v2(257.99,53.91) ; v2(250.07,85.05) UG9.E45
FB_B_D17: length 45
  IN1 w0.13: v2(259.59,53.91) 260.25,53.25 263.25,53.25 266.06,56.06 266.06,68.54 259.99,74.61 258.92,74.61 253.37,80.16 252.71,80.16 249.92,82.95 249.92,84.2 v2(250.07,84.35)
  BOTTOM w0.102: UG3.A13 259.81,54.13 259.81,54.13 v2(259.59,53.91) ; UG9.D45 v2(250.07,84.35)
FB_B_D18: length 47.5
  IN1 w0.13: v2(250.07,86.35) 249.6,85.88 249.6,82.57 252.77,79.4 253.34,79.4 258.71,74.03 259.78,74.03 265.5,68.31 265.5,56.47 262.9,53.87 260.55,53.87 260.11,54.31 258.39,54.31 v2(257.99,54.71)
  BOTTOM w0.102: UG3.B11 258.23,54.95 v2(257.99,54.71) ; v2(250.07,86.35) UG9.F45
FB_B_D19: length 44.7
  IN1 w0.13: v2(260.39,54.71) 260.84,54.26 262.21,54.26 262.82,54.87 262.82,55.7 264.84,57.72 264.84,68.17 259.62,73.4 258.55,73.4 253,78.95 252.59,78.95 249.19,82.35 249.19,86.28 249.71,86.8 249.71,87.2 v2(249.69,87.22)
  BOTTOM w0.102: UG9.G45 249.77,87.14 v2(249.69,87.22) ; v2(260.39,54.71) 260.17,54.92 UG3.B13
FB_B_D20: length 39.4
  IN1 w0.13: v2(258.79,57.11) 259.19,57.51 262.26,57.51 263.72,58.97 263.72,67.71 259.3,72.13 258.23,72.13 248.13,82.22 248.13,83.27 247.78,83.62 247.78,84.16 v2(247.97,84.35)
  BOTTOM w0.102: UG3.E11 v2(258.79,57.11) ; UG9.D42 v2(247.97,84.35)
FB_B_D21: length 39.7
  IN1 w0.13: v2(247.97,85.05) 248.69,84.33 248.69,82.46 258.39,72.76 259.46,72.76 264.28,67.94 264.28,58.49 262.5,56.71 260.79,56.71 v2(260.39,57.11)
  BOTTOM w0.102: v2(260.39,57.11) UG3.E13 ; UG9.E42 v2(247.97,85.05)
FB_B_D22: length 40.3
  IN1 w0.13: v2(258.79,57.91) 259.19,58.31 261.51,58.31 261.84,58.63 262.17,58.63 263.16,59.62 263.16,67.47 259.07,71.57 257.87,71.57 255.79,73.65 255.79,73.65 247.39,82.05 247.39,85.77 v2(247.97,86.35)
  BOTTOM w0.102: UG3.F11 258.56,58.13 v2(258.79,57.91) ; UG9.F42 v2(247.97,86.35)
FB_B_D23: length 41.3
  IN1 w0.13: v2(246.67,87.75) 247.09,87.33 247.09,84.6 246.8,84.31 246.8,81.91 253.09,75.62 253.09,75.14 257.23,71 258.83,71 262.08,67.76 262.08,61.82 261.95,61.7 260.83,61.7 260.7,61.57 260.7,61.39 260.83,61.27 261.95,61.27 262.08,61.14 262.08,59.49 261.8,59.21 260.89,59.21 v2(260.39,58.71)
  BOTTOM w0.102: v2(260.39,58.71) 260.16,58.48 UG3.F13 ; UG9.H41 v2(246.67,87.75)
FB_B_D24: length 44.3
  IN6 w0.102: 248.36,81.46 246.71,83.11 246.71,85.01 v2(246.67,85.05)
  IN6 w0.13: 248.36,81.46 248.36,80 257.52,70.83 257.52,69.74 257.58,69.69 257.58,61.66 257.7,61.53 257.89,61.53 258.02,61.41 258.02,61.23 257.89,61.1 257.7,61.1 257.58,60.98 257.58,60.8 257.7,60.67 257.89,60.67 258.02,60.55 258.02,60.37 257.89,60.24 257.7,60.24 257.41,59.95 257.41,59.77 257.59,59.58 257.59,59.41 257.47,59.28 257.29,59.28 257.1,59.47 256.92,59.47 256.22,58.76 256.22,53.9 255.91,53.59 255.77,53.59 255.64,53.46 255.64,53.39 255.52,53.26 255.34,53.26 255.21,53.39 255.21,53.46 255.09,53.59 254.91,53.59 254.79,53.46 254.79,53.39 254.66,53.26 254.48,53.26 254.36,53.39 254.36,53.46 254.23,53.59 253.51,53.59 v2(252.39,54.71)
  BOTTOM w0.102: v2(252.39,54.71) 252.63,54.47 252.63,54.47 UG3.A4 ; UG9.E41 v2(246.67,85.05)
FB_B_D25: length 47.2
  IN6 w0.102: v2(245.87,86.35) 246.08,86.35 246.41,86.02 246.88,86.02 247.09,85.81 247.09,83.37 248.99,81.46
  IN6 w0.13: 248.99,81.46 248.99,80.16 258.38,70.77 258.38,59.75 257.54,58.91 257.54,56.51 256.67,55.64 256.67,52.92 256.42,52.66 255.89,52.66 255.77,52.54 255.77,52.46 255.64,52.33 255.46,52.33 255.34,52.46 255.34,52.54 255.21,52.66 255.03,52.66 254.91,52.54 254.91,52.46 254.78,52.33 254.6,52.33 254.47,52.46 254.47,52.54 254.35,52.66 252.77,52.66 251.59,53.85 v2(251.59,53.91)
  BOTTOM w0.102: v2(251.59,53.91) 251.34,54.16 251.34,54.16 UG3.A2 ; UG9.F39 v2(245.87,86.35)
FB_B_D26: length 42.8
  IN6 w0.102: v2(245.87,85.05) 246.5,84.42 246.5,82.46 247.6,81.37
  IN6 w0.13: 247.6,81.37 247.6,79.81 256.96,70.44 256.96,61.49 256.41,60.94 256.41,59.97 256.27,59.83 256.09,59.83 255.73,60.18 255.55,60.18 255.43,60.06 255.43,59.88 255.79,59.52 255.79,59.34 255.61,59.17 255.61,58.23 255.82,58.02 255.82,57.8 255.61,57.59 255.61,57.37 255.82,57.16 255.82,56.94 255.61,56.73 255.61,56.51 255.82,56.3 255.82,56.08 255.61,55.87 255.61,55.66 255.82,55.45 255.82,55.23 255.61,55.02 255.61,54.44 255.43,54.26 255.14,54.26 255.01,54.39 255.01,55 254.89,55.13 254.71,55.13 254.58,55 254.58,54.39 254.46,54.26 253.64,54.26 v2(253.19,54.71)
  BOTTOM w0.102: v2(253.19,54.71) 252.95,54.94 UG3.B4 ; v2(245.87,85.05) UG9.E39
FB_B_D27: length 43.3
  IN6 w0.102: v2(245.87,84.35) 245.72,84.2 245.72,82.51 246.96,81.27
  IN6 w0.13: 246.96,81.27 246.96,79.62 256.36,70.22 256.36,61.39 255.06,60.09 255.06,59.48 254.93,59.35 254.87,59.35 254.74,59.23 254.74,59.05 254.87,58.92 254.93,58.92 255.06,58.8 255.06,58.62 254.93,58.5 254.87,58.5 254.74,58.37 254.74,58.19 254.87,58.07 254.93,58.07 255.06,57.94 255.06,57.76 254.93,57.64 254.87,57.64 254.74,57.51 254.74,57.33 254.87,57.21 254.93,57.21 255.06,57.08 255.06,56.67 254.93,56.54 253.07,56.54 252.94,56.42 252.94,56.24 253.07,56.11 254.93,56.11 255.06,55.99 254.18,55.11 251.99,55.11 v2(251.59,54.71)
  BOTTOM w0.102: v2(251.59,54.71) 251.36,54.94 UG3.B2 ; UG9.D39 v2(245.87,84.35)
FB_B_D28: length 37.1
  IN6 w0.102: v2(244.41,85.59) 244.44,85.62 244.89,85.62 245.28,85.23 245.28,83.76 245.07,83.55 245.07,82.46 246.39,81.14
  IN6 w0.13: 246.39,81.14 246.39,79.4 255.71,70.08 255.71,61.63 254.45,60.37 254.45,57.68 254.29,57.51 252.79,57.51 v2(252.39,57.91)
  BOTTOM w0.102: UG3.E4 v2(252.39,57.91) ; v2(244.41,85.59) UG9.F38
FB_B_D29: length 35.1
  IN6 w0.102: v2(244.51,85.03) 244.93,84.61 244.93,84.06 244.46,83.59 244.46,82.37 245.86,80.97
  IN6 w0.13: 245.86,80.97 245.86,79.13 254.98,70.01 254.98,61.57 253.98,60.57 253.98,59.43 253.61,59.06 253.61,58.51 253.41,58.31 251.99,58.31 v2(251.59,57.91)
  BOTTOM w0.102: UG9.E38 244.83,85.35 v2(244.51,85.03) ; UG3.E2 251.37,57.69 v2(251.59,57.91)
FB_B_D30: length 31.6
  IN6 w0.102: v2(243.77,84.35) 243.67,84.25 243.67,83.95 243.62,83.9 243.62,83.58 243.67,83.53 243.67,82.4 245.32,80.75
  IN6 w0.13: 245.32,80.75 245.32,78.69 254.32,69.69 254.32,61.74 253.58,61 253.58,59.63 253.19,59.24 v2(253.19,58.71)
  BOTTOM w0.102: v2(253.19,58.71) UG3.F4 ; UG9.D36 v2(243.77,84.35)
FB_B_D31: length 33.3
  IN6 w0.102: 244.77,80.6 243.02,82.35 243.02,84.3 v2(243.77,85.05)
  IN6 w0.13: v2(251.59,58.71) 251.99,59.11 252.61,59.11 253.04,59.54 253.04,61.44 253.68,62.08 253.68,69.47 244.77,78.38 244.77,80.6
  BOTTOM w0.102: UG3.F2 251.38,58.5 v2(251.59,58.71) ; v2(243.77,85.05) UG9.E36
FB_B_D32: length 21.2
  IN1 w0.13: v2(256.88,90.26) 257.37,89.77 258.85,89.77 259.31,89.32 261.2,89.32 269.01,81.51 269.6,81.51 v2(269.75,81.36)
  BOTTOM w0.102: v2(256.88,90.26) 256.27,90.87 254.44,90.87 254.17,90.6 253.77,90.6 253.42,90.25 UG9.M50 ; UG4.A4 269.99,81.12 v2(269.75,81.36)
FB_B_D33: length 22.3
  IN1 w0.13: v2(252.12,91.25) 252.22,91.15 253.04,91.15 253.21,91.32 253.76,91.32 253.86,91.22 258.66,91.22 259.6,90.29 261.82,90.29 268.89,83.21 269.5,83.21 v2(269.75,82.96)
  BOTTOM w0.102: UG4.A2 v2(269.75,82.96) ; v2(252.12,91.25) 252.12,91.4 UG9.P48
FB_B_D34: length 21.6
  IN1 w0.13: v2(255.74,90.24) 256.78,89.2 258.08,89.2 258.52,88.76 260.8,88.76 268.75,80.81 270,80.81 v2(270.55,81.36)
  BOTTOM w0.102: v2(255.74,90.24) 255.68,90.24 255.28,90.64 254.56,90.64 254.17,90.25 UG9.M51 ; UG4.B4 v2(270.55,81.36)
FB_B_D35: length 22.5
  IN1 w0.13: v2(252.97,90.66) 253.21,90.42 254.24,90.42 254.52,90.7 257.67,90.7 258.07,90.3 258.95,90.3 259.41,89.84 261.47,89.84 268.75,82.56 270.15,82.56 v2(270.55,82.16)
  BOTTOM w0.102: UG9.M49 v2(252.97,90.66) ; UG4.B2 v2(270.55,82.16)
FB_B_D36: length 29.9
  IN1 w0.13: v2(251.47,91.35) 251.75,91.63 253.75,91.63 254.86,92.74 259.88,92.74 260.81,91.81 260.81,91.8 261.24,91.37 262.33,91.37 268.81,84.88 272.52,84.88 273.35,84.05 273.35,81.76 v2(273.75,81.36)
  BOTTOM w0.102: UG4.E4 273.75,81.36 v2(273.75,81.36) ; UG9.P47 v2(251.47,91.35)
FB_B_D37: length 23.4
  IN1 w0.13: v2(272.95,82.96) 272.95,83.03 272.55,83.43 272.55,83.99 272.22,84.32 268.58,84.32 262.17,90.73 260.23,90.73 259.31,91.65 256.97,91.65 v2(256.27,92.35)
  BOTTOM w0.102: v2(256.27,92.35) 255.57,91.65 UG9.P52 ; UG4.E2 v2(272.95,82.96)
FB_B_D38: length 33.5
  IN1 w0.13: v2(250.17,92.65) 250.56,92.26 253.35,92.26 254.54,93.45 258.53,93.45 258.7,93.28 260.59,93.28 261.31,92.56 262.72,92.56 268.52,86.76 272.61,86.76 274.7,84.67 274.7,84.26 275.05,83.91 275.05,81.86 v2(274.55,81.36)
  BOTTOM w0.102: UG9.R46 v2(250.17,92.65) ; UG4.F4 274.55,81.36 v2(274.55,81.36)
FB_B_D39: length 30.4
  IN1 w0.13: v2(273.75,82.96) 274.15,83.36 274.15,84.11 272.79,85.47 269.02,85.47 262.49,92 261.22,92 260.21,93.01 258.28,93.01 258.16,93.13 254.71,93.13 253.53,91.95 251.32,91.95 v2(250.62,91.25)
  BOTTOM w0.102: v2(250.62,91.25) 250.62,91.5 UG9.P46 ; v2(273.75,82.96) UG4.F2
FB_B_D40: length 25.5
  IN6 w0.102: v2(255.32,88.65) 256.03,89.36 258.49,89.36 259.18,88.66 259.18,87.33 260.23,86.29 260.23,85.59
  IN6 w0.13: 260.23,85.59 263.18,82.64 263.18,81.53 v2(269.75,74.96)
  BOTTOM w0.102: v2(255.32,88.65) 254.99,88.98 254.34,88.98 254.12,89.2 253.85,89.2 253.5,89.55 UG9.L50 ; v2(269.75,74.96) 269.95,75.17 269.95,75.17 UG4.A11
FB_B_D41: length 25.4
  IN6 w0.102: 258.71,84.64 258.71,85.85 257.64,86.92 256.71,86.92 255.77,87.86 255.77,88.45 v2(255.92,88.6)
  IN6 w0.13: v2(269.75,73.36) 268.65,73.36 261.88,80.13 261.88,81.46 258.71,84.64
  BOTTOM w0.102: UG4.A13 269.96,73.57 v2(269.75,73.36) ; v2(255.92,88.6) 255.92,88.95 255.66,89.21 254.47,89.21 254.13,89.55 UG9.L51
FB_B_D42: length 25.4
  IN6 w0.102: v2(256.48,88.7) 256.89,89.11 258.13,89.11 258.77,88.47 258.77,87.13 259.79,86.12 259.79,85.08
  IN6 w0.13: 259.79,85.08 262.75,82.12 262.75,80.97 269.16,74.56 270.15,74.56 v2(270.55,74.96)
  BOTTOM w0.102: v2(270.55,74.96) 270.8,75.21 UG4.B11 ; UG9.L52 255.93,89.55 256.48,89 v2(256.48,88.7)
FB_B_D43: length 28
  IN6 w0.102: v2(257.71,88.65) 257.62,88.65 257.37,88.4 257.37,87.75 258.52,86.6 258.69,86.6 259.3,85.99 259.3,84.74
  IN6 w0.13: v2(270.55,73.36) 270.15,73.76 269.14,73.76 262.32,80.58 262.32,81.73 259.3,84.74
  BOTTOM w0.102: v2(257.71,88.65) 257.71,88.7 256.61,89.8 254.92,89.8 254.82,89.9 252.92,89.9 UG9.L49 ; v2(270.55,73.36) UG4.B13
FB_B_D44: length 34.7
  IN6 w0.102: 259.05,89.82 255.61,89.82 255.59,89.8 254.94,89.8 254.85,89.89 250.13,89.89 v2(249.35,90.67)
  IN6 w0.13: 259.05,89.82 262.77,86.1 262.77,84.66 270.34,77.09 272.37,77.09 273.35,76.11 UG4.E11 v2(272.95,74.96)
  BOTTOM w0.102: v2(272.95,74.96) UG4.E11 ; UG9.M46 250.1,89.88 249.52,89.88 249.42,89.98 249.42,90.6 v2(249.35,90.67)
FB_B_D45: length 32.6
  IN6 w0.102: 260.66,85.98 260.66,86.46 259.79,87.33 259.79,88.51 258.71,89.59 255.7,89.59 255.29,89.18 254.2,89.18 253.83,89.54 251.76,89.54 v2(251.47,89.25)
  IN6 w0.13: 260.66,85.98 270.25,76.38 272.13,76.38 272.55,75.96 272.55,73.95 272.74,73.76 273.35,73.76 v2(273.75,73.36)
  BOTTOM w0.102: UG9.L47 v2(251.47,89.25) ; UG4.E13 273.51,73.6 273.51,73.6 v2(273.75,73.36)
FB_B_D46: length 32
  IN6 w0.102: 262.77,87.49 259.85,90.41 ; v2(252.14,90.66) 252.55,90.25 253.52,90.25 254,90.73
  IN6 w0.13: 259.85,90.41 257.59,90.41 257.27,90.73 254,90.73 ; v2(273.75,74.96) UG4.F11 274.15,76.28 272.67,77.76 270.71,77.76 265.63,82.84 265.63,84.64 262.77,87.49
  BOTTOM w0.102: v2(252.14,90.66) 252.14,90.52 UG9.M48 ; v2(273.75,74.96) UG4.F11
FB_B_D47: length 36.9
  IN6 w0.102: v2(250.87,90.55) 251.07,90.75 251.07,91.51 251.32,91.76 252.21,91.76 252.67,91.3 ; 260.76,90.84 262.77,88.83
  IN6 w0.13: 252.67,91.3 257.44,91.3 257.91,90.84 260.76,90.84 ; v2(274.55,73.36) 274.95,73.76 274.95,76.43 272.91,78.47 270.9,78.47 266.45,82.92 266.45,85.14 262.77,88.83
  BOTTOM w0.102: UG9.M47 v2(250.87,90.55) ; v2(274.55,73.36) 274.55,73.36 UG4.F13
FB_B_D48: length 50.4
  IN6 w0.102: v2(251.57,84.95) 251.17,84.55 251.17,82.71
  IN6 w0.13: v2(283.35,74.96) 283.99,74.96 284.92,74.03 284.92,71.26 282.21,68.55 279.72,68.55 277.81,66.64 268.14,66.64 260.1,74.67 259.22,74.67 251.17,82.71
  BOTTOM w0.102: UG4.U11 283.11,75.2 283.11,75.2 v2(283.35,74.96) ; UG9.D48 v2(251.57,84.95)
FB_B_D49: length 40.3
  IN6 w0.102: 256.66,80.67 255.31,80.67 253.95,82.03 253.95,83.27 v2(253.57,83.65)
  IN6 w0.13: 256.66,80.67 268.5,68.84 276.2,68.84 277.6,70.23 281.51,70.23 282.95,71.67 282.95,72.96 v2(283.35,73.36)
  BOTTOM w0.102: UG9.C50 v2(253.57,83.65) ; UG4.U13 v2(283.35,73.36)
FB_B_D50: length 47.5
  IN6 w0.102: 259.38,75.3 259.06,75.62 258.81,75.62 ; v2(252.17,83.65) 251.79,83.27 251.79,82.64
  IN6 w0.13: v2(282.55,74.96) 282.95,74.56 283.59,74.56 284.36,73.79 284.36,71.5 281.98,69.11 279.49,69.11 277.58,67.2 268.55,67.2 260.44,75.3 259.38,75.3 ; 251.79,82.64 258.81,75.62
  BOTTOM w0.102: UG9.C48 v2(252.17,83.65) ; v2(282.55,74.96) UG4.T11
FB_B_D51: length 44
  IN6 w0.102: 253.49,81.6 253.24,81.6 252.87,81.97 v2(252.87,83.65) ; 259.47,75.62 260.92,75.62
  IN6 w0.13: 253.49,81.6 259.47,75.62 ; v2(282.55,73.36) 282.95,73.76 283.6,73.76 283.8,73.56 283.8,71.73 281.74,69.67 278.8,69.67 277.4,68.27 268.26,68.27 260.92,75.62
  BOTTOM w0.102: UG9.C49 v2(252.87,83.65) ; UG4.T13 v2(282.55,73.36)
FB_B_D52: length 40.4
  IN6 w0.102: 258.9,81.66 254.78,85.78 253.57,85.78 253.3,85.51 252.73,85.51 v2(252.27,85.05) ; 266.75,72.21 266.8,72.16
  IN6 w0.13: v2(280.15,74.96) 279.75,74.56 279.75,71.71 279.4,71.36 277.13,71.36 275.74,69.96 269,69.96 266.8,72.16 ; 258.9,81.66 258.9,80.06 266.75,72.21
  BOTTOM w0.102: UG9.E49 v2(252.27,85.05) ; UG4.N11 v2(280.15,74.96)
FB_B_D53: length 41
  IN6 w0.102: 258.4,80.11 254.68,83.83 254.68,85.25 254.4,85.53 254.05,85.53 v2(253.57,85.05)
  IN6 w0.13: v2(280.15,73.36) 280.55,73.76 281.15,73.76 281.35,73.56 281.35,71.71 280.43,70.79 277.36,70.79 275.97,69.4 268.73,69.4 258.4,79.73 258.4,80.11
  BOTTOM w0.102: UG9.E50 v2(253.57,85.05) ; UG4.N13 v2(280.15,73.36)
FB_B_D54: length 38
  IN6 w0.102: v2(252.17,86.45) 252.57,86.85 252.57,87.24 252.89,87.56 254.93,87.56 260.15,82.34
  IN6 w0.13: v2(279.35,74.96) 278.95,74.56 278.95,73.96 278.75,73.76 277.81,73.76 276.21,72.16 275.74,71.69 269.49,71.69 260.15,81.03 260.15,82.34
  BOTTOM w0.102: UG4.M11 279.15,75.17 v2(279.35,74.96) ; UG9.F49 v2(252.17,86.45)
FB_B_D55: length 38.3
  IN6 w0.102: 267.89,72.16 266.75,73.31 ; v2(251.57,86.35) UG9.F48 253.6,86.05 254.06,86.51 255.45,86.51 256.05,85.91 256.05,85.47 259.36,82.16
  IN6 w0.13: 266.75,73.31 259.36,80.7 259.36,82.16 ; 267.89,72.16 269.39,70.66 275.64,70.66 276.9,71.92 278.56,71.92 278.95,72.3 278.95,72.96 v2(278.55,73.36)
  BOTTOM w0.102: v2(251.57,86.35) UG9.F48 ; UG4.M13 v2(278.55,73.36)
FB_B_D56: length 38
  IN1 w0.13: v2(282.55,80.56) 282.96,80.15 282.96,79.25 280.9,77.19 278.26,77.19 277.32,76.25 275.05,76.25 274.73,76.57 267.44,76.57 261.47,82.54 258.07,82.54 255.81,84.8 255.18,84.8 254.37,85.61 253.81,85.61 v2(252.97,86.45)
  BOTTOM w0.102: UG4.U4 v2(282.55,80.56) ; v2(252.97,86.45) 252.97,86.35 UG9.F50
FB_B_D57: length 38.8
  IN1 w0.13: v2(255.77,84.19) 257.86,82.1 261.12,82.1 267.47,75.75 269.05,75.75 269.43,75.37 277.3,75.37 278.1,76.17 281.11,76.17 281.34,76.4 281.34,76.41 281.35,76.41 281.35,76.77 283.71,79.13 283.71,80.81 282.55,81.97 v2(282.55,82.16)
  BOTTOM w0.102: UG9.D52 254.72,84.7 255.27,84.7 255.77,84.2 v2(255.77,84.19) ; UG4.U2 v2(282.55,82.16)
FB_B_D58: length 35.1
  IN1 w0.13: v2(281.75,80.56) 281.35,80.16 281.35,79.56 280.3,78.51 277.36,78.51 276.69,77.84 267.75,77.84 262.77,82.82 262.77,82.86 261.88,83.75 258.2,83.75 253.57,88.38 v2(253.57,88.45)
  BOTTOM w0.102: UG9.J50 v2(253.57,88.45) ; UG4.T4 v2(281.75,80.56)
FB_B_D59: length 40
  IN1 w0.13: v2(252.17,87.15) 252.51,87.49 253.34,87.49 254.94,85.9 254.94,85.89 255.16,85.67 255.17,85.67 255.3,85.54 255.58,85.54 258.01,83.11 261.69,83.11 267.6,77.21 277,77.21 277.76,77.96 280.65,77.96 282.15,79.46 UG4.T2 v2(282.55,82.96)
  BOTTOM w0.102: UG4.T2 v2(282.55,82.96) ; UG9.H48 v2(252.17,87.15)
FB_B_D60: length 33.1
  IN1 w0.13: v2(279.35,81.36) 279.79,80.92 279.79,79.54 279.32,79.07 276.88,79.07 276.22,78.41 267.98,78.41 262.01,84.38 258.07,84.38 256.74,85.72 v2(256.74,86.53)
  BOTTOM w0.102: UG4.N4 v2(279.35,81.36) ; UG9.H51 254.12,87.45 254.76,86.81 255.62,86.81 255.73,86.7 256.57,86.7 v2(256.74,86.53)
FB_B_D61: length 32.4
  IN1 w0.13: v2(254.37,88.55) 254.37,88.35 255.73,86.99 257.82,86.99 259.72,85.08 262.1,85.08 268.14,79.05 275.87,79.05 276.56,79.74 277.94,79.74 278.36,80.16 278.72,80.16 278.9,80.34 278.9,80.35 278.94,80.4 278.94,82.03 279.08,82.16 v2(279.35,82.16)
  BOTTOM w0.102: UG9.J51 v2(254.37,88.55) ; UG4.N2 v2(279.35,82.16)
FB_B_D62: length 31.2
  IN1 w0.13: v2(256.95,88.02) 257.48,87.49 258.71,87.49 260.49,85.72 262.26,85.72 268.36,79.62 275.27,79.62 276.26,80.61 277.65,80.61 278.4,81.36 v2(278.55,81.36)
  BOTTOM w0.102: v2(256.95,88.02) 256.48,87.55 255.17,87.55 254.92,87.8 252.92,87.8 UG9.H49 ; UG4.M4 v2(278.55,81.36)
FB_B_D63: length 30.9
  IN1 w0.13: v2(279.35,82.96) UG4.M2 275.9,82.56 275.75,82.41 275.75,81.11 274.77,80.13 268.65,80.13 260.75,88.02 257.83,88.02 v2(257.78,88.07)
  BOTTOM w0.102: v2(257.78,88.07) 257.78,88.05 256.94,87.21 254.91,87.21 UG9.H52 ; UG4.M2 279.17,82.78 v2(279.35,82.96)
FB_B_DBI0: length 24.7
  IN2 w0.117: v2(240.62,79.85) 240.76,79.85 248.55,72.06 248.55,66.48 249.51,65.51 250.39,65.51 v2(250.79,65.11)
  BOTTOM w0.102: UG9.C32 240.34,83.62 240.34,83.12 240.14,82.92 240.14,82.46 240.04,82.36 240.04,81.67 240.23,81.47 240.23,80.24 v2(240.62,79.85) ; v2(250.79,65.11) UG3.P2
FB_B_DBI1: length 30
  IN2 w0.117: v2(241.77,85.05) 242.32,84.5 242.32,82.8 244.68,80.44 244.68,80.44 256.03,69.09 256.03,67.25 257.77,65.51 259.99,65.51 v2(260.39,65.11)
  BOTTOM w0.102: v2(260.39,65.11) UG3.P13 ; UG9.E33 241.47,85.35 v2(241.77,85.05)
FB_B_DBI2: length 40.6
  IN2 w0.117: v2(260.39,56.31) 260.79,55.91 262.03,55.91 265.01,58.89 265.01,68.91 258.81,75.11 257.63,75.11 248.91,83.83 248.91,84.91 v2(248.77,85.05)
  BOTTOM w0.102: v2(260.39,56.31) UG3.D13 ; UG9.E44 v2(248.77,85.05)
FB_B_DBI3: length 52.7
  IN2 w0.117: v2(250.79,57.11) 251.18,56.72 251.18,56.12 251.39,55.91 254.94,55.91 256.14,57.11 257.34,57.11 257.74,57.51 261.98,57.51 264.32,59.85 264.32,68.62 258.53,74.41 257.18,74.41 255.98,75.62 255.66,75.62 247.55,83.73 247.55,85.52 v2(246.5,86.57)
  BOTTOM w0.102: UG9.G39 245.59,86.73 246.38,86.73 246.51,86.6 246.51,86.58 v2(246.5,86.57) ; v2(250.79,57.11) 251.02,56.88 251.02,56.88 UG3.D2
FB_B_DBI4: length 24.7
  IN2 w0.117: v2(255.67,92.35) 257.25,90.77 258.1,90.77 260.42,88.45 261.28,88.45 267.17,82.55 271.76,82.55 v2(272.15,82.16)
  BOTTOM w0.102: UG9.P49 252.92,92 254.82,92 254.92,91.9 255.22,91.9 255.35,92.03 v2(255.67,92.35) ; UG4.D2 v2(272.15,82.16)
FB_B_DBI5: length 29.6
  IN2 w0.117: v2(272.15,73.36) 271.75,73.76 271.75,75.94 271.31,76.38 267.91,76.38 259.6,84.69 257.9,84.69 257.74,84.85 257.73,84.85 257.51,85.07 257.51,85.08 254.75,87.85 254.75,88.79 254.14,89.4 253.22,89.4 v2(252.97,89.15)
  BOTTOM w0.102: v2(252.97,89.15) 252.9,89.22 252.44,89.22 252.11,89.55 UG9.L48 ; v2(272.15,73.36) UG4.D13
FB_B_DBI6: length 38.6
  IN2 w0.117: v2(280.95,73.36) 280.55,72.96 280.55,71.73 279.55,70.73 277,70.73 276.59,70.32 267.8,70.32 261.84,76.28 261.84,76.68 254.7,83.82 254.7,85.19 254.37,85.52 253.45,85.52 252.97,85.04 v2(252.97,84.95)
  BOTTOM w0.102: UG4.P13 v2(280.95,73.36) ; UG9.D50 v2(252.97,84.95)
FB_B_DBI7: length 33.6
  IN2 w0.117: v2(280.15,82.96) 279.75,82.56 279.75,81.15 279.56,80.96 278.26,80.96 276.1,78.8 267.82,78.8 260.51,86.12 v2(257.82,86.12)
  BOTTOM w0.102: UG9.H50 253.62,87.1 254.12,87.1 254.76,86.45 255.55,86.45 255.89,86.12 v2(257.82,86.12) ; UG4.P2 280.34,82.77 v2(280.15,82.96)
FB_B_EDC0: length 23.1
  IN2 w0.117: v2(251.58,65.91) 251.19,66.31 249.72,66.31 249.22,66.8 249.22,72.61 v2(241.64,80.19)
  BOTTOM w0.102: UG9.B33 241.8,82.82 241.8,80.35 v2(241.64,80.19) ; UG3.R2 251.58,65.91 v2(251.58,65.91)
FB_B_EDC1: length 28.7
  IN2 w0.117: v2(242.47,85.65) 242.83,85.29 242.83,83.5 257.47,68.86 257.47,66.57 257.73,66.31 259.19,66.31 v2(259.59,65.91)
  BOTTOM w0.102: UG3.R13 v2(259.59,65.91) ; UG9.E35 v2(242.47,85.65)
FB_B_EDC2: length 47.3
  IN2 w0.117: v2(248.88,87.64) 249.06,87.46 249.06,86.88 249.38,86.56 249.38,84.08 257.84,75.62 260.17,75.62 266.33,69.46 266.33,59.01 262.43,55.11 259.99,55.11 v2(259.59,55.51)
  BOTTOM w0.102: v2(248.88,87.64) 249.07,87.45 UG9.G44 ; v2(259.59,55.51) 259.8,55.73 259.81,55.73 UG3.C13
FB_B_EDC3: length 51.2
  IN2 w0.117: v2(244.57,87.75) 244.42,87.75 244.21,87.54 243.57,87.54 243.37,87.34 243.37,83.77 243.92,83.22 244.57,83.22 258.52,69.27 259.98,69.27 261.59,67.66 261.59,61.73 260.56,60.71 258.12,60.71 257.74,60.33 255.04,60.33 254.93,60.22 254.93,59.73 254.82,59.62 254.59,59.62 254.48,59.73 254.48,60.21 254.37,60.32 254.2,60.32 252.8,58.92 252.8,58.87 252.8,58.87 252.8,58.55 252.8,58.54 252.8,58.07 252.8,58.07 252.8,57.75 252.8,57.74 252.8,57.72 252.59,57.51 252.17,57.51 251.99,57.33 251.99,56.71 v2(251.59,56.31)
  BOTTOM w0.102: v2(244.57,87.75) UG9.H38 ; v2(251.59,56.31) UG3.C2
FB_B_EDC4: length 23.3
  IN2 w0.117: v2(271.35,82.96) 270.95,83.37 267.31,83.37 261.66,89.02 260.75,89.02 v2(257.42,92.35)
  BOTTOM w0.102: UG9.P50 253.6,91.32 254.15,91.32 254.36,91.11 254.94,91.11 255.06,91.23 256.3,91.23 v2(257.42,92.35) ; v2(271.35,82.96) 271.59,82.72 UG4.C2
FB_B_EDC5: length 26.2
  IN2 w0.117: v2(252.17,88.45) 252.43,88.19 253.2,88.19 253.32,88.07 253.83,88.07 255.47,86.43 255.48,86.43 255.7,86.21 255.7,86.2 255.74,86.16 255.74,86.05 267.23,74.56 270.95,74.56 v2(271.35,74.16)
  BOTTOM w0.102: UG4.C13 271.75,73.76 v2(271.35,74.16) ; v2(252.17,88.45) UG9.J48
FB_B_EDC6: length 41.1
  IN2 w0.117: v2(254.27,84.35) 254.27,84.2 253.95,83.88 253.95,83.81 253.95,83.11 253.95,82.05 253.95,82.04 253.95,82.04 254.17,81.82 254.17,81.82 256.44,79.56 257.4,79.56 268.03,68.92 275.22,68.92 275.94,69.65 276.87,69.65 277.28,70.05 280.88,70.05 282.15,71.32 282.15,73.76 v2(281.75,74.16)
  BOTTOM w0.102: UG9.D51 v2(254.27,84.35) ; v2(281.75,74.16) 281.75,74.16 UG4.R13
FB_B_EDC7: length 33.6
  IN2 w0.117: v2(280.95,82.16) 280.55,81.76 280.55,81.06 280.06,80.57 280.06,79.63 279.33,78.91 277.92,78.91 276.92,77.9 267.56,77.9 260.23,85.23 v2(257.89,85.23)
  BOTTOM w0.102: v2(257.89,85.23) 257.3,85.23 256.9,85.63 255.04,85.63 254.95,85.72 254.3,85.72 UG9.F51 ; v2(280.95,82.16) UG4.R2
FB_B_WCK01: length 31
  IN2 w0.089: v2(241.67,88.45) 241.39,88.17 241.16,88.17 240.81,87.82 240.81,83.41 240.82,83.4 240.82,83.21 241.99,82.04 241.99,81.92 253.68,70.24 253.68,65.84 253.36,65.52 252.81,65.52 v2(252.39,65.11)
  BOTTOM w0.102: UG9.J33 v2(241.67,88.45)
  BOTTOM w0.119: UG3.P4 252.79,64.71 v2(252.39,65.11)
FB_B_WCK23: length 46.3
  IN2 w0.089: v2(245.87,88.45) 245.69,88.27 245.42,88.27 245.14,87.99 245.14,87.46 245.33,87.27 245.33,83.8 245.88,83.25 246.03,83.25 258,71.29 258.53,71.29 261.92,67.9 261.92,61.59 259.67,59.34 256.23,59.34 256.13,59.24 256.11,59.24 254.35,57.47 253.78,57.47 253.41,57.1 v2(253.17,57.1)
  BOTTOM w0.102: UG9.J39 v2(245.87,88.45)
  BOTTOM w0.119: UG3.D4 v2(253.17,57.1)
FB_B_WCK45: length 30.5
  IN2 w0.089: v2(250.17,89.25) 250.17,89.5 250.68,90.01 254.6,90.01 255.08,89.53 258.01,89.53 259.91,87.62 260.9,87.62 268.85,79.67 272.88,79.67 273.33,80.12 273.33,80.98 v2(272.95,81.36)
  BOTTOM w0.102: UG9.L46 v2(250.17,89.25)
  BOTTOM w0.119: v2(272.95,81.36) 272.55,80.96 UG4.D4
FB_B_WCK67: length 44.5
  IN2 w0.089: v2(251.57,87.05) 251.57,87.47 251.72,87.62 252.97,87.62 268.91,71.67 276.12,71.67 277.9,73.46 277.9,76.44 278.68,77.22 279.54,77.22 281.34,79.02 281.34,80.18 v2(280.95,80.56)
  BOTTOM w0.102: UG9.H47 v2(251.57,87.05)
  BOTTOM w0.119: UG4.P4 v2(280.95,80.56)
FB_B_WCK#01: length 31.1
  IN2 w0.089: v2(241.67,87.75) 241.43,87.99 241.23,87.99 241,87.76 241,83.41 241,83.41 241,83.28 242.17,82.12 242.17,82 253.85,70.31 253.85,65.76 253.43,65.34 253.34,65.34 253.3,65.3 253.19,65.19 253.19,65.11 v2(253.19,65.11)
  BOTTOM w0.102: v2(241.67,87.75) 241.61,87.81 241.16,87.81 241.06,87.71 241.06,87.54 241.15,87.45 UG9.H33
  BOTTOM w0.119: UG3.P5 253.34,64.71 253.19,64.86 v2(253.19,65.11)
FB_B_WCK#23: length 46.5
  IN2 w0.089: v2(245.87,87.75) 245.87,87.99 245.78,88.08 245.5,88.08 245.32,87.9 245.32,87.53 245.51,87.34 245.51,83.88 245.95,83.43 246.11,83.43 258.07,71.47 258.61,71.47 262.1,67.98 262.1,61.51 259.74,59.16 256.31,59.16 254.39,57.24 254.39,57.1 254.3,57.01 254.06,57.01 v2(253.97,57.1)
  BOTTOM w0.102: v2(245.87,87.75) 245.82,87.8 245.34,87.8 245.26,87.72 245.26,87.54 245.35,87.45 UG9.H39
  BOTTOM w0.119: UG3.D5 v2(253.97,57.1)
FB_B_WCK#45: length 30.4
  IN2 w0.089: v2(249.47,89.25) 249.47,89.52 249.6,89.65 250.07,89.65 250.61,90.19 254.67,90.19 255.15,89.7 258.08,89.7 259.99,87.8 260.97,87.8 268.92,79.85 272.81,79.85 273.15,80.19 273.15,80.41 273,80.56 v2(272.95,80.56)
  BOTTOM w0.102: UG9.L45 249.59,89.55 249.47,89.43 v2(249.47,89.25)
  BOTTOM w0.119: UG4.D5 272.55,80.44 272.67,80.56 v2(272.95,80.56)
FB_B_WCK#67: length 44.5
  IN2 w0.089: v2(250.77,87.15) 251,87.15 251.65,87.8 253.04,87.8 268.99,71.85 276.03,71.85 277.72,73.55 277.72,76.52 278.61,77.4 279.47,77.4 281.15,79.08 281.15,79.28 281.06,79.37 280.96,79.37 280.82,79.51 280.82,79.63 v2(280.95,79.76)
  BOTTOM w0.102: v2(250.77,87.15) 250.81,87.19 250.81,87.59 250.71,87.69 250.55,87.69 250.47,87.61 UG9.H46
  BOTTOM w0.119: v2(280.95,79.76) 280.73,79.98 280.73,79.99 UG4.P5
FB_C_CLK0: length 37.8
  TOP w0.119: v2(227.39,63.72) 227.58,63.53 228.13,63.53 RG124.1
  IN6 w0.107: v2(224.56,61.18) 224.56,60.95 224.67,60.85 225.04,60.85 225.17,60.71 225.72,60.71 226.78,61.78 226.78,62.81 226.98,63 226.98,63.31 v2(227.39,63.72) 227.78,63.33 227.89,63.33 228,63.44 228,71.42 227.89,71.53 227.22,71.53 227,71.75 227,72.23 227.22,72.45 227.89,72.45 228,72.56 228,72.97 227.89,73.07 227.16,73.07 226.94,73.3 226.94,73.78 227.16,74 227.89,74 228,74.11 228,74.43 227.89,74.53 227.17,74.53 226.95,74.75 226.95,75.24 227.17,75.46 227.89,75.46 228,75.56 228,76.41 228.95,77.36 228.95,83.73 228.7,83.98 228.7,86.26 228.85,86.41 228.85,86.83 v2(229.07,87.05)
  BOTTOM w0.089: UG9.G15 v2(229.07,87.05)
  BOTTOM w0.119: v2(224.56,61.18) 224.56,60.91 224.37,60.71 UG5.J12
FB_C_CLK1: length 35.5
  TOP w0.102: v2(232.64,64.06) 232.46,63.88 RG125.1
  IN1 w0.102: 232.88,82.3 232.88,82.53 232.88,86.4 232.54,86.74 232.54,87.84 232.81,88.12 233.11,88.12 233.27,87.95 v2(233.27,87.75)
  IN1 w0.107: 232.88,82.3 232.01,81.44 232.01,75.26 232.01,70.55 232.01,63.71 232.29,63.43 232.51,63.43 232.64,63.55 v2(232.64,64.06) 232.94,63.76 232.94,63.25 233.37,62.82 233.37,61.52 234.19,60.7 235.03,60.7 235.28,60.95 235.43,60.95 v2(235.59,61.11)
  BOTTOM w0.102: UG9.H21 232.73,87.45 232.64,87.54 232.64,87.72 232.72,87.8 233.22,87.8 v2(233.27,87.75)
  BOTTOM w0.119: UG6.J12 235.99,60.71 235.99,61 235.88,61.11 v2(235.59,61.11)
FB_C_CLK#0: length 37.8
  TOP w0.119: RG527.1 228.13,63.32 227.58,63.32 v2(227.39,63.14)
  IN6 w0.107: v2(223.79,61.11) 224.07,61.11 224.53,60.65 224.96,60.65 225.09,60.52 225.8,60.52 226.98,61.69 226.98,62.73 v2(227.39,63.14) 227.98,63.14 228.2,63.36 228.2,71.5 227.98,71.72 227.31,71.72 227.2,71.83 227.2,72.15 227.31,72.25 227.98,72.25 228.2,72.48 228.2,73.05 227.98,73.27 227.24,73.27 227.14,73.38 227.14,73.7 227.24,73.8 227.98,73.8 228.2,74.02 228.2,74.51 227.98,74.73 227.26,74.73 227.15,74.83 227.15,75.15 227.26,75.26 227.98,75.26 228.2,75.48 228.2,76.33 229.15,77.28 229.15,83.81 228.9,84.06 228.9,86.18 v2(229.22,86.5)
  BOTTOM w0.102: UG9.F15 v2(229.22,86.5)
  BOTTOM w0.119: UG5.J11 v2(223.79,61.11)
FB_C_CLK#1: length 35
  TOP w0.102: v2(232.64,62.76) 232.43,62.97 RG528.1
  IN1 w0.102: 232.68,82.38 232.68,82.53 232.68,86.32 232.34,86.66 232.34,87.92 232.87,88.45 v2(233.27,88.45)
  IN1 w0.107: 232.68,82.38 231.82,81.52 231.82,75.26 231.81,70.55 231.81,63.63 232.21,63.23 232.53,63.23 232.61,63.15 232.61,62.79 v2(232.64,62.76) 232.82,62.94 232.97,62.94 233.18,62.74 233.18,61.44 234.11,60.51 235.11,60.51 235.3,60.7 235.97,60.7 v2(236.39,61.11)
  BOTTOM w0.102: UG9.J21 v2(233.27,88.45)
  BOTTOM w0.119: UG6.J11 236.62,60.88 236.62,60.88 v2(236.39,61.11)
FB_C_CMD0: length 37.2
  BOTTOM w0.102: 219.46,79.74 224.35,79.74 225.42,80.81 225.42,82.9 225.62,83.1 225.62,83.6 UG9.C11 ; 216.59,59.51 UG5.G3
  BOTTOM w0.185: 219.46,79.74 211.64,71.93 211.64,62.37 214.39,59.62 214.65,59.36 215.02,59.36 215.17,59.51 216.59,59.51
FB_C_CMD1: length 36.8
  TOP w0.102: RG51.2 218,60.38 217.54,59.93 216.97,59.93 v2(216.59,60.31)
  BOTTOM w0.102: UG9.B11 225.97,83.1 225.62,82.75 225.62,80.68 224.27,79.34 220.07,79.34 ; UG5.J3 v2(216.59,60.31)
  BOTTOM w0.185: v2(216.59,60.31) 215.05,60.31 215,60.26 214.59,60.26 212.18,62.66 212.18,71.45 220.07,79.34
FB_C_CMD2: length 33.1
  TOP w0.102: v2(215.79,61.11) 216.17,61.49 217.59,61.49 217.75,61.33 RG58.1
  BOTTOM w0.102: 220.97,78.97 224.22,78.97 225.97,80.72 UG9.A11 ; v2(215.79,61.11) 215.99,60.91 UG5.J2
  BOTTOM w0.185: v2(215.79,61.11) 214.99,61.11 214.96,61.14 214.66,61.14 213.87,61.93 213.87,71.87 220.97,78.97
FB_C_CMD3: length 31.7
  BOTTOM w0.102: UG9.D11 226.32,84.3 226.32,80.71 224.21,78.6 221.68,78.6
  BOTTOM w0.185: 221.68,78.6 214.41,71.33 214.41,62.58 214.9,62.08 215.01,62.08 215.19,61.9 216.58,61.9 UG5.L3
FB_C_CMD4: length 26.7
  BOTTOM w0.102: UG9.A12 226.67,80.66 224.13,78.12 222.41,78.12
  BOTTOM w0.185: 222.41,78.12 217.42,73.14 217.42,68.9 218.95,67.37 218.95,66.06 218.95,61.88 UG5.K5
FB_C_CMD5: length 28.5
  BOTTOM w0.102: UG9.B12 226.67,83.05 227.02,82.7 227.02,80.67 224,77.64 222.75,77.64 ; 217.79,61.51 UG5.K4
  BOTTOM w0.185: 217.79,61.51 218.16,61.14 218.77,61.14 219.24,61.62 219.24,66.18 219.24,66.18 219.24,67.53 218.13,68.64 218.13,73.02 222.75,77.64
FB_C_CMD6: length 28.3
  BOTTOM w0.102: UG9.C12 226.67,83.8 227.02,83.45 227.02,83.05 227.22,82.85 227.22,80.52 223.77,77.06 223.07,77.06
  BOTTOM w0.185: 223.07,77.06 218.67,72.67 218.67,68.87 219.53,68.01 219.53,66.3 219.53,61.4 218.84,60.71 UG5.J5
FB_C_CMD7: length 29.3
  BOTTOM w0.102: 223.22,76.4 223.42,76.4 227.47,80.45 227.47,82.85 227.72,83.1 227.72,83.6 UG9.C14
  BOTTOM w0.185: UG5.J4 218.18,60.32 218.87,60.32 219.82,61.26 219.82,66.42 219.82,68.7 219.21,69.31 219.21,72.38 223.22,76.4
FB_C_CMD8: length 27.7
  BOTTOM w0.102: UG9.B14 228.07,83.1 227.72,82.75 227.72,80.04 223.49,75.81 221.79,74.11
  BOTTOM w0.185: UG5.H5 218.93,59.91 220.1,61.08 220.1,66.54 220.1,69.22 219.78,69.54 219.78,72.1 221.79,74.11
FB_C_CMD9: length 28.2
  BOTTOM w0.102: 222.56,74.37 228.07,79.88 UG9.A14
  BOTTOM w0.185: 222.56,74.37 222.56,73.13 220.39,70.96 220.39,66.66 220.39,60.73 219.2,59.54 218.15,59.54 UG5.H4
FB_C_CMD10: length 31.5
  BOTTOM w0.102: 223.33,74.62 228.42,79.71 228.42,84.3 UG9.D14
  BOTTOM w0.185: 223.33,74.62 223.33,71.85 220.68,69.19 220.68,66.78 220.68,60.7 221.65,59.74 221.67,59.74 221.78,59.62 221.84,59.62 221.96,59.51 223.79,59.51 UG5.G12
FB_C_CMD11: length 27
  BOTTOM w0.102: UG9.A15 228.77,79.65 224.1,74.98
  BOTTOM w0.185: UG5.H10 221.9,59.91 221.79,60.02 221.76,60.02 220.96,60.82 220.96,66.9 220.96,68.54 224.1,71.68 224.1,74.98
FB_C_CMD12: length 28.3
  BOTTOM w0.102: 224.87,75.05 229.12,79.3 229.12,82.7 228.77,83.05 UG9.B15
  BOTTOM w0.185: 224.87,75.05 224.87,71.63 221.25,68.01 221.25,67.02 221.25,67.02 221.25,60.94 221.88,60.31 222.99,60.31 UG5.H11
FB_C_CMD13: length 28.5
  BOTTOM w0.102: UG9.C15 229.12,83.6 229.12,83.05 229.42,82.75 229.42,78.9 225.64,75.12
  BOTTOM w0.185: 225.64,75.12 225.64,70.89 224.45,69.69 223.51,69.69 221.54,67.72 221.54,67.14 221.54,61.86 222.26,61.14 223.02,61.14 UG5.K11
