# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XMP2-1: length 7.8
  TOP w0.102: v1(107.9,57.57) PC218.1
  TOP w0.254: PR214.2 106.17,55.46 106.54,55.83 PQ202.5 107.27,55.83 PC218.1 108.44,55.91 108.44,54.14 108.1,53.8 PR217.1
XMP2-2: length 2.1
  TOP w0.102: PQ202.3 104.41,55.18 v1(104.07,55.52)
  TOP w0.254: PR215.2 104.99,54.1 PQ202.3
XTAL24_IN: length 16.9
  TOP w0.089: 201.02,37.84 200.74,37.56 200.74,37.16 201.26,36.64 201.26,36.62 v2(201.24,36.62)
  TOP w0.114: 193.27,43.52 v2(192.82,43.97)
  TOP w0.122: 193.27,43.52 193.56,43.23 194.21,43.23 194.65,42.8 194.65,39.16 194.89,38.92 195.65,38.92 196.65,39.91 197.5,39.91 197.99,39.42 198.73,39.42 199.55,38.6 200.65,38.6 201.06,38.19 201.06,37.88 201.02,37.84
  BOTTOM w0.114: v2(192.82,43.97) 192.82,44.05 193.21,44.44 RH91.2
  BOTTOM w0.122: v2(201.24,36.62) 201.26,36.62 201.26,36.64 201.32,36.58 UH1.U10
XTAL24_IN_R: length 5
  BOTTOM w0.102: CH47.1 192.63,45.25 RH91.1
  BOTTOM w0.114: 193.49,45.32 193.87,45.7 193.87,47.35 YH2.1 ; 193.49,45.32 RH72.1 ; 193.49,45.32 CH47.1
XTAL24_OUT: length 14.5
  TOP w0.114: 193.49,44.06 v2(193.43,44)
  TOP w0.122: v2(201.1,37.31) 201.27,37.48 201.27,38.28 200.74,38.81 199.64,38.81 198.82,39.63 198.08,39.63 197.59,40.13 196.16,40.13 195.72,39.68 195.33,39.68 195,40.01 v1(195,41.37) 195,42.74 193.68,44.06 193.49,44.06
  BOTTOM w0.089: 193.8,44.41 193.8,44.36 v2(193.43,44)
  BOTTOM w0.114: RH92.2 193.8,44.41
  BOTTOM w0.122: UH1.U9 v2(201.1,37.31)
XTAL24_OUT_R: length 2.8
  BOTTOM w0.089: RH92.1 194.38,44.99 ; 194.82,45.32 RH72.2
  BOTTOM w0.102: RH72.2 194.38,45.28 194.38,44.99
  BOTTOM w0.114: YH2.3 195.17,45.38 CH48.1 194.82,45.32
XTALIN: length 15.5
  BOTTOM w0.089: YG1.1 210.79,119.33 210.94,119.18 211.79,119.18 CG75.2 212.71,119.13 212.86,119.13 RG99.1 213.5,119 213.62,119 v1(214.08,119.46) 214.38,119.76 221.71,119.76 222.84,118.62 222.84,118.09 222.47,117.71 UG9.BL6
XTALOUT: length 15.6
  BOTTOM w0.089: YG1.3 209.09,118.46 209.43,118.8 211.53,118.8 211.96,118.37 CG76.2 212.33,118.47 RG99.2 213.45,118.8 213.91,118.8 214.68,119.56 221.62,119.56 222.47,118.72 UG9.BM6
XTALOUTBUFF_R: length 12.6
  BOTTOM w0.089: v1(214.05,115.18) 214.27,115.18 RG98.1
  BOTTOM w0.102: UG9.BK6 222.12,117.2 222.12,118.53 221.35,119.31 217.3,119.31 216.47,118.47 216.47,118.07 215.99,117.59 215.99,117.02 215.54,116.58 RG98.1
XTLI: length 3.1
  BOTTOM w0.114: RL16.2 277.33,163.25 v1(276.67,162.59) 276.35,162.27 275.66,162.27 275.49,162.44 UL1.8
XTLI_R: length 4.8
  BOTTOM w0.102: CL8.1 280.32,165.5 YL1.1 ; 279.07,163.31 279.02,163.25 RL16.1
  BOTTOM w0.114: CL8.1 280.08,164.97 280.08,164.96 279.97,164.86 279.96,164.86 279.88,164.78 279.88,164.12 279.07,163.31
XTLO: length 3.2
  BOTTOM w0.114: RL17.2 277.2,163.83 276.39,163.02 276.39,162.92 276.16,162.7 275.67,162.7 275.53,162.84 UL1.7
XTLO_R: length 6
  BOTTOM w0.102: CL9.1 279.7,165.51 280.04,165.85 ; 278.88,163.83 RL17.1
  BOTTOM w0.114: 280.04,165.85 280.04,166.82 YL1.3 ; CL9.1 279.61,165.13 279.61,164.19 279.26,163.83 v1(278.99,163.83) 278.88,163.83
N04520:
  vias: v1(22.97,54.78) v2(25.37,51.21) v2(25.78,51.63) v2(28.61,51.03) v2(29.19,51.03)
N102521: length 2.5
  BOTTOM w0.102: RU17.1 23.72,50.73 v1(23.99,50.45) 24.98,49.47 UU7.16
N102523: length 1.5
  TOP w0.102: v2(27.44,51.07) 27.57,50.94 RU16.1
  BOTTOM w0.102: v2(27.44,51.07) 27.44,51.04 27.41,51.01 UU7.20
N102525: length 2.3
  TOP w0.102: RU15.1 28.14,50.93 v2(28.02,51.04)
  BOTTOM w0.102: v2(28.02,51.04) 28.08,51.04 28.21,50.91 UU7.1
N102559: length 1.5
  TOP w0.102: v2(25.28,49.97) 25.28,49.97 25.28,49.97 25.76,50.45 RU18.1
  BOTTOM w0.102: v2(25.28,49.97) 25.28,49.97 25.28,49.97 25.32,50 25.59,50.27 UU7.17
N102569: length 1.3
  BOTTOM w0.102: UU7.8 26.91,45.32 26.91,45.32 RU23.2
N102573: length 3
  BOTTOM w0.102: v1(26.83,43.48) 26.27,44.03 RU14.1 26.27,45.28 26.41,45.41 UU7.9
N102595: length 2.2
  BOTTOM w0.102: v1(25.69,44.06) RU14.2 25.69,45.23 25.91,45.45 UU7.10
N102623: length 2.2
  BOTTOM w0.102: UU7.7 27.41,45.36 27.5,45.27 RU21.2 27.58,44.85 v1(28.37,44.85)
N102677: length 2.7
  TOP w0.102: v1(297.43,66.64) RU25.1 RU24.2 296.49,66.04 QU1.2
N102751: length 1.4
  TOP w0.102: UU2.38 16.37,49.5 16.01,49.14 T142.1
N102753: length 2.3
  TOP w0.102: UU2.37 15.97,49.49 15.49,49.01 T143.1
N102771: length 2.7
  TOP w0.102: v2(14.31,50.54) 14.71,50.94 UU2.36
  BOTTOM w0.102: v1(13.24,49.57) 13.61,49.94 RU32.2 14.17,50.4 v2(14.31,50.54)
N102835: length 1.6
  BOTTOM w0.102: v1(24.16,53.15) 23.36,53.95 LU13.1
  vias: v2(22.04,54.03)
N16758539: length 1.5
  TOP w0.102: PC6416.1 v1(301.94,50.26)
N16760382:
  vias: v1(300.82,57.84)
N16761462: length 4
  TOP w0.203: PR6417.1 304.97,59.16 PC6437.1 ; PR6418.1 303.23,59.16 PC6437.1 ; PC6437.1 v1(304.1,58.18) 304.1,57.96 303.84,57.7 PU6400.7
N16857461: length 3.2
  TOP w0.102: v1(189.24,67.08) 188.69,66.54 DS1.1 188.13,67.14 188.54,67.54 QS3.1
N16910514: length 5.5
  TOP w0.254: PR6417.2 305.9,60.07 PR6416.2 305.91,60.92 PC6439.1 305.9,61.64 305.13,62.41 v1(304.62,62.41) 303.71,62.41 PR6426.2
N16935748: length 2.3
  BOTTOM w0.102: RG570.1 187.59,54.63 v1(188.08,54.63) 188.43,54.63 188.68,54.88 UG31.12
N16935754: length 5.6
  BOTTOM w0.102: UG31.1 191.82,56.88 191.92,56.98 191.92,57.37 191.4,57.89 CG488.1 191.19,58.98 RG200.2 190.46,59.07 190.94,59.55 v1(190.94,60.9)
N17186119: length 7.4
  TOP w0.203: PU6400.10 302.64,57.4 301.82,58.22 301.25,58.22 300.81,58.66 300.81,60.98 v1(300.04,61.74) 298.86,61.74 PR6421.2
N17230071: length 1.6
  TOP w0.508: PR6405.2 307.41,52.12 PC6423.2
N17235867:
  vias: v1(306.18,57.15)
N17244796: length 0.9
  TOP w0.254: PR6418.2 303.23,60.07 PR6423.1
N17249165: length 3.9
  TOP w0.102: v1(296.44,59.18) PR6415.1
  TOP w0.254: PR6422.2 297.86,60.15 PC6434.1 297.8,60.06 PR6415.1
N17249236: length 1.2
  TOP w0.254: PC6434.2 299.43,60.07 PR6414.1
N17431129: length 2.5
  TOP w0.102: v1(302.88,29.56) 302.13,28.81 RE89.1 301.25,27.74 CE36.1
N17434554: length 2.3
  TOP w0.107: RE74.2 308.89,14.7 307.98,15.61 UE5.107
N17956500: length 5.4
  BOTTOM w0.102: UX3.3 243.31,164.95 242.95,164.58 241.41,164.58 240.8,163.97 RX9.1 v1(239.42,163.97)
N17957050: length 2.2
  BOTTOM w0.102: UX3.4 242.82,163.17 RX3.2 v1(242.82,161.7)
N18370426: length 1.3
  TOP w0.102: RT111.2 v1(197.42,7.72)
N19111564:
  vias: v1(171.54,166.17)
N19518338: length 1.8
  TOP w0.102: CA51.2 v1(21.19,28.6)
  TOP w0.203: UA2.B3 22.05,29 22.04,29 CA51.2
N19518342: length 2.4
  TOP w0.127: v1(23.85,31.75) RA46.2
  TOP w0.203: UA2.A1 22.88,30.53 23.02,30.66 RA46.2
N19518343: length 1.9
  TOP w0.102: v1(23.55,28.6) RA47.2
  TOP w0.203: UA2.A3 22.55,29.14 22.68,29.01 RA47.2
N19518406: length 0.8
  TOP w0.254: UA3.A3 19.92,23.83 RA39.2
N19518407: length 4
  TOP w0.203: RA38.2 21.65,22.52 v1(21.17,23) 20.74,23.43 20.74,24.48 20.21,25 UA3.A1
N19518412: length 2.3
  TOP w0.254: CA44.2 17.79,25 v1(18.15,24.63) 18.78,24 UA3.B3
N19518451: length 3.4
  TOP w0.102: v1(37.38,28.71) 37.51,28.71 38.45,29.65 CA11.1
  TOP w0.107: CA11.1 39.07,29.07 v2(39.07,28.63)
  BOTTOM w0.102: RA2.2 39.02,28.58 v2(39.07,28.63)
N19518500: length 5.3
  BOTTOM w0.102: CA21.1 29.37,25.75 29.01,25.38 29.01,25.28 28.61,24.89 28.61,24.67 v1(28.38,24.44)
  BOTTOM w0.203: 29.44,27.73 29.44,27.78 30.02,28.35 UA1.27
  BOTTOM w0.254: 29.44,27.73 28.96,27.24 28.96,26.21 29.37,25.8 CA21.1
N19518501: length 3.5
  BOTTOM w0.203: UA1.28 29.62,28.41 v1(28.51,27.31)
  BOTTOM w0.254: v1(28.51,27.31) 28.51,26.33 28.46,26.28 CA21.2
N19518503: length 2.4
  BOTTOM w0.203: CA20.1 30.36,27.05 30.36,27.62 v1(30.37,27.63) 30.37,27.69 30.82,28.13 UA1.25
N19518504: length 3.6
  BOTTOM w0.102: CA20.2 29.84,26.09 v1(30.31,25.62)
  BOTTOM w0.203: UA1.26 30.42,28.24 30.06,27.89
  BOTTOM w0.254: 30.06,27.89 29.84,27.67 CA20.2
N19518526: length 3.5
  TOP w0.254: CA85.1 34.82,26.8 34.81,26.79 33.99,26.79 CA23.1 33.98,27.39 33.96,27.42 v2(33.96,27.82)
  BOTTOM w0.107: v2(33.96,27.82) 33.96,28.07 33.62,28.41 UA1.18
N19518594: length 7.9
  BOTTOM w0.102: v1(26.78,39.67) 28.74,39.67 29.22,40.15 RA68.1
  BOTTOM w0.203: UA1.46 30.82,37.51 CA4.1
  BOTTOM w0.381: CA4.1 30.81,37.86 30.56,38.1 CA3.1 30.56,38.97 RA68.1
N19518614: length 4.9
  TOP w0.102: v1(32.25,36.1) 32.25,36.15 v2(32.76,36.67)
  TOP w0.508: v2(32.76,36.67) 33.12,37.02 CA8.1 33.12,38.35 CA7.1 RA69.1
  BOTTOM w0.203: v2(32.76,36.67) 32.82,36.62 UA1.51
N19518635: length 5.4
  BOTTOM w0.102: v1(26.11,37.32) 26.66,36.77 26.87,36.77 27.33,36.31 CA26.1
  BOTTOM w0.203: 28.85,36.31 29.49,36.31 29.62,36.18 UA1.43
  BOTTOM w0.254: 28.85,36.31 28.6,36.05 28.09,36.05 27.83,36.31 CA26.1 CA27.1
N19518638: length 4.6
  BOTTOM w0.102: CA33.1 26.64,34.37 26.01,35 v1(24.57,35)
  BOTTOM w0.203: UA1.41 28.17,34.51
  BOTTOM w0.254: CA33.1 27.33,34.69 28,34.69 28.17,34.51
N19518639: length 5.2
  TOP w0.102: v1(30.07,27.96) 30.07,27.68 31.01,26.73 CA30.1
  TOP w0.254: v2(32.6,27.36) 32.28,27.04 CA31.1 31.77,26.66 31.69,26.73 CA30.1
  BOTTOM w0.203: v2(32.6,27.36) 32.39,27.56 32.39,28.1 32.42,28.12 UA1.21
N19518650: length 4.5
  TOP w0.102: v1(30.21,37.2) CA32.1
  TOP w0.254: CA32.1 v2(28.34,36.56)
  BOTTOM w0.203: v2(28.34,36.56) 28.53,36.75 29.55,36.75 30.02,36.29 UA1.44
N19518666: length 4.3
  TOP w0.102: CA25.1 v1(29.76,29.73)
  TOP w0.254: v2(27.76,28.68) 27.8,28.68 28.03,28.45 CA25.1
  BOTTOM w0.203: v2(27.76,28.68) 28.02,28.68 28.29,28.95 28.29,29.58 28.41,29.71 UA1.29
N19518674: length 4.5
  TOP w0.102: CA24.1 28.58,32.1 v1(28.76,32.27)
  TOP w0.254: CA24.1 28.47,31.12 28.01,30.66 28.01,30.34 27.63,29.96 v2(27.44,29.96)
  BOTTOM w0.203: v2(27.44,29.96) 27.62,29.96 28.17,30.51 UA1.31
N19518681: length 9.1
  TOP w0.254: CA19.2 33.36,28.43 33.18,28.61 32.75,28.61 v1(32.19,28.05) 32.14,28.05 v2(31.51,27.42)
  BOTTOM w0.203: v2(31.51,27.42) 31.57,27.48 31.57,28.1 31.62,28.14 UA1.23
N19518684: length 4.9
  TOP w0.102: v1(33.04,21.89) 32.44,22.49 CA19.1
  TOP w0.254: RA16.1 30.29,23.6 RA15.2 31.76,23.95 31.76,23.55 32.2,23.1 CA19.1
N19529476: length 3.9
  TOP w0.203: v2(33.32,16.05) 33.45,15.92 UA4.23
  BOTTOM w0.102: 33.78,16.81 33.64,16.81 32.91,17.54 v1(32.91,18.3)
  BOTTOM w0.457: v2(33.32,16.05) 33.32,16.36 33.78,16.81 CA74.1
N19529515: length 4.1
  TOP w0.102: CA66.2 28.71,9.9 28.25,9.45 27.52,9.45 v1(26.88,10.09)
  TOP w0.107: UA4.40 29.28,9.81 29.19,9.9 CA66.2
N19529521: length 2.9
  TOP w0.102: 36.76,10.17 36.72,10.21 v2(36.72,10.34)
  TOP w0.107: 36.76,10.17 37.11,9.81 UA4.3
  BOTTOM w0.107: RA51.2 37.46,11.34 CA71.2 37.25,10.34 v2(36.72,10.34)
N19529522: length 4.1
  TOP w0.102: v2(36.71,11.74) 36.71,11.56 36.78,11.5
  TOP w0.107: UA4.6 37.26,11.01 36.78,11.5
  BOTTOM w0.102: RA52.1 36.71,13.1 v1(36.69,13.12)
  BOTTOM w0.107: v2(36.71,11.74) 37.3,12.33 RA51.1 37.6,12.4 RA52.1
N19529526:
  vias: v1(39.54,10.04) v2(39.7,10.6) v2(40.29,10.6)
N19529531: length 3.4
  TOP w0.107: UA4.5 37.08,10.61 v2(36.72,10.98)
  BOTTOM w0.107: RA62.2 36.77,9.64 v1(36.56,9.85) 36.31,10.11 36.31,10.51 36.72,10.92 v2(36.72,10.98)
N19616464: length 16.8
  TOP w0.089: v1(217.13,119.5) CG231.1
  TOP w0.305: v2(226.97,111.65) 226.5,111.65 226.35,111.5 CG230.1 224.66,111.52 224.58,111.6 224.58,112.04 224.77,112.23 224.77,112.92 224.06,113.63 224.06,116.92 LG4.2 221.32,119.66 CG232.1 218.8,119.66 CG231.1
  BOTTOM w0.25: UG9.BC12 v2(226.97,111.65)
N19616930: length 64.7
  TOP w0.254: CG237.1 226.93,99.19 v2(226.32,99.8)
  TOP w0.305: v2(247.32,93.5) 247.03,93.21 CG233.1 ; CG234.1 235.81,110.41 v2(235.32,110.9) 234.9,110.48 CG235.1
  IN1 w0.35: v2(247.32,93.5) 246.72,92.9 246.72,91.8 245.45,90.53 228.29,90.53 226.92,91.9 226.92,99.2 v2(226.32,99.8) 226.92,100.4 226.92,108.66 227.97,109.72 234.14,109.72 v2(235.32,110.9)
  IN3 w0.381: v2(227.02,112.39) 228.1,112.39 228.42,112.07 228.42,110.54 228.7,110.27 234.69,110.27 v2(235.32,110.9)
  BOTTOM w0.25: v2(235.32,110.9) 235.32,111 UG9.BB24 ; v2(227.02,112.39) 226.93,112.39 UG9.BD12
  BOTTOM w0.3: v2(226.32,99.8) 226.22,99.8 UG9.AF11 ; v2(247.32,93.5) 247.42,93.5 UG9.U42
  vias: v1(226.28,113.66)
N19618056: length 38.1
  TOP w0.102: RG101.1 196.81,108.74 196.91,108.84 v1(197.2,108.84) 197.54,109.19 v2(197.67,109.19)
  IN6 w0.102: v2(223.09,115.5) 222.13,116.45 222.13,118.8 221.24,119.69 217.44,119.69 217.11,119.36 213.5,119.36 212.16,118.02 212.16,117.28 211.37,116.48 208.97,116.48 208.55,116.89 204.03,116.89 201.3,114.17 201.3,113.34 200.48,112.51 200.48,110.94 198.56,109.02 197.84,109.02 v2(197.67,109.19)
  BOTTOM w0.089: v2(223.09,115.5) 222.47,116.11 UG9.BJ6
N19842722: length 2.4
  TOP w0.102: RG130.1 v1(227.24,61.06)
  TOP w0.305: RG130.1 225.43,61.06 v2(225.39,61.11)
  BOTTOM w0.122: UG5.J13 v2(225.39,61.11)
N19842724: length 4.9
  TOP w0.102: v2(214.81,60.71) v1(215.2,60.32) 216.41,59.11 217.69,59.11 218.07,59.49 RG126.1
  BOTTOM w0.102: UG5.J1 v2(214.81,60.71)
N19842731: length 2
  TOP w0.102: v2(222.04,60.76) 221.91,60.63 v1(221.52,60.63)
  TOP w0.305: v2(222.04,60.76) 222.26,60.98 RG128.1
  BOTTOM w0.111: UG5.J10 222.09,60.71 v2(222.04,60.76)
N19847413: length 3.1
  TOP w0.102: v1(277.55,71.75) 276.97,72.33 RG120.1
  TOP w0.305: RG120.1 276.36,73.15 v2(276.15,73.36)
  BOTTOM w0.102: UG4.J13 276.55,73.76 v2(276.15,73.36)
N19847417: length 3.5
  TOP w0.102: RG116.1 275.13,84.66 v1(275.13,83.56)
  TOP w0.508: v2(276.52,83.99) 275.75,84.76 RG116.1
  BOTTOM w0.305: v2(276.52,83.99) 276.55,83.96 UG4.J1
N19847426: length 2.1
  TOP w0.102: v2(276.5,76.71) v1(276.5,77.49)
  TOP w0.305: RG118.1 276.96,76.25 v2(276.5,76.71)
  BOTTOM w0.107: v2(276.5,76.71) 276.55,76.66 UG4.J10
N19849394: length 2.1
  TOP w0.102: RG119.1 260.47,61.02 v2(260.39,61.11) 260.39,61.16 v1(260.87,61.64)
  BOTTOM w0.102: UG3.J13 v2(260.39,61.11)
N19849396: length 2.5
  TOP w0.102: RG115.1 v1(249.06,61.81)
  TOP w0.305: v2(249.81,60.71) 249.12,60.71 RG115.1
  BOTTOM w0.3: UG3.J1 v2(249.81,60.71)
N19849403: length 1.9
  TOP w0.102: v2(257.04,60.76) v1(257.04,61.38)
  TOP w0.305: RG117.1 257.5,60.3 v2(257.04,60.76)
  BOTTOM w0.102: v2(257.04,60.76) 257.09,60.71 UG3.J10
N19854250: length 2.7
  TOP w0.102: v1(277.78,109.24) 276.93,108.39 RG109.1 276.24,108.27 v2(276.15,108.36)
  BOTTOM w0.125: v2(276.15,108.36) 276.36,108.57 UG2.J13
N19854254: length 4.2
  TOP w0.102: v2(276.52,119.01) 276.04,119.5 RG105.1 274.72,119.99 v1(273.96,120.75)
  BOTTOM w0.3: v2(276.52,119.01) 276.55,118.99 UG2.J1
N19854263: length 2.2
  TOP w0.102: v2(276.5,111.71) v1(277.26,111.71)
  TOP w0.305: RG107.1 276.25,111.46 v2(276.5,111.71)
  BOTTOM w0.125: v2(276.5,111.71) 276.55,111.66 UG2.J10
N19855299: length 5.5
  BOTTOM w0.305: QG2.1 283.87,103.66 v1(280.78,103.66) 278.7,103.66 RG111.1
N19856231: length 2
  TOP w0.102: v2(276.15,98.96) 276.25,99.06 RG108.1
  BOTTOM w0.125: UG1.J13 v2(276.15,98.96)
N19856233: length 2.7
  TOP w0.102: RG104.1 276.5,87 v1(276.02,86.52)
  TOP w0.305: v2(276.55,88.36) 276.54,88.35 276.54,87.6 RG104.1
  BOTTOM w0.3: UG1.J1 v2(276.55,88.36)
N19856240: length 1.9
  TOP w0.102: v2(276.5,95.61) v1(277.12,95.61)
  TOP w0.305: v2(276.5,95.61) 276.49,95.62 RG106.1
  BOTTOM w0.111: v2(276.5,95.61) 276.55,95.66 UG1.J10
N19942790: length 18.3
  TOP w0.254: UU5.2 22.84,36.22 CU27.1 24.01,36.31 v1(24.28,36.59) 24.39,36.69 v2(24.39,37.2) ; v2(32.08,44.19) 32.89,44.19 RU5.2 34.16,45.46 DU8.2
  IN2 w0.254: v2(32.08,44.19) 32.01,44.19 31.87,44.33 29.75,44.33 28.74,43.31 28.74,42.75 27.95,41.96 27.95,41.27 25.47,38.79 25.47,38.28 v2(24.39,37.2)
N19967780: length 2.6
  TOP w0.102: v1(18.73,43.58) 19.15,44 RU3.2 20.1,44.36 20.9,44.36 UU1.16
N19967783: length 3.4
  TOP w0.102: v1(18.69,45.82) 18.54,45.67 18.54,45.08 18.78,44.83 RU2.2 19.76,44.86 UU1.15
N19967793: length 2.7
  TOP w0.102: v1(25.17,47.09) 25.17,46.89 25.59,46.47 RU7.2
  TOP w0.107: RU7.2 25.32,46.09 25.09,45.86 UU1.8
N19967795: length 3.9
  TOP w0.102: 23.4,43.21 23.33,43.29 UU1.4 ; RU1.2 25.78,43.97 v1(25.55,44.2)
  TOP w0.107: 23.4,43.21 23.45,43.17 25.71,43.17 RU1.2
N20019079: length 2.8
  BOTTOM w0.102: UG31.2 191.97,56.48 192.15,56.66 192.15,57.09 192.5,57.45 v1(192.5,57.6) 192.5,58.05 RG582.2
N20112847: length 3.5
  BOTTOM w0.102: RT116.2 189.43,167.57 CT37.1 189.5,167.5 190.04,167.5 190.44,167.1 191.34,167.1 191.87,167.63 YT1.1
N20112857: length 3.4
  BOTTOM w0.102: RT117.2 189.38,166.98 CT38.1 189.79,167.27 189.95,167.27 190.18,167.04 190.18,166.07 190.28,165.97 190.53,165.97 YT1.3
N20124859: length 2.2
  TOP w0.254: v2(181.94,164.95) 181.94,164.97 UT1.R13
  BOTTOM w0.102: LT4.1 176.91,170.65 v1(177.03,170.53)
  BOTTOM w0.381: v2(181.94,164.95) 181.9,164.99 CT153.1
  vias: v2(175.27,167.8)
N20496102: length 2.9
  TOP w0.102: v1(28.43,3.05) 28.6,2.89 30.59,2.89 31.06,3.36 RA76.1
N20496103: length 0.9
  BOTTOM w0.102: v2(34.46,3.9) 34.32,4.23 RA75.1
N20496104: length 1.1
  TOP w0.102: RA74.1 35.57,3.42 v1(34.95,2.8)
N20496105: length 1.4
  BOTTOM w0.102: 40.2,6.91 40.2,6.56 40.39,6.37 40.39,5.79 v1(40.23,5.63)
N20647992: length 1.3
  BOTTOM w0.102: RH591.2 CH232.1
N20649294: length 1.2
  BOTTOM w0.102: CE20.1 101.06,27.32 RE22.2
N20653356: length 1.2
  BOTTOM w0.102: CT157.2 198.18,159.95 198.23,159.95 198.26,159.97 198.61,159.97 RT123.1
N20764785: length 15.8
  TOP w0.089: v1(194.47,45.08) 195.97,45.08 196.48,44.57 197.49,44.57 198,44.06 v2(198,43.74)
  TOP w0.102: v2(192.92,42.6) 192.79,42.6 191.72,43.68 191.72,44.2 192.59,45.08 v1(194.47,45.08)
  BOTTOM w0.089: v2(198,43.74) 198,44.31 197.8,44.52 RH580.1 ; UH1.F3 195.75,40.92 195.88,41.05 195.88,41.42 194.26,43.04 193.37,43.04 193.27,42.95
  BOTTOM w0.102: 193.27,42.95 v2(192.92,42.6)
N20764786: length 14
  TOP w0.089: v2(195.53,40.06) v1(196.86,41.39) 196.86,41.95 198.38,43.48 198.38,43.93 198.26,44.06 198.26,44.89 199.07,45.7 199.57,45.7
  TOP w0.102: 199.57,45.7 200.22,46.35 200.22,46.56 v2(200.85,47.18)
  BOTTOM w0.089: UH1.G3 196.37,40.21 196.1,39.93 195.65,39.93 v2(195.53,40.06) ; 199.7,45.7 199.34,45.33 RH581.1
  BOTTOM w0.102: v2(200.85,47.18) 199.97,46.3 199.97,45.96 199.7,45.7
N20764806: length 2.7
  TOP w0.122: v2(213.87,23.3) v1(214.83,23.3) 215.84,23.3 RH89.2
  BOTTOM w0.122: UH1.BB36 213.86,23.31 v2(213.87,23.3)
N20904379: length 2.9
  BOTTOM w0.089: UT4.A7 UT4.A6 ; UT4.A7 UT4.B7 ; UT4.A7 UT4.A8 201.66,161.3 201.56,161.2 201.56,160.65
  BOTTOM w0.102: 201.56,160.65 RT22.1
N20905578: length 4.2
  TOP w0.107: v2(202.65,168.37) 202.65,168.15 202.32,167.82 202.32,166.8 v2(201.41,165.89)
  BOTTOM w0.076: v2(201.41,165.89) 201.16,165.63 UT4.H7
  BOTTOM w0.089: v2(202.65,168.37) 202.63,168.39 202.63,168.46
  BOTTOM w0.102: CT104.1 202.63,168.46
N20905857: length 3.1
  TOP w0.102: v2(197,164.45) 196.89,164.45 196.52,164.82 v1(196.52,165.08) 196.53,165.09 RT83.2
  BOTTOM w0.076: UT4.F1 197.9,164.62 197.56,164.62 197.56,164.62 197.16,164.62
  BOTTOM w0.127: 197.16,164.62 v2(197,164.45)
N20968008: length 1.7
  TOP w0.107: RE528.2 RE527.1 230.54,32.73 230.2,33.07 QE53.5
N20968033: length 3.1
  TOP w0.107: QE54.2 225.29,27.41 225.76,26.94 RE449.2 RE511.1
N20968035: length 1.7
  BOTTOM w0.107: RE455.2 RE456.1 230.54,23.7 230.2,23.36 QE39.5
N20968040: length 1.7
  BOTTOM w0.107: QE29.5 236.1,33.07 236.44,33.42 RE397.1 RE396.2
N20968043: length 2.8
  BOTTOM w0.102: RE401.1 233.24,32.73 233.59,33.07 QE29.2 ; RE401.1 RE399.2 ; RE401.1 232.47,32.73 v1(232.13,32.39)
N20968050: length 1.7
  BOTTOM w0.107: RE454.2 RE453.1 227.15,23.02 227.38,23.02 227.72,23.36 QE39.2
N20968053: length 2.8
  TOP w0.102: v1(231.85,27.08) 231.71,26.94 RE513.2
  TOP w0.107: QE49.5 230.2,26.6 230.54,26.25 RE512.1 RE513.2
N20968066: length 2.8
  TOP w0.107: QE49.2 227.66,26.6 227.53,26.47 227.53,26.07 227.66,25.95 QE49.3 228.02,25.62 227.85,25.45 227.36,25.45 RE511.2
N20968067: length 1.7
  BOTTOM w0.102: QE40.2 227.85,26.6 227.31,26.06 RE458.1 RE460.2
N20968070: length 1.7
  BOTTOM w0.107: RE461.2 RE462.1 230.54,26.94 230.2,26.6 QE40.5
N20968081: length 1.6
  BOTTOM w0.102: RE467.2 RE465.1 227.44,29.56 227.72,29.84 QE41.2
N20968083: length 1.7
  BOTTOM w0.107: QE41.5 230.2,29.84 230.54,30.18 RE468.1 RE466.2
N20968085: length 3.5
  TOP w0.107: RE517.2 RE514.1 223.68,26.13 224.1,25.71 224.1,25.64 224.57,25.17 225.17,25.17 225.29,25.29 QE54.5
N20968092: length 4.2
  TOP w0.102: QE50.5 225.29,21.85 v1(225.61,21.53)
  TOP w0.107: RE516.2 RE515.1 225.01,23.14 225.29,22.87 QE50.5
N20968099: length 3.2
  TOP w0.107: QE50.2 225.29,24.11 225.19,24.01 224.74,24.01 224.64,24.1 QE50.3 224.64,24.77 223.87,25.54 RE514.2
N20968108: length 1.7
  BOTTOM w0.107: QE42.2 227.72,33.07 227.38,32.73 227.15,32.73 RE472.1 RE474.2
N20968112: length 3.2
  BOTTOM w0.102: RE471.2 231.01,32.73 v1(231.94,33.66)
  BOTTOM w0.107: RE471.2 RE473.1 230.54,33.42 230.2,33.07 QE42.5
N20968116: length 2.7
  BOTTOM w0.102: v1(232.2,29.81) 232.57,30.18 RE480.2 RE479.1 233.28,29.49 233.63,29.84 QE43.2
N20968120: length 2.8
  BOTTOM w0.102: RE476.2 237.17,29.49 v1(237.6,29.06)
  BOTTOM w0.107: QE43.5 236.1,29.84 236.44,30.18 RE478.1 RE476.2
N20968122: length 5.1
  TOP w0.102: v1(223.59,29.92) 224.65,29.92 225.05,30.33 225.05,30.57 QE55.2
  TOP w0.107: QE55.2 225.51,30.6 225.51,30.5 225.77,30.24 227.09,30.24 RE521.2 RE518.1
N20968127: length 1.7
  TOP w0.107: QE51.5 230.2,29.84 230.54,29.49 RE519.1 RE520.2
N20968134: length 2.2
  TOP w0.107: RE518.2 227.43,28.91 227.7,29.19 QE51.3 228.27,29.19 228.37,29.29 228.37,29.73 228.27,29.84 QE51.2
N20968141: length 11
  TOP w0.102: v2(226.15,29.78) 225.83,29.78 225.29,29.25 QE55.5
  TOP w0.107: RE525.2 RE522.1 226.64,23.02 v2(226.61,22.99)
  IN1 w0.102: v2(226.15,29.78) 227.02,28.91 227.02,26.53 226.61,26.13 v2(226.61,22.99)
  BOTTOM w0.102: v2(226.15,29.78) 226.15,30.51 v1(225.93,30.72)
N20968146: length 2.7
  TOP w0.102: RE524.2 v1(231.76,23.7)
  TOP w0.107: QE52.5 230.32,23.36 230.67,23.02 RE523.1 RE524.2
N20968153: length 2.7
  TOP w0.102: v1(226.95,21.48) 226.95,22.23 RE522.2
  TOP w0.107: RE522.2 227.74,22.43 QE52.3 QE52.2
N20968157: length 1.7
  BOTTOM w0.102: RE486.2 RE485.1 233.28,26.25 233.63,26.6 QE44.2
N20968166: length 2.6
  BOTTOM w0.102: RE484.1 v1(237.61,26.94)
  BOTTOM w0.107: QE44.5 236.1,26.6 236.44,26.94 RE484.1 RE482.2
N20968170: length 1.7
  BOTTOM w0.102: RE492.2 RE491.1 233.33,23.02 233.67,23.36 QE45.2
N20968174: length 3.5
  BOTTOM w0.102: v1(235.91,21.66) 235.91,21.93 236.33,22.35 236.33,22.69 236.66,23.02 RE488.2
  BOTTOM w0.107: QE45.5 236.22,23.36 236.56,23.7 RE490.1 RE488.2
N20968178: length 1.7
  TOP w0.107: RE498.2 RE496.1 236.42,32.73 236.08,33.07 QE46.2
N20968182: length 1.6
  TOP w0.107: RE495.2 RE497.1 233.32,33.42 233.66,33.07 QE46.5
N20968184: length 6.7
  TOP w0.102: QE56.2 223.89,34.74 v1(223.33,35.31)
  TOP w0.107: QE56.2 223.89,33.63 224,33.52 224.16,33.52 224.52,33.17 224.52,32.92 225.1,32.34 225.98,32.34 226.38,32.73 RE526.1 RE529.2
N20968195: length 3.5
  TOP w0.102: v1(226.18,32.07) 226.26,32.15 RE526.2
  TOP w0.107: RE526.2 227.49,32.15 227.77,32.42 QE53.3 228.43,32.42 228.52,32.51 228.52,32.91 228.35,33.07 QE53.2
N20968204: length 1.7
  TOP w0.107: RE503.2 RE501.1 236.48,29.49 236.14,29.84 QE47.2
N20968208: length 1.5
  TOP w0.102: RE502.2 RE504.1 233.91,29.87 QE47.5
N20968214: length 4.6
  TOP w0.102: QE48.2 235.36,26.11 235.36,25.63 235.37,25.62 235.37,25.29 235.36,25.28 235.36,25.1 235.15,24.88 v1(234.57,24.88) 234.32,24.88 RE508.1 233.82,24.31 233.26,23.75 RE510.2
N20968218: length 1.7
  TOP w0.107: RE507.2 RE509.1 233.26,26.94 233.6,26.6 QE48.5
N20972959: length 3.7
  TOP w0.102: JLAN.9 245.95,172.76 v1(244.09,172.76) RL8.1
N20972981: length 2.7
  BOTTOM w0.102: RL5.1 v1(265.74,170.12)
  BOTTOM w0.107: RL5.1 267.59,169.49 UL2.3
N20972982: length 19.9
  TOP w0.102: CL31.1 266.12,161.47 265.88,161.23 LL1.2
  TOP w0.107: JLAN.12 v1(261.76,172.47) 262.65,172.47 263.71,171.4 263.74,171.4 266.56,168.59 266.56,167.8 267.75,166.61 267.75,163.53 266.12,161.9 CL31.1
N20973042: length 3.1
  BOTTOM w0.102: RL2.2 276.61,164.68 276.4,164.47 v1(276.4,164.16) 276.4,163.79 276.12,163.52 275.79,163.52 275.66,163.64 UL1.5
N20973177: length 9.3
  TOP w0.508: RL13.2 263.47,157.19 264.46,156.2 v1(264.82,156.2) 265.29,156.2 265.64,156.55 266.87,156.55 267.95,157.63 267.95,158.07 267.33,158.69 RL14.2 266.96,159.27 QL3.1
N20986399: length 8.4
  TOP w0.102: v2(147.12,167.18) 147.19,167.25 UE12.3 148,167.25 148.45,166.81 v1(148.81,166.81)
  TOP w0.107: v2(152.62,166.63) 152.47,166.48 RE161.1
  IN6 w0.102: v2(152.62,166.63) 152.34,166.91 147.86,166.91 147.59,167.18 v2(147.12,167.18)
N20995131: length 3.5
  TOP w0.102: UE3.24 227.51,163.98 v1(227.38,164.11) 226.06,164.11 RE25.2
N20995135: length 1.6
  TOP w0.102: UE3.30 225.41,159.66 RE31.1
N20999302: length 4.2
  BOTTOM w0.102: v1(123.86,161.98) 123.86,161.33 RM72.1 124.32,160.84 124.65,160.51 125.19,160.51 125.38,160.32 125.76,160.32 126.1,159.98 UM8.27
N20999314: length 1.8
  BOTTOM w0.107: RM61.2 138.07,156.49 v2(137.75,156.81) 137.58,156.98 UM8.52
N20999316: length 4
  BOTTOM w0.102: 138.35,160.01 138.79,159.57 v1(139.77,159.57)
  BOTTOM w0.107: UM8.48 138.17,158.98 RM64.1 RM66.1
N21000707: length 3.8
  BOTTOM w0.102: v1(172.49,154.16) RM21.2
  BOTTOM w0.107: UM4.1 171.19,154.66 171.26,154.59 RM21.2 RM96.2
N21000709: length 3.3
  BOTTOM w0.102: CM99.1 RM29.1
  BOTTOM w0.107: RM29.1 164.25,163.48 164.83,164.06 RM28.1
N21000711: length 5.9
  BOTTOM w0.102: CM98.1 RM38.1 164.21,164.61 164.92,165.32 166.12,165.32 166.26,165.18 166.26,165.01 166.76,164.52 166.79,164.52 167.24,164.06 RM27.1 v1(167.45,165)
N21000719: length 1.4
  BOTTOM w0.102: CM17.1 172.4,162.91 v1(172.86,163.36)
N21000750: length 1.7
  BOTTOM w0.107: UM4.18 169.89,163.25 RM25.2
N21000786: length 1.7
  BOTTOM w0.107: UM4.13 166.64,162.48 166.43,162.69 RM28.2
N21000788: length 1.6
  BOTTOM w0.107: UM4.14 167.29,162.57 167.45,162.73 RM27.2
N21000830: length 8.1
  BOTTOM w0.107: RM92.2 147.91,167.21 147.19,166.49 147.06,166.49 145.98,167.57 QM1.2 145.74,167.58 145.74,168.46 146.19,168.9 v1(147.52,168.9) 148.53,168.9 149.22,168.22 QM2.6
N21000850: length 5.8
  BOTTOM w0.102: RM94.2 150.91,165.48 151.41,165.98 152.71,165.98 153.29,166.55 QM3.2 152.97,167.47 152.52,167.02 152.07,167.02 151.96,166.92 QM2.3
N21000877: length 3.8
  BOTTOM w0.102: RM20.2 168.84,153.65 v1(168.84,152.28)
  BOTTOM w0.107: UM4.4 169.24,154.27 RM20.2
N21002214: length 2.7
  BOTTOM w0.102: v1(99.96,16.64) 100.31,17 RE14.2
  BOTTOM w0.107: RE14.2 UE2.3
N21002223: length 1.9
  BOTTOM w0.102: UE2.6 101.09,26.37 100.24,27.22 RE11.1
N21002224: length 6.3
  BOTTOM w0.102: v1(97.86,21.47) 97.7,21.63 RE9.1 99.65,22.41 99.82,22.57 UE2.5
N21002246: length 1.6
  BOTTOM w0.107: RE13.2 UE2.7
N21002352: length 1.6
  BOTTOM w0.107: UE2.2 102.36,17.36 RE10.1
N21002397: length 3.1
  BOTTOM w0.102: UE9.3 100.81,30.53 100.71,30.63 100.31,30.63 99.95,30.27 RE20.1 v1(99.39,29.27)
N21003330: length 2.7
  BOTTOM w0.102: v1(187.35,40.5) R181.2 187.39,41.57 U2407.7
N21003701: length 5.9
  TOP w0.254: JFAN1.3 104.37,64.22 103.35,63.2 v1(102.88,63.2) 102.88,61.63 DF1.1 103.3,61.21 RF3.1
N21003743: length 12.7
  TOP w0.102: DF2.1 292.83,74.49 RF6.1 293.37,75.89 293.37,77.12 v1(292.38,78.11) 292.38,79.78 291.27,80.89 289.04,80.89 288.37,80.22 JFAN2.3
N21024703: length 2.5
  BOTTOM w0.102: C3.1 v1(128.04,106.43)
  BOTTOM w0.127: UZ21.6 128.1,104.93 128.04,104.99 C3.1
N21194807: length 2.2
  TOP w0.102: RV13.2 163.55,164.58 CV374.1 164.35,163.73 v1(164,163.39)
N21200526: length 14.4
  IN6 w0.102: v2(136.92,117.72) 136.92,116.82 136.46,116.36 134.96,116.36 133.47,117.85 133.47,119.17 131.91,120.73 130.09,120.73 v2(129.04,121.78)
  BOTTOM w0.076: v2(136.92,117.72) 137.17,117.46 UC1.BH31
  BOTTOM w0.102: RH153.2 v1(128.55,122.52) 128.71,122.52 129.04,122.19 v2(129.04,121.78)
N21200532: length 4
  BOTTOM w0.076: UC1.BR30 132.72,117.08 130.87,117.08 130.86,117.08 130.39,117.08 129.87,117.6 129.87,117.75 129.88,117.76 RH158.2
N21238299: length 5.4
  TOP w0.102: UE8.24 305.22,40.95 305.12,41.05 303.76,41.05 303.16,40.44 v1(302.5,40.44) 302.24,40.44 302.14,40.34 302.14,39.36 RE166.2
N21238303: length 3.1
  TOP w0.102: RE167.1 302,35.8 v1(302.95,36.76) 303.47,37.28 UE8.30
N21643800: length 26.4
  IN1 w0.762: 308.84,51.24 308.84,50.7 307.09,48.95 301.88,48.95 297.18,44.25 292.3,44.25 290.46,46.09 290.08,46.09
  IN2 w0.762: 288.93,44.92 288.93,41.3
  vias: v1(309.62,51.51) v2(288.35,40.36) v2(288.55,46.3) v2(288.93,45.85) v2(288.93,40.36) v2(308.84,52.8) v2(308.84,52.22)
N21646778: length 13.3
  IN1 w0.762: 297.02,54.47 293.79,51.24 288.69,51.24
  IN2 w0.762: 286.77,50.46 286.77,46.82
  vias: v1(296.87,55.4) v2(287.08,51.55) v2(287.22,45.5) v2(287.35,46.07) v2(287.66,51.55) v2(297.57,55.82) v2(297.57,55.24)
N21748624: length 1.4
  TOP w0.102: PR733.1 v1(79.89,27.83)
N21874242: length 5.6
  TOP w0.254: PQ9.6 118.56,79.62 118.94,80 118.94,82.79 118.5,83.24 v1(118.33,83.24) 117.31,83.24 PR27.2
N21874255: length 2.9
  TOP w0.102: PR31.2 v1(115.29,80.29)
  TOP w0.254: PR31.2 PR29.1 117.26,80.27 PQ9.5
N21874275: length 2.8
  TOP w0.102: PR33.2 v1(122.06,79.38)
  TOP w0.254: PR33.2 PC15.2 121.02,80.27 PQ9.2
N21874281: length 3
  TOP w0.102: v1(120.12,82.05) PQ9.3
  TOP w0.254: PQ9.3 120.85,80.92 PC15.1 121.07,81.89 PR32.2
N21995444: length 0.9
  BOTTOM w0.102: RT122.2 195.33,158.65 CT156.1
N22226841: length 6.3
  TOP w0.102: QV97.5 218.28,159.99 219.46,161.17 219.55,161.17 219.73,161.34 219.73,163.74 v1(219.85,163.86) 219.96,163.98 UX1.4
N22301470: length 2
  TOP w0.102: v1(199.86,91.28) 199.43,91.71 v2(199.43,91.85) 199.41,91.88 RG157.1
  BOTTOM w0.125: v2(199.43,91.85) 199.18,92.1 UG7.J13
N22301471: length 2.7
  TOP w0.102: RG158.1 v1(198.97,104.51)
  TOP w0.254: RG158.1 198.97,102.69 v2(199.03,102.63)
  BOTTOM w0.305: v2(199.03,102.63) UG7.J1
N22301473: length 2.3
  TOP w0.102: v1(199.83,95.51) 199.53,95.2 v2(199.08,95.2) 198.52,95.76 RG159.1
  BOTTOM w0.111: UG7.J10 199.08,94.7 v2(199.08,95.2)
N22301475: length 2.7
  TOP w0.102: v2(199.43,82.45) 199.32,82.35 RG162.1 v1(198.65,83.65)
  BOTTOM w0.17: UG8.J13 199.2,82.23 v2(199.43,82.45)
N22301476: length 2.6
  TOP w0.102: RG161.1 v1(199.13,69.88)
  TOP w0.305: v2(199.08,71.8) 199.13,71.75 RG161.1
  BOTTOM w0.4: UG8.J1 199.03,71.85 v2(199.08,71.8)
N22301478: length 2.1
  TOP w0.102: v2(199.08,79.1) 199.08,79.38 v1(198.76,79.7)
  TOP w0.305: RG163.1 198.58,78.6 v2(199.08,79.1)
  BOTTOM w0.125: 199.03,79.43 199.03,79.15 v2(199.08,79.1)
  BOTTOM w0.129: UG8.J10 199.03,79.43
N23042187: length 1.9
  TOP w0.089: v1(221.02,114.23) v2(221.5,113.75) 221.18,113.43 RG564.1
  BOTTOM w0.1: UG9.BE5 221.5,113.62 v2(221.5,113.75)
N23258859: length 5.8
  BOTTOM w0.089: 129.44,105.18 131.35,105.18 131.76,104.78 131.76,104.09 132.01,103.84 133.1,103.84 133.53,103.41 UC1.BP13
  BOTTOM w0.102: T144.1 129.42,105.18 129.44,105.18
N23259058: length 6.3
  TOP w0.089: RH592.2 174.51,117.07 v1(174.51,117.35) 174.51,117.86 v2(173.69,118.67)
  BOTTOM w0.089: UC1.A36 173.99,120.66 174.35,120.3 174.35,119.33 v2(173.69,118.67)
N23259061: length 9.9
  BOTTOM w0.089: v1(178.33,121.49) RH593.2 176.54,121.49 175.78,120.73 175.78,118.85 175.45,118.52 174.91,118.52 174.56,118.88 174.56,120.63 173.75,121.44 UC1.A37
N24138892: length 5.9
  TOP w0.089: 217.7,16.86 217.84,16.72 RH7.1 ; RH6.1 217.75,18.2 v1(217.75,17.52) 217.75,17.43 217.46,17.14 v2(217.46,17.1) 217.6,16.96
  TOP w0.102: 217.7,16.86 217.6,16.96
  BOTTOM w0.254: UH1.BE48 215.53,17.76 UH1.BE49 215.53,17.15 216.06,16.61 217.08,16.61 217.46,17 v2(217.46,17.1)
N24314166: length 4.4
  TOP w0.102: v1(236.13,161.28) 236.47,161.62 v2(236.7,161.62) 237.07,161.62 RX39.2 237.44,162.72 QV3.1
  BOTTOM w0.102: UV3.15 v2(236.7,161.62)
N24365027: length 3.3
  TOP w0.102: UE10.3 317.26,56.08 RE530.2 CE63.2 316.32,55.21 316.3,55.2 v1(316.3,55.12)
N24371838: length 29.2
  IN6 w0.102: v2(208.84,165.85) 209.66,165.85 210.37,165.13 210.37,164.1 211.37,163.1 218.26,163.1 218.68,163.52 218.68,165.55 219.72,166.6 219.72,167.2 221.65,169.13 221.65,174.97 221.34,175.28 218.94,175.28 JHDMI.13
  BOTTOM w0.102: RV655.2 208.8,165.8 v2(208.84,165.85)
N24377091: length 10.4
  TOP w0.102: v2(217.88,157.53) 217.88,157.53 218.06,157.53 218.3,157.77 218.3,157.77 218.39,157.85 218.39,159.57 218.8,159.99 QV97.2
  BOTTOM w0.102: UX2.4 212.52,158.24 213.64,157.13 215.43,157.13 216.15,157.85 217.56,157.85 v2(217.88,157.53)
N24377100: length 3.2
  BOTTOM w0.102: RX6.1 208.36,161.51 208.54,161.33 v1(208.8,161.33) 209.17,161.33 210.04,162.21 QX3.2
N24654525:
  vias: v1(226.15,42.57)
N24654698: length 2.3
  TOP w0.102: U18.3 v1(228.48,45.89) 228.75,45.62 R367.1
N25145265: length 16.2
  BOTTOM w0.102: QV2.1 149.59,161.46 149.75,161.29 150.88,161.29 151.93,162.33 151.93,162.62 153.38,164.07 154.66,164.07 156.09,162.64 157.84,162.64 158.78,163.58 158.78,164.93 v1(159.5,165.64) RV12.2
N25301591: length 11.2
  TOP w0.102: v2(198.05,118.66) 198.38,118.99 v1(199.79,118.99) 200.14,118.99 v2(201.39,120.25)
  BOTTOM w0.102: v2(201.39,120.25) 201.54,120.25 201.99,120.7 201.99,121.04 201.74,121.29 201.53,121.29 201.41,121.41 UG10.4 201.41,122.24 202.54,123.37 203.77,123.37 RG562.1 ; RG7.1 198.42,118.29 v2(198.05,118.66)
N25301635: length 7
  BOTTOM w0.089: RG26.1 230.64,120.67 v1(230.7,120.6) 230.7,119.99 231.28,119.42 232.71,119.42 233.81,118.32 233.81,118 234.02,117.79 234.02,117.35 234.37,117 UG9.BK23
N25301647: length 104.9
  BOTTOM w0.102: RG572.2 193.07,57.07 193.07,58.69 193.29,58.91 193.29,59.34 193.8,59.84 193.8,60.05 194.15,60.4 194.15,62.34 192.62,63.87 190.1,63.87 189.3,64.67 188.33,64.67 187.36,65.64 187.36,66.65 187.36,66.66 187.36,66.9 187.74,67.28 187.74,85.04 187.98,85.28 188.12,85.41 188.12,95.54 182.98,100.68 182.44,100.68 181.51,101.6 181.51,104.66 184.91,108.06 184.91,114.7 183.31,116.3 183.31,120.1 188.29,125.09 196.6,125.09 197.62,124.07 197.62,123.12 198.21,122.54 199.28,122.54 199.72,122.1 199.72,121.03 199.88,120.86 199.88,120.86 199.91,120.83 199.91,119.62 200.79,118.74 201.87,118.74 202.13,119.01 v1(202.13,119.78) 202.13,120.51 202.51,120.89 203.53,120.89 204.46,119.96 QG501.1
N25301655: length 12.8
  BOTTOM w0.102: RG519.1 211.15,124.9 211.02,124.77 209.88,124.77 209.62,125.02 QG500.5 209.62,125.97 209.46,126.14 208.81,126.14 208.58,125.91 208.58,125.58 208.48,125.48 206.59,125.48 206.25,125.81 204.67,125.81 v1(204.57,125.91) 204.29,125.91 203.27,126.93 203.27,128.69 203.5,128.92 RG508.1
N25585283: length 18.3
  IN6 w0.102: v2(212.89,164.56) 216.07,164.56 216.19,164.44 217.98,164.44 218.22,164.68 218.22,165.74 219.26,166.79 219.26,167.5 218.87,167.89 218.87,169.2 218.93,169.26 218.93,169.53 v2(219.33,169.93)
  BOTTOM w0.102: v2(212.89,164.56) 212.75,164.41 212.75,163.68 212.87,163.55 v1(212.87,161.84) 213.03,161.69 RV653.2 ; v2(219.33,169.93) 219.76,169.93 221.46,168.23 DV13.1
N25585284: length 17.9
  IN6 w0.102: v2(219.34,169.35) 219.1,169.1 219.1,167.99 219.49,167.59 219.49,166.69 218.45,165.65 218.45,164.07 217.78,163.4 213.63,163.4 v2(213.15,163.87)
  BOTTOM w0.102: DV12.1 222.4,167.73 221.08,167.73 220.08,168.73 v1(220.08,169.06) 219.8,169.35 v2(219.34,169.35) ; v2(213.15,163.87) 213.38,163.65 213.38,163.01 RV649.2
N25732286: length 1.7
  BOTTOM w0.102: CG64.1 196.16,111.53 196.26,111.63 UG12.12
N25732288: length 3.8
  BOTTOM w0.102: UG12.10 197.06,111.81 196.96,111.71 196.96,111.27 CG65.1 197.52,111.01 198.93,111.01 v1(199.12,110.82)
N25785396: length 13.5
  TOP w0.102: UG22.2 215.97,159.07 216.14,159.24 v2(216.14,159.41) ; QG502.6 212.05,160.14 212.29,160.38 212.29,160.99 211.97,161.31 RG516.2 211.53,161.71 210.98,161.71 210.55,161.28 v2(210.52,161.28)
  IN2 w0.102: v2(210.52,161.28) 210.55,161.26 210.55,160.98 211.24,160.29 212.34,160.29 213.56,161.51 214.28,161.51 216.14,159.65 v2(216.14,159.41)
  BOTTOM w0.102: v2(210.52,161.28) 210.52,160.95 v1(210.05,160.48)
N25788545: length 3.6
  TOP w0.102: QE57.5 271.87,38.83 RE638.1 RE637.2 272.06,39.81 272.35,40.1 272.75,40.1 273.44,39.41 v1(273.44,39.3)
N25788553: length 2.4
  TOP w0.102: v1(273.62,37.11) 272.78,36.28 QE57.3 272.52,35.33 RE636.2
N25788554: length 2.7
  TOP w0.102: RE639.2 271.22,39.19 QE57.6 v1(269.61,38.18)
N25788555: length 2.7
  TOP w0.102: v1(272.77,34.38) 272.21,34.38 271.75,34.84 RE640.2 RE641.1 271.87,35.59 QE57.2
N25802636: length 3.2
  BOTTOM w0.102: v1(194.52,120.91) 195,120.42 RG65.2 194.81,119.99 194.2,119.38 UG11.5
N25805684: length 27.1
  IN6 w0.102: v2(223.57,114.45) 224.01,114.89 224.01,117.88 223.4,118.48 223.4,119.22 222.89,119.72 222.89,121.66 221.97,122.58 220.21,122.58 218.57,120.95 216.72,120.95 216.23,120.45 213.96,120.45 210.76,123.65 209.81,123.65 208.37,122.21 v2(208.37,121.87)
  BOTTOM w0.1: UG9.BG8 v2(223.57,114.45)
  BOTTOM w0.102: RG19.1 208.47,121.66 208.37,121.76 v2(208.37,121.87)
N25805686: length 30
  IN6 w0.102: v2(223.57,113.75) 224.2,114.38 224.2,117.96 223.59,118.56 223.59,119.35 223.08,119.86 223.08,121.86 222.11,122.84 220.14,122.84 218.44,121.14 216.59,121.14 216.14,120.68 214.06,120.68 210.86,123.88 209.71,123.88 207.91,122.07 207.91,120.7 v2(207.84,120.64)
  BOTTOM w0.1: UG9.BF8 v2(223.57,113.75)
  BOTTOM w0.102: RG20.1 207.73,120.46 207.84,120.58 v2(207.84,120.64)
N25867602: length 3.4
  TOP w0.102: RE160.2 203.98,175.44 203.98,174.23 203.24,173.49 QE13.6
N25867965: length 3.3
  TOP w0.102: QE21.6 200.76,173.7 201.18,174.12 201.18,175.45 RE155.2
N25868866: length 5.5
  TOP w0.102: QE22.6 205.71,173.59 206.23,174.11 206.23,176.52 RE157.2 v1(207.02,177.02)
N26209034: length 3.3
  TOP w0.102: v1(305.89,27.64) RE646.2 304.96,27.64 304.63,27.3 304.63,26.92 305.14,26.41 UE5.2
N26229867: length 2.3
  TOP w0.089: v2(205.48,32.07) 205.55,32.07 v1(205.89,31.74)
  TOP w0.381: v2(205.48,32.07) 205.48,32.69 RH598.1
  BOTTOM w0.254: UH1.AF19 205.84,32.44 v2(205.48,32.07) 205.83,31.72 UH1.AF20
N26231028: length 4.2
  BOTTOM w0.089: 219.18,38.92 216.82,38.92 UH1.BG5 ; T146.1 219.18,38.25
  BOTTOM w0.102: 219.18,38.25 219.52,38.59 CH36.1 219.18,38.92
N26232649: length 2.1
  BOTTOM w0.254: UH1.AK22 207.84,30.62 v2(207.84,30.61) 207.84,30.5 UH1.AK23 ; UH1.AJ22 207.38,30.95 v2(207.04,30.61) 207.04,30.53 UH1.AJ23
N26795549: length 3.3
  TOP w0.102: QG512.1 180.82,72.19 180.82,73.65 180.72,73.75 RG575.1 179.68,73.75 v1(179.37,74.06)
N26956296: length 5.7
  BOTTOM w0.102: PR9000.1 29.23,12.92 28.38,13.77 PR9001.1 28.32,14.63 PC9001.1 28.33,14.72 28.85,15.24 28.85,16.77 29.38,17.3 PU9000.3
N26956300: length 1.8
  BOTTOM w0.102: 31.68,16.16 32.43,16.16 v1(33.19,15.4)
N26956432: length 3.8
  BOTTOM w0.102: PC9002.1 28.33,17.52 27.95,17.9 27.95,18.41 v1(28.01,18.47) 28.27,18.72 28.84,18.72 29.86,19.74 PU9000.4
N27252307: length 3.5
  BOTTOM w0.102: RV671.1 236.2,165.6 236.13,165.52 UV3.9 234.87,165.52 v1(233.78,166.61)
N27252308: length 2.4
  BOTTOM w0.102: RV672.1 v1(236.8,163.68) 236.48,163.68 236.38,163.57 UV3.12
N27420614: length 1.9
  TOP w0.089: T147.1 199.65,38.03 v2(200.1,38.03)
  BOTTOM w0.089: UH1.R6 200.45,38.7 200.16,38.41 200.16,38.09 v2(200.1,38.03)
N27472757: length 94.3
  TOP w0.102: v2(204.61,61.01) 205.11,61.01 205.43,60.7 205.43,58.98 208.1,56.32 208.1,55.74 212.63,51.21 v1(213.83,51.21)
  IN4 w0.102: v2(204.61,61.01) 204.61,67.35 207.68,70.42 207.68,102.39 206.27,103.8 196.86,103.8 194.6,106.06 194.6,106.81 192.48,108.94 192.48,112.96 193.51,113.99 195.05,113.99 196.12,115.07 196.71,115.07 196.96,115.32 196.96,116.31 196.02,117.25 196.02,119.1 197.37,120.45 v2(197.95,120.45)
  BOTTOM w0.102: QG510.2 198.88,120.9 198.44,120.45 v2(197.95,120.45) 197.68,120.18 RG1.1
N28080092: length 2.9
  TOP w0.102: v1(273.44,103.2) RG102.2 RG523.2 CG313.1
N28084182: length 3.4
  TOP w0.102: RG524.2 RG103.2 CG314.1 v1(271.15,104.36)
N28087019: length 3.4
  BOTTOM w0.102: CG315.1 264.85,62.44 RG525.2 RG113.2 264.32,64.57 v1(264.83,65.08)
N28087890: length 3.1
  TOP w0.102: RG114.2 RG526.2 CG316.1 v1(274.6,67.14)
N28090623: length 3.2
  TOP w0.102: v1(228.82,65.98) 229.4,65.41 CG317.1 RG124.2 RG527.2
N28092415: length 3.3
  TOP w0.102: v1(231.3,65.22) 230.93,64.85 RG125.2 RG528.2 CG318.1
N28094238: length 3
  BOTTOM w0.102: CG387.1 RG531.2 RG160.2 v1(202.22,87.85)
N28096445: length 2.8
  BOTTOM w0.102: v1(199.11,86.29) CG388.1 RG532.2 RG164.2
N28329347: length 4.4
  BOTTOM w0.102: v1(191.44,85.22) 191.73,85.51 QG8.1
  BOTTOM w0.508: QG8.1 192.03,86.72 193.23,86.72 193.43,86.92 RG156.1
N28330529: length 5.6
  BOTTOM w0.102: RG133.1 v1(230.22,57.29) 230.42,57.09 230.42,53.74 QG4.1
N28331699: length 7.4
  BOTTOM w0.305: QG3.1 283.81,68.74 v1(280.83,68.74) 279.87,68.74 278.82,69.78 RG122.1
N28597766: length 6.3
  TOP w0.203: v2(125.92,148.62) PC532.1 125.92,147.59 126.07,147.44 126.07,147.06 126.04,147.03 126.04,146.62 125.74,146.31 PU500.16
  BOTTOM w0.102: v2(125.92,148.62) 125.57,148.62 125.22,148.97 125.22,150.12 v1(125.61,150.51)
  BOTTOM w0.203: v2(125.92,148.62) 125.92,147.94 PR577.2
N28597770: length 4.2
  TOP w0.203: PU500.15 126.14,146.25 126.37,146.48 126.37,146.92 126.71,147.26 v2(126.83,147.26)
  TOP w0.254: PC530.2 126.97,147.39 v2(126.83,147.26)
  BOTTOM w0.102: v1(126.03,146.69) 126.6,147.26 v2(126.83,147.26)
  BOTTOM w0.203: v2(126.83,147.26) 126.83,147.27 126.87,147.31 126.87,147.76 PR571.2
N28597795: length 3.8
  TOP w0.203: PU500.36 120.76,141.5 120.69,141.43 120.48,141.43 120.22,141.18 120.07,141.18 120.07,141.19 v2(120.06,141.19)
  BOTTOM w0.102: v1(119.41,140.9) 119.71,141.19 v2(120.06,141.19)
  BOTTOM w0.254: v2(120.06,141.19) 120.29,141.43 PC522.1 120.74,140.87 PR538.1
N28597846: length 3.3
  BOTTOM w0.102: PR567.2 153.73,153.47 v1(153.6,153.47)
  BOTTOM w0.254: PH503.1 154.46,152.2 154.47,152.2 ; PR586.1 154.47,152.2 ; 154.47,152.2 PR567.2
N28597859: length 2
  BOTTOM w0.102: PR540.2 v1(117.45,142.83)
  BOTTOM w0.254: PC521.1 PR540.2
N28597868: length 6.3
  TOP w0.254: PR570.1 148.85,151.41 149.12,151.68 149.12,152.04 148.47,152.68 v1(147.65,152.68) 146.85,152.68 v2(146.79,152.75)
  BOTTOM w0.254: v2(146.79,152.75) 146.84,152.7 PH504.1 146.29,151.54 146.29,151.43 146.06,151.2 PR568.2
N28597881: length 3.1
  TOP w0.203: v2(128.2,140.79) 128.08,140.91 127.85,140.91 127.66,141.1 PU500.3
  BOTTOM w0.254: v2(128.2,140.79) 127.71,141.28 PC520.1 127.36,142.07 PR534.1
N28597896: length 4.5
  TOP w0.203: PU500.43 122.94,138.96 122.67,138.69 122.67,138.23 123.2,137.7 v2(123.35,137.7)
  BOTTOM w0.254: PR524.1 124.93,137.19 124.27,137.85 v1(123.88,137.85) 123.5,137.85 123.37,137.71 123.37,137.7 v2(123.35,137.7)
N28598015: length 3.3
  BOTTOM w0.102: 129.74,140.49 v1(130.84,140.49)
  BOTTOM w0.254: PC517.1 129.74,140.49 130.26,141.01 130.26,141.68 130.22,141.72 130.22,141.74 129.73,142.23 PR535.2
N28598023: length 5.9
  TOP w0.254: PC511.1 130.21,136.58 130.79,137.16 v1(130.79,137.81) 130.79,138.28 130.31,138.76 PR525.2 PC512.1 v2(130.39,139.63)
  BOTTOM w0.254: PC512.1 v2(130.39,139.63)
N28598065: length 2.3
  TOP w0.102: PR520.1 v1(130.68,135.72)
  TOP w0.254: PR520.1 v2(129.73,135.06)
  BOTTOM w0.254: v2(129.73,135.06) PR520.1
N28598080: length 27.5
  IN4 w0.254: v2(150.06,133.34) 149.87,133.53 149.42,133.53 148.09,132.2 144.28,132.2 142.2,134.27 141.07,134.27 140.7,134.65 138.69,134.65 130.69,142.65 v2(130.64,142.65)
  BOTTOM w0.102: PR543.2 v1(131.58,143.28)
  BOTTOM w0.254: v2(150.06,133.34) 149.92,133.2 PH501.2 ; PR547.1 PR543.2 v2(130.64,142.65)
N28598124: length 7
  TOP w0.254: PC513.2 119.69,133.73 PR531.1 120.1,133.33 v2(120.4,133.33)
  BOTTOM w0.254: v2(120.4,133.33) 120.05,133.68 v1(120.05,134.97) 120.05,136.93 PC514.2 PR530.2
N28598150: length 4.7
  TOP w0.254: PC500.1 127.09,136.4 v2(127.09,135.97) 127.03,135.92 127.03,135.49 PC503.2
  BOTTOM w0.102: PC503.2 126.83,135.21 126.39,134.76 126.39,134.37 126.69,134.06 v1(126.87,134.06)
  BOTTOM w0.254: PC500.1 127.09,136.4 v2(127.09,135.97) 127.09,135.78 126.83,135.53 PC503.2
N28598222: length 1.9
  TOP w0.102: PC518.1 v1(116.02,133.68)
  TOP w0.254: PR537.2 PC518.1
N28598224: length 3.2
  TOP w0.102: 129.78,140.52 v1(130.73,140.52)
  TOP w0.254: PC516.1 129.78,140.52 130.26,140.99 130.26,141.96 129.98,142.24 PR533.2
N28598271: length 4.6
  TOP w0.102: PR510.2 v1(129.98,134.37)
  TOP w0.254: PR510.2 128.79,134.37 128.61,134.55 128.6,134.55 128.3,134.84 128.3,134.85 127.87,135.28 PC503.1 v2(127.75,135.97) PC508.1
  BOTTOM w0.254: v2(127.75,135.97) PC508.1
N28598352: length 2.9
  TOP w0.203: PU500.27 121.07,146.23 121.12,146.28 v1(121.12,146.77) 121.12,147.19 120.73,147.58 PR545.2
N28598562: length 36
  IN4 w0.254: v2(140.62,134.04) 140.62,133.84 140.27,133.48 137.98,133.48 131.1,140.36 129.55,140.36 128.44,139.25 125.53,139.25 125.38,139.4 125.23,139.4 125.15,139.47 119.87,139.47 119.01,140.34 119.01,145.95 118.67,146.29 v2(118.67,146.97)
  BOTTOM w0.102: v2(118.67,146.97) 118.67,147.12 v1(118.25,147.55)
  BOTTOM w0.254: v2(140.62,134.04) 141.03,134.45 PH502.2 ; PR544.2 PR548.1 118.55,146.85 v2(118.67,146.97)
N28598616: length 74.7
  TOP w0.102: v1(124.84,132.21) 125.23,132.6 v2(125.23,132.77)
  TOP w0.254: PR501.1 125.03,132.97 v2(125.23,132.77)
  IN4 w0.254: v2(185.73,133.36) 185.81,133.44 186.17,133.44 186.42,133.19 186.42,132.67 185.96,132.21 180.04,132.21 178.79,130.97 175.84,130.97 175.23,130.36 162.41,130.36 161.8,130.97 151.8,130.97 151.21,131.56 138.18,131.56 130.59,139.14 130.19,139.14 130.11,139.22 129.8,139.22 129.79,139.22 129.01,139.22 128,138.21 128,136.43 128.28,136.14 128.28,135.79 127.95,135.45 127.95,134.42 127.18,133.65 126.12,133.65 v2(125.23,132.77)
  BOTTOM w0.254: PH500.2 186.38,133.53 185.9,133.53 v2(185.73,133.36)
N28601001: length 3.6
  BOTTOM w0.102: v1(157.58,149.84) 157.81,149.61 157.81,148.16 157.45,147.81 PR563.2
  BOTTOM w0.254: PR563.2 157.34,147.17 157.49,147.02 PU503.1
N28601008: length 2.9
  BOTTOM w0.254: PU503.16 156.4,145.5 156.14,145.75 156.14,147.22 156.47,147.55 PR566.2
N28601054: length 3.6
  BOTTOM w0.254: PR556.2 149.11,150.45 148.57,149.91 148.28,149.91 v1(148.17,149.8) 148.17,149.17 148.62,148.72 148.62,148.72 148.72,148.63 PU502.16
N28601064: length 1.6
  BOTTOM w0.254: PR552.2 149.64,150.81 149.64,150.78 149.49,150.63 149.49,150.63 149.49,150.35 149.69,150.14 PU502.1
N28601070: length 1.1
  BOTTOM w0.102: PC541.2 v1(152.23,153.47)
N28601086: length 1.2
  TOP w0.102: PC548.1 v1(151.68,141.68)
N28601170: length 1.3
  BOTTOM w0.102: v1(162.47,149.62) 162.21,149.37 PR564.1
N28601188: length 1.2
  TOP w0.102: PC556.1 v1(159.51,137.86)
N28601213: length 4.9
  TOP w0.254: v2(150.71,150.6) 150.71,150.73 150.35,151.08 v1(149.89,151.08) 149.46,150.65 149.46,149.83 149.63,149.66 PC540.2
  BOTTOM w0.254: PR553.2 151.01,151.13 150.75,150.87 150.75,150.64 v2(150.71,150.6) 150.71,150.4 150.69,150.38 PU502.3
N28601267: length 3.9
  TOP w0.254: v2(158.59,147.42) 158.59,147.91 v1(158.42,148.09) 158.19,148.31 157.69,148.31 157.34,147.96 PC549.2
  BOTTOM w0.254: PU503.3 158.49,147.33 v2(158.59,147.42) 158.59,147.91 PR5004.2
N28602138: length 2.9
  BOTTOM w0.254: PR576.2 163.79,147.47 163.79,145.71 164.04,145.46 PU504.16
N28602178: length 3.6
  BOTTOM w0.102: PR573.2 165.06,147.76 165.48,148.17 165.48,149.51 v1(165.22,149.76)
  BOTTOM w0.254: PR573.2 164.94,147.31 165.1,147.16 PU504.1
N28602236: length 4.9
  TOP w0.254: PC557.2 167.09,144.87 v1(167.09,145.52) 167.09,145.72 166.16,146.66 166.16,147.34 166.15,147.35 166.15,147.37 v2(166.15,147.37)
  BOTTOM w0.254: PR5020.2 166.15,147.82 v2(166.15,147.37) 166.1,147.31 PU504.3
N28602391: length 1.2
  TOP w0.102: PC564.1 v1(167.02,137.86)
N28602475: length 2.3
  BOTTOM w0.102: v1(178.84,149.53) 178.44,149.14 178.14,149.14 177.36,148.36 PR592.2
N28602493: length 4.8
  TOP w0.254: PC573.2 173.57,146.34 v1(173.57,147.44) 173.91,147.77 174.48,147.77 v2(174.86,147.39)
  BOTTOM w0.254: PU510.3 174.86,147.39 v2(174.86,147.39) 174.86,148.01 PR5024.2
N28602593: length 1.2
  TOP w0.102: PC580.1 v1(176.02,137.86)
N28602604: length 3.1
  BOTTOM w0.102: v1(180.22,149.7) 180.06,149.86 178.61,149.86 178.17,149.43 PR592.1
N28602621: length 4.1
  BOTTOM w0.102: PR591.2 173.81,147.66 174.14,147.98 174.14,149.37 173.78,149.72 v1(173.63,149.72)
  BOTTOM w0.254: PR591.2 173.61,147.59 173.61,147 173.86,146.75 PU510.1
N28602627: length 4.4
  BOTTOM w0.102: PR594.2 172.71,147.66 172.04,148.33 v1(171.71,148.33)
  BOTTOM w0.254: PU510.16 172.88,145.13 172.55,145.46 172.55,145.65 172.55,145.65 172.55,146.01 172.68,146.14 172.68,147.52 PR594.2
N28603914: length 3.5
  BOTTOM w0.254: PR585.2 v1(140.52,150.03) 140.52,149 140.9,148.62 PU507.16
N28603920: length 1.9
  BOTTOM w0.254: PU507.1 142.12,149.82 141.39,150.56 PR590.2
N28603964: length 3.7
  TOP w0.254: PC566.2 141.79,149.61 v1(142.46,150.28) 142.8,150.61 v2(142.86,150.61)
  BOTTOM w0.254: PR5022.2 142.42,151.05 v2(142.86,150.61) 142.86,150.45 143.12,150.18 PU507.3
N28604029: length 2.9
  TOP w0.254: v2(182.23,147.4) 182.24,147.4 182.24,147.04 181.72,146.52 PC588.2
  BOTTOM w0.254: PR5025.2 182.1,147.53 v2(182.23,147.4) 182.23,147.08 182.16,147.01 PU511.3
N28604096: length 3
  BOTTOM w0.254: PR5006.2 180.19,146.87 179.82,146.5 179.82,145.51 180.19,145.14 PU511.16
N28604102: length 1.3
  BOTTOM w0.254: PU511.1 181.16,147 181.06,147.1 PR5001.2
N28604619: length 2.8
  BOTTOM w0.102: PR583.1 145.13,152.62 145.69,153.18 v1(147.35,153.18)
N28604630: length 1.1
  TOP w0.102: PC570.1 v1(144.26,141.62)
N28604706: length 1.3
  TOP w0.102: PC587.1 v1(183.25,136.2)
N29076894: length 4.4
  BOTTOM w0.102: v1(206.78,127.17) 206.82,127.21 RG530.2 207.82,127.21 208.4,126.62 RG540.2 208.87,126.62 209.13,126.37 210.03,126.37 210.27,126.12 QG500.6
N29125650: length 1.6
  BOTTOM w0.102: RG529.1 191.92,115.64 192.16,115.88 UG11.9
N29401212: length 3.8
  TOP w0.102: UE4.24 190.77,23.5 191.08,23.8 191.08,25.34 v1(190.84,25.58) 190.23,26.19 RE32.2
N29401214: length 1.6
  TOP w0.107: UE4.30 187.1,25.38 187.03,25.45 RE37.1
N29700600: length 2.4
  TOP w0.102: v1(188.91,98.07) RG535.2 188.85,99.1 UG24.2 UG24.3
N29702846: length 1
  TOP w0.102: LX8.1 210.68,163.34 RX38.2
N29702855: length 2.8
  TOP w0.102: v1(212.66,164.02) 212.66,163.87 212.76,163.77 212.76,163.26 212.42,162.93 LX7.1 212.03,162.93 RX37.2
N29702861: length 0.9
  TOP w0.102: LX6.1 216,163.27 RX36.2
N29702867: length 1.9
  TOP w0.102: v1(217.37,164.3) 216.78,163.71 RX35.2 216.56,163.26 LX5.1
N29702873: length 0.9
  TOP w0.102: RX34.2 218.26,163.13 LX4.1
N29702889: length 0.9
  TOP w0.102: RX33.2 218.83,163.23 LX3.1
