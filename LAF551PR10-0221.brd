# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_EE_CS_N: length 42.5
  TOP w0.089: 175.44,159.76 176.84,161.16 UT1.AC3
  TOP w0.114: 175.44,159.76 175.1,159.76 174.8,160.06 174.43,160.06 174.39,160.1 174.01,160.1 173.74,159.83 173.74,159.26 v2(173.82,159.19)
  IN3 w0.127: v2(173.82,159.19) 173.59,158.96 173.59,158.78 174.32,158.05 174.32,157.75 175.24,156.83 176.23,156.83 176.7,156.35 176.7,156.2 177.57,155.34 180.52,155.34 180.52,155.34 181.23,155.34 181.95,155.34 181.95,155.35 181.96,155.34 192.88,155.34 193.39,155.86 193.39,156.22 193.79,156.62 194.09,156.62 194.66,157.19 194.66,158.21 v2(194.51,158.37)
  BOTTOM w0.114: RT50.2 188.81,157.71 189.19,158.09 189.19,160.78 189.7,161.3 UT2.1 190.18,161.01 192.59,158.6 193.61,158.6 193.84,158.37 v2(194.51,158.37) 194.9,158.76 194.9,159.08 195.23,159.41 RT100.1
TBT_EE_DI: length 36.7
  TOP w0.089: UT1.AB3 176.6,161.74 176.6,161.18 176.47,161.05
  TOP w0.102: 176.47,161.05 175.43,160.01 175.14,160.01
  TOP w0.114: 175.14,160.01 v2(174.7,160.46)
  IN3 w0.127: v2(193.81,157.29) 193.4,157.29 193.31,157.38 184.83,157.38 183.59,156.14 182.6,156.14 182.28,156.46 182.27,156.46 181.89,156.84 181.89,158.91 181.11,159.69 175.46,159.69 v2(174.7,160.46)
  BOTTOM w0.114: RT98.1 199.32,158.64 199.05,158.36 198.43,158.24 198.21,158.19 197.38,157.84 197.28,157.78 196.97,157.57 196.69,157.38 196.63,157.34 196.6,157.3 196.59,157.3 195.63,156.34 195.41,156.34 194.46,157.29 v2(193.81,157.29) 193.56,157.04 193.56,154.99 193.99,154.56 193.99,154.4 UT2.5
TBT_EE_DO: length 38.6
  TOP w0.089: UT1.AC4 177.3,161.11 176.03,159.85 176.03,159.6 v1(176.01,159.59) 176.01,159.42 175.27,158.68
  TOP w0.114: v2(174.38,158.96) 174.66,158.68 175.27,158.68
  IN3 w0.127: v2(174.38,158.96) 174.38,158.35 174.57,158.16 174.57,157.85 175.34,157.08 176.45,157.08 176.98,156.54 181.11,156.54 181.96,155.69 181.96,155.69 182.03,155.63 192.8,155.63 193.14,155.96 193.14,156.33 193.68,156.87 193.98,156.87 194.23,157.12 194.23,157.93 193.94,158.22 v2(193.94,158.87)
  BOTTOM w0.114: RT49.2 188.12,160.96 188.27,161.12 RT99.1 189.25,161.71 190.1,162.56 190.38,162.56 190.71,162.23 191.34,162.23 191.45,162.12 UT2.2 191.45,160.24 192.82,158.87 v2(193.94,158.87)
TBT_EE_WP_N: length 41.4
  TOP w0.089: UT1.V1 175.49,163.82 174.95,163.28 v2(174.68,163.28)
  IN3 w0.127: v2(174.68,163.28) 174.97,163 174.97,162.19 174.06,161.28 174.06,160.58 173.2,159.72 173.2,158.81 174.06,157.95 174.06,157.64 175.13,156.57 175.55,156.57 176.13,156.57 176.45,156.25 176.45,156.1 177.46,155.09 180.62,155.09 192.98,155.09 193.65,155.75 193.65,156.12 193.89,156.37 194.2,156.37 195.03,157.2 195.03,159.11 194.89,159.25 194.89,159.28 194.65,159.53 194.3,159.53 194.28,159.52 v2(193.94,159.52)
  BOTTOM w0.114: v2(193.94,159.52) 193.02,159.52 192.72,159.82 UT2.3 192.72,161.85 192.1,162.47 191.03,162.47 190.36,163.15 RT48.2
TBT_FORCE_PWR: length 188.1
  TOP w0.107: RT13.2 169.9,163.5 v2(170.49,162.91)
  IN1 w0.089: v2(201.3,23.55) 200.8,23.04 200.8,22.85 200.57,22.63 200,22.63 199.8,22.83 199.8,26.39 199.34,26.85 199.34,29 198.55,29.78 198.55,31.3 198.05,31.8 196.54,31.8 196.25,32.1 196.25,32.73 194.93,34.05 194.93,35.38 193.31,37 192.21,37 192.1,37
  IN1 w0.102: v2(186.71,61.93) 186.22,61.93 185.66,61.37 185.66,56.73 186.24,56.15 186.24,43.19 187.4,42.03 187.4,40.88 187.76,40.52 187.76,39.32 188.95,38.13 189.46,38.13 189.99,37.6 190.07,37.6 190.23,37.44 191.14,37.44 191.58,37 192.1,37
  IN4 w0.102: v2(170.49,162.91) 171.34,162.06 175.61,162.06 177.2,160.47 178.76,160.47 179.08,160.15 182.99,160.15 183.76,159.39 186.25,159.39 186.5,159.14 186.5,158.32 186.93,157.88 188.52,157.88 190.09,156.3 190.09,154.18 191.54,152.73 191.54,150.8 194.35,147.99 195.02,147.32 195.02,129.07 194.4,128.45 194.4,127.65 193.79,127.04 193.79,126.45 188.18,120.84 188.18,116.83 187.02,115.66 187.02,111.41 186.5,110.89 186.5,109.35 185.43,108.28 185.43,100.99 185.47,100.95 185.47,98.09 188.2,95.36 188.2,82.39 187.86,82.05 187.86,78.76 188.42,78.2 188.42,70.76 189.69,69.49 189.69,65.75 186.75,62.81 186.75,61.96 v2(186.71,61.93)
  BOTTOM w0.089: v2(201.3,23.55) 201.45,23.4 203.25,23.4 203.34,23.31 203.34,23.12 203.34,23.12 203.34,22.88 203.34,22.88 203.34,22.66 204.03,21.96 204.73,21.96 204.92,21.77 204.92,19.93 204.61,19.61 204.2,19.61 204.19,19.62 203.89,19.62 203.88,19.61 203.84,19.61 203.73,19.5 203.73,19.44 203.59,19.3 203.59,19.07 203.17,18.65 UH1.Y47
  BOTTOM w0.102: v2(186.71,61.93) v1(187.26,61.93)
TBT_FORCE_PWR_R: length 13.4
  TOP w0.102: v1(168.46,164.23) 168.45,164.25 168.61,164.63 v2(168.77,164.79) ; UT1.H4 v2(177.4,168.86)
  TOP w0.107: RT13.1 RT35.1 169.21,164.79 v2(168.77,164.79)
  IN1 w0.102: v2(177.4,168.86) 176.68,168.86 176.44,168.61 173.37,168.61 171.01,166.25 171.01,165.98 170.7,165.66 170.15,165.66 169.27,164.79 v2(168.77,164.79)
  BOTTOM w0.107: RT94.2 169.15,164.79 v2(168.77,164.79)
TBT_HDMI_DDC_CLK: length 3
  TOP w0.089: UT1.Y2 176.15,163.13 175.77,163.13 175.76,163.12 175.54,163.12 174.57,162.14 174.49,162.14 174.39,162.04
  TOP w0.102: 174.39,162.04 174.3,161.95 T9.1
TBT_HDMI_DDC_DATA: length 4.7
  TOP w0.089: UT1.Y1 175.57,162.9 174.6,161.93
  TOP w0.127: T7.1 172.14,161.61 174.28,161.61 174.6,161.93
TBT_HOLD_N: length 3
  BOTTOM w0.102: UT2.7 191.45,153.09 191.6,152.94 RT51.2 192.13,152.2 v1(192.54,151.79)
TBT_I2C_SCL: length 43.8
  TOP w0.089: 174.39,165.12 v2(174.99,164.51) 175,164.5 176.16,164.5 UT1.U2
  TOP w0.114: 174.39,165.12 174.38,165.12 RT27.2
  IN3 w0.127: v2(196.93,163.3) 196.66,163.3 196.46,163.5 196.46,164.65 198.13,166.32 198.13,168.75 196.23,170.65 193.77,170.65 193.3,170.18 191.45,170.18 190.91,169.65 190.91,169.09 190.67,168.85 190.52,168.85 190.1,168.43 189.78,168.43 189.34,168.86 188.65,168.86 187.84,168.05 187.84,165.64 183.72,161.52 179.54,161.52 179.04,161.03 176.37,161.03 175.55,161.85 175.55,163.46 175.03,163.98 175.03,164.21 174.97,164.27 174.99,164.29 v2(174.99,164.51)
  BOTTOM w0.076: v2(196.93,163.3) 197.16,163.3 197.38,163.51 197.94,163.52 198.04,163.62 198.41,163.62 UT4.D2
TBT_I2C_SDA: length 43.2
  TOP w0.089: 174.39,164.16 174.51,164.04 v2(174.61,164.04)
  TOP w0.114: v2(174.61,164.04) 174.67,164.04 174.72,163.99 175.13,163.99 175.38,164.23 175.49,164.23 175.54,164.28 UT1.U1 ; 174.39,164.16 174.39,164.32 174.16,164.55 RT26.2
  IN3 w0.127: v2(174.61,164.04) 175.29,163.35 175.29,161.74 176.26,160.77 179.15,160.77 179.64,161.26 183.83,161.26 188.1,165.54 188.1,167.95 188.76,168.61 189.24,168.61 189.67,168.18 190.21,168.18 190.62,168.59 190.77,168.59 191.16,168.99 191.16,169.54 191.55,169.93 193.4,169.93 193.87,170.4 196.12,170.4 197.87,168.65 197.87,166.42 196.2,164.75 196.2,163.4 196.68,162.92 v2(196.68,162.74)
  BOTTOM w0.076: v2(196.68,162.74) 196.69,162.74 196.69,162.73 196.81,162.84 197.09,162.84 197.56,163.31 198.02,163.31 198.07,163.37 UT4.D1
TBT_PCIE_WAKE#: length 286.9
  TOP w0.102: UE5.70 295.14,10.89 295.38,11.13 295.38,13.8 295.03,14.15 295.03,16.88 295.73,17.58 v2(295.73,19.23)
  TOP w0.107: RT10.2 171.97,163.3 v2(171.76,163.1)
  IN4 w0.089: 219.18,41.67 215.87,41.67 215.47,41.27 211.8,41.27 210.77,42.31 210.77,43.68 210.56,43.88
  IN4 w0.102: 210.56,43.88 209.05,45.4 208.66,45.4 207.97,46.08 203.24,46.08 193.13,56.19 189.81,56.19 188.5,57.5 187.12,57.5 186.54,58.08 186.54,61.03 187.46,61.95 187.46,63.2 190.76,66.49 190.76,68.75 188.65,70.86 188.65,78.29 188.09,78.85 188.09,81.96 188.29,82.16 188.43,82.29 188.43,82.29 188.75,82.61 188.75,87.34 188.43,87.66 188.43,95.46 185.73,98.15 185.73,108.26 186.73,109.26 186.73,110.8 187.24,111.31 187.24,115.57 188.28,116.6 188.41,116.74 188.41,120.75 194.01,126.35 194.01,126.95 194.62,127.56 194.62,128.35 195.25,128.98 195.25,147.41 194.45,148.22 191.77,150.9 191.77,152.82 190.32,154.27 190.32,156.4 188.61,158.11 187.03,158.11 186.72,158.41 186.72,159.24 186.35,159.61 183.85,159.61 183.09,160.38 179.17,160.38 178.86,160.7 177.29,160.7 175.71,162.28 172.58,162.28 v2(171.76,163.1) ; 219.18,41.67 222.4,41.67 223.35,41.67 224.42,40.61 226.72,40.61 227.1,40.99 229.09,40.99 229.94,41.84 232.16,41.84 234.04,39.96 235.44,39.96 236.79,38.61 238.45,38.61 241,36.06 241.56,36.06 242.71,34.92 242.71,33.36 242.36,33.02 242.36,31.94 243.14,31.17 246.85,31.17 248.67,29.34 248.67,28.21 249.13,27.75 251.34,27.75 252.29,28.71 256.42,28.71 257.81,27.32 260.13,27.32 260.73,26.73 264.12,26.73 265.11,27.71 266,27.71 269.01,30.72 274.8,30.72 276.55,32.48 283.47,32.48 284.63,31.33 291.82,31.33 292.74,32.25 v2(295.86,32.25)
  BOTTOM w0.102: v2(171.76,163.1) 171.22,163.1 v1(171.2,163.08) ; v2(295.86,32.25) 295.86,30.79 294.59,29.52 294.59,20.37 v2(295.73,19.23)
TBT_PCIE_WAKE_N: length 5.7
  TOP w0.089: UT1.W1 175.53,163.36 174.5,162.33 174.39,162.33
  TOP w0.102: 174.39,162.33 174.35,162.33 ; RT28.2 172.31,162.71 RT10.1 171.95,162.71 171.93,162.69 171.4,162.69 v1(171.07,163.02)
  TOP w0.127: RT28.2 172.88,162.59 173.14,162.33 174.35,162.33
TBT_RBIAS: length 1.2
  TOP w0.089: v2(178.71,168.85) 178.7,168.85 UT1.H6
  BOTTOM w0.127: RT25.1 179.22,168.85 v2(178.71,168.85)
TBT_RESET_N: length 48.4
  TOP w0.089: v2(177.4,169.49) 177.38,169.49 177.08,169.19 UT1.F4
  TOP w0.107: v2(170.51,166.07) 170.33,165.89 RT23.1
  IN1 w0.102: v2(177.4,169.49) 176.87,169.49 176.22,168.84 173.28,168.84 v2(170.51,166.07)
  IN3 w0.102: v2(177.4,169.49) 177.81,169.89 177.81,170.99 178.69,171.87 178.69,173.35 179.14,173.79 180.35,173.79 180.54,173.98 180.91,173.98 181.5,173.4 187.28,173.4 188.67,172.01 190.74,172.01 191.02,172.29 192.71,172.29 192.96,172.04 198.93,172.04 201.19,169.78 203.47,169.78 204.76,168.49 204.76,167.05 v2(206.74,165.07)
  BOTTOM w0.102: v2(206.74,165.07) 206.71,165.09 RT102.2 ; RT80.1 177.38,169.46 v2(177.4,169.49)
TBT_RESET_N_EC: length 280.3
  TOP w0.102: v2(297.07,30.79) v1(297.47,30.39) 298.15,29.71 298.88,29.71 299.61,28.98 299.61,27.45 300.02,27.04 300.02,26.57 299.94,26.49 UE5.15
  TOP w0.107: v2(168.63,165.92) 168.75,165.92 168.78,165.89 RT23.2
  IN4 w0.089: 199.59,45.14 200.07,44.66 200.64,44.66
  IN4 w0.102: v2(168.63,165.92) 168.15,165.92 167.71,165.47 167.71,165.47 167.7,165.46 167.7,161.21 167.12,160.62 167.12,160.01 168.2,158.92 172.16,158.92 172.86,158.22 175.2,158.22 176.02,159.04 178.44,159.04 180.15,157.33 180.54,157.33 182.42,155.45 184.95,155.45 185.38,155.02 186.55,155.02 190.39,151.17 190.39,150.63 194.11,146.92 194.11,129.78 193.46,129.12 193.46,128.33 192.64,127.52 192.64,126.92 187.04,121.32 187.04,117.3 185.87,116.14 185.87,111.88 185.36,111.37 185.36,109.83 184.5,108.97 184.5,105.74 184.16,105.4 184.16,97.56 187.28,94.44 187.28,83.09 186.72,82.53 186.72,78.28 187.28,77.72 187.28,70.13 187.81,69.6 187.81,65.93 186.13,64.26 186.13,64.03 185.84,63.74 185.84,62.81 185.62,62.6 185.62,57.57 186.73,56.46 186.73,55.66 187.17,55.22 192.7,55.22 198.17,49.75 198.17,46.05 199.08,45.14 199.59,45.14 ; 200.64,44.66 200.83,44.66 201.55,43.95 205.02,43.95 205.26,44.18 207.23,44.18 208.1,43.31 208.1,41.84 208.61,41.33 210.1,41.33 210.91,40.51 213.65,40.51 213.96,40.21 218.64,40.21 219.2,40.76 222.78,40.76 222.97,40.76 222.97,40.76 224.04,39.69 227.1,39.69 227.48,40.07 229.52,40.07 230.25,40.81 230.31,40.81 231.76,40.81 233.53,39.04 235.06,39.04 236.41,37.7 238.07,37.7 240.88,34.89 240.88,31.74 242.87,29.74 242.87,28.14 243.4,27.61 246.62,27.61 247.7,26.52 255.85,26.52 257.09,25.29 257.09,25.26 258.13,24.22 260.26,24.22 261.84,25.81 264.6,25.81 264.9,26.11 265.69,26.11 269.38,29.81 275.18,29.81 276.19,30.83 283.83,30.83 284.25,30.41 296.7,30.41 v2(297.07,30.79)
TBT_RSENSE: length 1.2
  TOP w0.102: UT1.J6 v2(178.71,168.21)
  BOTTOM w0.127: v2(178.71,168.21) 179.21,168.21 RT25.2
TBT_RST#_R: length 1.4
  TOP w0.089: UT1.L4 v2(177.4,167.56)
  BOTTOM w0.114: RT1.2 176.93,167.08 v2(177.4,167.56)
TBT_SRC_CFG1: length 3.6
  TOP w0.089: UT1.AA1 175.39,162.44 174.45,161.5 174.45,161.44
  TOP w0.127: 174.45,161.44 174.22,161.22 v1(173.81,161.22) 173.1,161.22 RT11.1
TBT_SRC_HPD: length 3.9
  TOP w0.102: UT1.G1 175.69,168.88 175.28,168.47 174.73,168.47 v1(174.41,168.14) 174.41,167.25 174.52,167.14 174.52,166.69 RT4.1
TBT_SVR_IND:
  vias: v1(169.74,170.93) v2(170.44,171.31) v2(170.51,170.42)
TBT_TCK: length 24.9
  TOP w0.102: UT1.T4 v2(177.4,164.96)
  TOP w0.114: v2(171.14,158.13) 171.14,158.6 v1(171.67,159.13)
  IN3 w0.127: v2(177.4,164.96) 177.4,165.01 175.97,166.45 173.45,166.45 171.14,164.14 v2(171.14,158.13)
  BOTTOM w0.114: RT7.2 175.65,162.62 175.98,162.29 175.98,159.85 174.65,158.52 171.53,158.52 v2(171.14,158.13)
TBT_TDI: length 10
  TOP w0.089: UT1.Y4 v2(177.4,163)
  BOTTOM w0.107: RT9.2 173.79,156.48 v1(174.99,157.68) 177.3,159.99 177.3,162.9 v2(177.4,163.01)
TBT_TDO: length 8.3
  TOP w0.102: UT1.W4 177.39,163.64 v2(177.41,163.64)
  BOTTOM w0.107: v2(177.41,163.64) 177.39,163.64 176.98,163.23 176.98,160.16 v1(176.4,159.57) 174.84,158.02 RT6.2
TBT_TEST_EN: length 4.8
  TOP w0.089: UT1.E1 175.47,169.8
  TOP w0.102: 175.47,169.8 175.3,169.8 174.9,169.4 v1(173.68,169.4) 173.53,169.4 172.34,168.2 RT17.1
TBT_TEST_PWG: length 2.7
  TOP w0.102: UT1.AB5 177.99,161.75 177.99,161.69 177.99,161.23 177.29,160.53 177.29,160.28 RT18.1
TBT_TMS: length 2.7
  TOP w0.102: v2(177.4,164.29) 177.39,164.29 177.08,163.98 UT1.V4
  BOTTOM w0.102: v2(177.4,164.29) 177.4,164.24 176.91,163.75 176.7,163.75 RT8.2 v1(176.48,162.53)
TBT_TMU_CLK_OUT: length 3.3
  TOP w0.089: UT1.V2 176.16,164.04 175.46,164.04 175.06,163.64 174.39,163.64 174.39,163.65
  TOP w0.102: 174.39,163.65 174.38,163.66 T2.1 174.07,163.89 173.92,163.89 173.9,163.91 RT34.1
TBT_XTAL_25_IN: length 6.2
  TOP w0.089: UT1.D22 185.81,170.49 186.22,170.49 186.95,171.22 v2(186.95,171.3)
  BOTTOM w0.114: v2(186.95,171.3) 187.11,171.3 187.51,170.9 187.51,169.86 187.98,169.39 v1(187.98,168.68) 187.98,167.82 RT116.1
TBT_XTAL_25_OUT: length 5.8
  TOP w0.089: UT1.D23 186.24,170.26 186.72,170.74 186.93,170.74 186.95,170.72 186.95,170.71 v2(186.95,170.71)
  BOTTOM w0.114: RT117.1 187.6,166.98 187.48,167.1 187.48,169.19 187.01,169.66 187.01,170.66 v2(186.95,170.71)
TBTA_DEBUG1: length 2.6
  BOTTOM w0.102: UT4.L2 198.66,166.97 198.65,166.98 198.65,167.55 198.36,167.85 v1(198.36,168.23) 198.36,168.5
  BOTTOM w0.107: RT71.1 198.39,169.03 198.39,168.97 198.36,168.94 198.36,168.5
TBTA_DEBUG2: length 3.1
  BOTTOM w0.076: 198.07,168.46 198.07,167.86 198.41,167.52 198.41,166.87 198.41,166.68 198.66,166.43 UT4.K2
  BOTTOM w0.102: RT72.1 198.07,169.19 198.07,168.46
TBTA_DIG_AUD_N: length 3.2
  BOTTOM w0.076: 199,168.46 198.99,168.45 198.99,168.43 198.79,168.23 198.79,167.81 198.83,167.77 198.83,167.05 198.91,166.97 198.91,166.76 198.91,166.69 199.16,166.44 UT4.K3
  BOTTOM w0.089: 199,168.46 199.08,168.54 199.08,168.77 199.22,168.91 199.22,169.18 RT69.1
TBTA_DIG_AUD_P: length 2.8
  BOTTOM w0.076: 199.13,168.33 199.13,168.33 199.12,168.31 199.11,168.31 198.95,168.16 198.95,167.88 198.99,167.84 198.99,167.12 199.16,166.95 UT4.L3
  BOTTOM w0.089: 199.13,168.33 199.2,168.4 199.22,168.4 199.28,168.45 199.28,168.47 199.34,168.53 199.34,168.73 199.72,169.1 RT68.1
TBTA_HPD: length 63.9
  TOP w0.102: v2(177.4,166.91) UT1.M4 ; v2(202.21,161.2) v1(202.21,160.4)
  TOP w0.107: v2(168.18,164.71) 168.18,164.78 168.6,165.19 169.25,165.19 RT41.1
  IN1 w0.102: v2(168.18,164.71) 168.18,164.66 168.25,164.59 168.25,164.49 168.63,164.11 171.56,164.11 173.92,166.47 174.43,166.47 174.75,166.79 176.14,166.79 176.26,166.91 v2(177.4,166.91)
  IN3 w0.102: v2(202.21,161.2) 202.21,161.22 203.54,162.55 204.11,162.55 206.22,164.66 206.91,164.66 207.15,164.9 207.15,165.23 204.99,167.39 204.99,168.58 203.56,170.01 201.28,170.01 200.33,170.96 199.02,172.27 197.81,172.27 197.81,172.27 197.62,172.27 193.06,172.27 192.72,172.61 191.01,172.61 190.64,172.24 188.76,172.24 187.38,173.63 181.59,173.63 181.01,174.21 180.44,174.21 180.25,174.02 178.67,174.02 178.46,173.81 178.46,173.62 178.46,173.62 178.46,173.44 178.46,173.44 178.46,173.25 178.46,173.25 178.46,171.97 176.28,169.79 176.28,168.03 v2(177.4,166.91)
  BOTTOM w0.076: v2(202.21,161.2) 202.21,161.38 202.41,161.58 202.41,162.52 202.66,162.77 UT4.C10
TBTA_I2C_INT: length 54.6
  TOP w0.102: v2(177.4,168.21) UT1.J4
  TOP w0.114: RT32.2 169.29,166.5 v2(168.68,166.5)
  IN1 w0.081: v2(177.4,168.21) 177.87,168.67 177.87,170.3 177.61,170.56 176.81,170.56 175.9,169.65 170.71,169.65 169.32,168.27 168.79,168.27 168.33,167.81 168.33,166.84 v2(168.68,166.5)
  IN3 w0.127: v2(196.22,161.27) 196.22,161.32 198.29,163.38 198.29,165.76 198.83,166.3 198.83,169.31 197.81,170.33 197.81,171.27 197.29,171.8 193.29,171.8 192.82,171.33 191.49,171.33 191.1,171.71 188.55,171.71 187.16,173.1 183.57,173.1 183.12,172.65 183.12,172.19 182.64,171.71 179.41,171.71 178.13,170.42 178.13,168.93 v2(177.4,168.21)
  BOTTOM w0.107: UT4.C1 197.6,162.87 196.99,162.25 196.99,162.07 196.68,161.77
  BOTTOM w0.114: 196.68,161.77 196.22,161.31 v2(196.22,161.27)
TBTA_I2C_SCL1_R: length 12.4
  IN6 w0.081: v2(205.46,155.31) 205.26,155.51 205.26,156.98 202.03,160.22 200.56,160.22 v2(200.4,160.37)
  BOTTOM w0.076: 199.91,162.16 199.91,161.39
  BOTTOM w0.089: 199.91,162.16 200.12,162.37 UT4.B5
  BOTTOM w0.114: RT60.2 205.54,154.65 205.29,154.9 205.29,155.15 v2(205.46,155.31) 205.31,155.46 205.31,155.63 205.56,155.88 RT57.2 ; v2(200.4,160.37) 200.4,160.93 199.91,161.39
TBTA_I2C_SDA1_R: length 12.3
  IN6 w0.081: v2(204.86,155.31) 205.05,155.51 205.05,156.9 201.94,160.01 200.64,160.01 v2(200.41,159.78)
  BOTTOM w0.114: v2(200.41,159.78) 200.81,160.19 200.81,160.82 200.16,161.47 UT4.A5 ; RT58.2 204.86,155.88 205.06,155.68 205.06,155.52 v2(204.86,155.31) 205.05,155.12 205.05,154.87 204.83,154.65 RT59.2
TBTA_LDO_BMC: length 2.8
  BOTTOM w0.203: UT4.E1 197.96,163.87 197.83,163.74 197.14,163.74 197.12,163.76 196.76,163.76 196.06,163.06 195.79,163.06 CT98.1
TBTA_LSRX: length 31.5
  TOP w0.089: v2(176.91,172.52) 177.05,172.38 177.05,172.01 177.3,171.76 UT1.A4
  IN1 w0.089: v2(199.34,168) 199.34,167.76 199.25,167.68 198.68,167.68 196.7,169.66 196.7,169.66 196.11,170.25 196.1,170.25 195.77,170.58 191.01,170.58 190.33,171.26 189.11,171.26 188.66,171.71 187.38,172.99 184.92,172.99 184.48,173.44 181.85,173.44 181.28,174 178.34,174 178.06,173.73 177.62,173.73 176.91,173.02 v2(176.91,172.52)
  BOTTOM w0.076: UT4.K4 199.41,166.62 199.41,167.1 199.23,167.27 199.23,167.9 v2(199.34,168)
  BOTTOM w0.089: RT42.1 177.71,174.04 176.91,173.24 v1(176.91,173.14) v2(176.91,172.52)
TBTA_LSTX: length 28.2
  TOP w0.089: UT1.A5 177.76,172.49 v2(178.02,172.75) 178.13,172.86 178.13,173.63 RT40.1
  IN1 w0.089: v2(199.66,167.48) 198.59,167.48 196.5,169.57 196.5,169.58 196.03,170.05 196.02,170.05 195.69,170.38 190.93,170.38 190.25,171.06 189.03,171.06 188.58,171.51 187.3,172.79 184.84,172.79 184.39,173.24 181.68,173.24 181.38,173.54 v2(180.73,173.54) 180.6,173.66 178.93,173.66 v2(178.02,172.75)
  BOTTOM w0.089: RT21.2 180.67,173.6 v2(180.73,173.54)
  BOTTOM w0.102: UT4.L4 v2(199.66,167.48)
TBTA_MRESET: length 2.4
  BOTTOM w0.076: 203.77,163.86 203.76,163.87 UT4.E11
  BOTTOM w0.107: 203.77,163.86 205.1,163.86 205.42,164.18 RT63.1
TBTA_ROSC: length 7.3
  BOTTOM w0.076: UT4.G2 198.4,165.12 198.26,165.12 198.26,165.12 198.05,165.12 198.05,165.12 197.77,165.12 197.67,165.21 197.67,165.21 197.54,165.34 196.92,165.34
  BOTTOM w0.127: 196.92,165.34 196.8,165.46 196.03,165.46 195.46,166.03 195.46,168.79 196,169.32 RT75.1
TBTB_I2C_INT: length 5.8
  TOP w0.089: UT1.E2 176.14,169.56 175.68,169.56 175.65,169.53
  TOP w0.114: 175.65,169.53 175.37,169.53 174.99,169.16 173.92,169.16 173.82,169.06 173.56,169.06 172.84,168.34 v1(172.84,168.04) 172.24,167.44 RT33.2
TOBII_INT#: length 334.8
  TOP w0.102: RE651.2 323.91,16.67 v1(323.91,19.59) 323.91,20.87 v2(324.18,21.14) ; RE300.1 v2(158.23,166.36) 158.56,166.69 JTOBII.6
  IN2 w0.102: v2(287.94,25.61) 288.5,25.61 291.6,22.51 297.04,22.51 297.66,23.13 298.38,23.13 299.09,22.43 300.94,22.43 301.06,22.54 301.11,22.54 302.44,23.88 302.51,23.88 306.14,23.88 307.14,24.88 308.3,24.88 308.96,25.54 308.96,27 309.49,27.54 310.64,27.54 311.9,28.79 318.42,28.79 320.49,26.73 323.63,26.73 325.05,25.3 325.05,23.47 324.15,22.57 324.15,21.16 v2(324.18,21.14)
  IN4 w0.089: 195.21,42.38 194.05,43.54
  IN4 w0.102: v2(287.94,25.61) 287.87,25.68 285.02,25.68 284.62,25.29 283.1,25.29 282.36,24.54 270.51,24.54 270.51,24.54 269.94,24.54 269.7,24.54 268.41,23.24 266.16,23.24 265.89,22.96 265.87,22.96 265.63,22.72 265.44,22.72 265.15,22.72 264.12,21.69 258.1,21.69 257.93,21.86 255.28,21.86 253.61,20.18 251.27,20.18 247.7,23.76 247.3,24.16 246.73,24.16 245.66,25.23 239.89,25.23 239.89,25.23 239.7,25.23 238.94,25.23 238.72,25.01 237.67,25.01 236.93,25.75 236.93,25.97 236.79,26.1 236.66,26.24 235.66,27.24 235.66,30.6 233.34,32.91 233.34,32.93 232.37,33.9 232.37,36.34 232.23,36.48 232.23,36.48 230.8,37.91 228.37,37.91 227.6,37.14 226.4,37.14 226.28,37.01 224.34,37.01 222.99,35.66 220.04,35.66 219.23,36.48 214.36,36.48 214.05,36.17 213.47,36.17 213.36,36.06 212.76,36.06 211.52,37.31 211.52,38.3 211.3,38.52 211.3,38.53 209.63,40.2 204.3,40.2 204.07,40.44 202.85,40.44 202.6,40.69 200.53,40.69 200.18,41.04 198.62,41.04 197.28,42.38 195.21,42.38 ; 194.05,43.54 190.88,43.54 188.86,45.56 188.57,45.56 188.07,46.06 188.07,46.35 187.95,46.47 187.82,46.6 187.82,52.26 187.01,53.07 187.01,53.66 185.59,55.07 185.59,55.43 185.57,55.45 185.07,55.95 185.07,56.5 184.48,57.1 184.48,62.06 184.32,62.22 183.93,62.61 183.88,62.66 183.88,63.81 184.32,64.26 184.32,69.21 184.03,69.5 184.03,70.03 185.31,71.31 185.31,76.33 184.79,76.85 184.79,83.79 185.57,84.57 185.57,88.65 186.05,89.13 186.05,94.05 182.06,98.04 182.06,100.89 182.32,101.15 182.32,107.2 183.18,108.06 183.18,109.34 183.68,109.84 183.68,115.14 184.49,115.95 184.49,120.38 191.5,127.39 191.5,127.99 192.31,128.8 192.31,129.62 192.97,130.27 192.97,136.08 192.19,136.87 192.19,138.15 192.82,138.78 192.82,142.28 192.04,143.06 191.91,143.19 191.91,147.51 189.34,150.07 189.02,150.07 185.21,153.87 184.91,153.87 184.48,154.31 181.62,154.31 180.97,154.96 172.25,154.96 171.59,155.62 169.34,155.62 168.38,156.58 168.38,156.8 165.71,159.48 165.71,161.64 164.85,162.49 164.85,166.16 162.86,168.15 159.15,168.15 158.23,167.22 v2(158.23,166.36)
TOBII_PWR_EN#: length 377.6
  TOP w0.102: CE79.1 144.8,167.95 144.45,167.6 RE652.2 144.51,167.25 UE12.4 146.44,167.25 146.82,166.87 146.82,163.98 147.43,163.37 v2(147.43,163.29) ; v2(329.87,48) 329.95,48 330.4,47.55 330.4,47.17 330.54,47.03 UE6.17
  IN3 w0.102: v2(329.87,48) 329.46,47.59 329.46,42.28 328.66,41.48 328.66,39.07 327.25,37.67 327.25,34.88 323.41,31.04 323.41,27.67 323.04,27.3 323.04,26.74 323.95,25.84 324.52,25.84 325.05,25.3 325.05,23.37 324.21,22.53 323.18,22.53 322.75,22.1 322.75,21.48 323.24,21 323.24,19.81 322.46,19.03 320.07,19.03 317.75,16.71 317.75,16.3 317.19,15.74 v2(317.19,15.48)
  IN4 w0.089: 194.2,38.93 194.54,39.26 194.54,39.64 195.69,40.8 196.76,40.8 197.94,39.61 198.95,39.61
  IN4 w0.102: v2(317.19,15.48) 316.72,15.95 313.48,15.95 312.3,17.14 308.97,17.14 308.58,16.74 306.33,16.74 306.06,16.48 305.72,16.48 305.71,16.49 305.1,16.49 304.76,16.82 304.75,16.82 303.92,17.64 303.92,19.29 303.09,20.12 302.52,20.12 301.63,19.23 298.46,19.23 297.76,19.93 293.82,19.93 292.46,21.29 272.69,21.29 272.53,21.45 267.44,21.45 266.8,20.81 266.42,20.81 265.6,20.81 264.89,20.09 258.24,20.09 257.22,19.08 254.77,19.08 254.22,18.53 248.66,18.53 248.35,18.22 246.37,18.22 246.19,18.4 246.05,18.53 243.48,18.53 241.05,20.96 241.05,21.39 240.42,22.03 237.03,22.03 236.01,23.04 234.32,23.04 232.39,24.97 232.39,25.61 231.71,26.3 231.71,32.3 230.77,33.24 230.77,33.51 229.77,34.51 229.77,34.51 229.45,34.83 228.87,34.83 228.7,34.83 228.2,35.33 226.86,35.33 225.59,34.06 223.62,34.06 222.42,32.86 219.75,32.86 219.6,33.01 218.55,33.01 218.38,33.18 218.06,33.5 217.61,33.5 217.56,33.46 213.6,33.46 213.25,33.11 212.9,33.11 212.23,32.44 208.36,32.44 207.93,32.87 207.4,32.87 206.63,33.64 205.96,33.64 205.64,33.96 202.11,33.96 201.75,34.33 201.75,34.49 201.75,34.79 201.43,35.1 201.31,35.1 200.73,35.68 200.73,36.76 199.59,37.9 199.59,38.98 198.95,39.61 ; 194.2,38.93 190.62,38.93 190.36,39.19 190.36,40.06 190.76,40.47 190.76,40.88 185.66,45.99 185.66,50.31 182.95,53.01 182.95,56.36 182.06,57.25 182.06,60.51 181.71,60.86 181.71,65.8 181.49,66.02 181.49,69.7 182.43,70.64 182.43,70.69 182.99,71.25 182.99,71.71 183.6,72.32 183.6,75.64 183.32,75.92 181.21,75.92 180.88,76.25 180.88,85.29 178.27,87.9 178.09,88.08 178.09,93.6 180.46,95.98 180.46,107.86 181.58,108.98 181.58,110.23 182.03,110.67 182.03,112.62 181.8,112.84 181.49,113.15 181.49,116.73 182.89,118.13 182.89,121.05 189.87,128.03 189.87,128.63 190.59,129.34 190.59,137.99 190.13,138.45 190.13,143.49 190.31,143.66 190.31,146.84 188.68,148.47 188.35,148.47 185.64,151.18 173.76,151.18 172.52,152.43 170.92,154.02 168.68,154.02 167.31,155.4 165.41,155.4 164.11,156.7 164.11,160.23 163.11,161.23 161.99,161.23 161.96,161.26 158.55,161.26 158.18,160.89 156.25,160.89 155.64,161.5 153.07,161.5 151.8,162.77 150.1,162.77 149.57,163.3 147.43,163.3 v2(147.43,163.29)
TON_1.2V: length 1.9
  BOTTOM w0.203: PR206.2 94.89,45.4 PU201.9
TP_CLK: length 141.6
  TOP w0.102: UE5.87 301.94,8.62 301.94,8.46 v2(301.94,8.46) 302.1,8.29 302.1,7.79 RE100.2
  IN1 w0.102: v2(192.17,10.15) 192.17,9.51 192.39,9.29 203.99,9.29 204.32,9.62 225.66,9.62 225.87,9.83 229.83,9.83 230.95,10.95 239.2,10.95 240.69,12.44 251.27,12.44 252.79,13.96 255,13.96 256.82,12.14 271.98,12.14 272.56,12.72 280.35,12.72 283.24,15.61 290.77,15.61 292.58,13.81 295.12,13.81 295.79,13.13 295.79,12.37 299.18,8.98 300.53,8.98 301.6,7.92 301.84,7.92 301.94,8.02 v2(301.94,8.46)
  BOTTOM w0.102: v2(192.17,10.15) 192.04,10.28 192.05,10.29 192.05,10.62 191.8,10.87 191.27,10.87 190.94,10.54 190.94,8.63 192.56,7.01 203.54,7.01 203.78,7.25 v4(203.78,8.02) 203.78,8.52 203.54,8.75 RE654.1
TP_CLK_R: length 13.4
  BOTTOM w0.102: RE654.2 201.06,8.33 200.76,8.33 200.6,8.17 197.47,8.17 194.97,10.67 193.74,10.67 192.98,11.43 191.32,11.43 191.05,11.71 191.05,12.08 191.32,12.35 JTP.12
TP_DATA: length 141.6
  TOP w0.102: RE101.2 302.33,7.82 302.33,8.27 v2(302.52,8.46) 302.36,8.62 302.35,8.62 302.35,8.63 302.17,8.8 302.17,9.03 302.34,9.2 UE5.88
  IN1 w0.102: v2(191.59,10.15) 191.94,9.8 191.94,9.42 192.3,9.06 204.09,9.06 204.42,9.39 225.75,9.39 225.97,9.6 229.93,9.6 231.05,10.72 239.29,10.72 240.79,12.21 251.37,12.21 252.88,13.73 254.91,13.73 256.72,11.91 272.08,11.91 272.65,12.49 280.44,12.49 283.34,15.38 290.68,15.38 292.48,13.58 295.02,13.58 295.56,13.04 295.56,12.28 299.09,8.75 300.44,8.75 301.51,7.69 301.93,7.69 302.17,7.92 302.17,8.1 v2(302.52,8.46)
  BOTTOM w0.102: v2(191.59,10.15) 191.82,10.38 191.82,10.53 191.7,10.65 191.37,10.65 191.17,10.45 191.17,8.73 192.66,7.24 203.45,7.24 203.55,7.34 203.55,8.42 203.45,8.53 203.12,8.53 203.02,8.42 203.02,7.97 202.92,7.86 RE655.1
TP_DATA_R: length 13.6
  BOTTOM w0.102: RE655.2 201.24,8.11 200.86,8.11 200.69,7.94 v4(200.28,7.94) 197.38,7.94 194.88,10.44 193.65,10.44 192.88,11.2 191.23,11.2 190.82,11.61 JTP.13
TP_EN: length 211.8
  TOP w0.102: UE10.21 314.66,59.81 v2(314.46,59.62) ; UT5.3 v2(196.68,9.94) ; v2(185.4,6.07) 185.15,6.33 v1(185.15,8.49) 185.15,9.88 CT114.1 185.23,12.78 185.51,13.06 188.24,13.06 189.1,12.19 v2(189.1,11.68)
  IN1 w0.102: v2(297.13,8.12) 297.13,9.77 294.46,12.44 292.87,12.44 290.27,15.04 283.47,15.04 280.68,12.25 273,12.25 272.43,11.68 256.63,11.68 254.81,13.5 252.98,13.5 251.34,11.87 245.18,11.87 243.95,10.63 243.25,10.63 242.58,9.96 v2(240.23,9.96)
  IN3 w0.102: v2(314.46,59.62) 314.49,59.62 314.99,59.11 314.99,58.06 314.33,57.39 314.33,53.01 317.76,49.58 317.76,45.52 318.22,45.06 320.44,45.06 321.47,44.03 321.47,42.94 320.79,42.26 320.79,41.61 321.35,41.05 321.35,40.14 320.56,39.35 320.56,37.4 316.12,32.97 316.12,32.17 314.27,30.32 314.27,28.04 313.73,27.49 313.73,20.53 313.43,20.23 313.43,20.02 312.29,18.88 312.29,18.12 311.98,17.81 311.98,17.81 310.64,16.46 310.23,16.46 309.98,16.21 307.78,16.21 306.1,14.53 306.1,13.86 301.44,9.2 298.2,9.2 v2(297.13,8.12) ; v2(196.68,9.94) 196.37,9.94 195.96,10.35 192.66,10.35 192.45,10.56 189.91,10.56 189.1,11.37 v2(189.1,11.68)
  IN6 w0.102: v2(240.23,9.96) 240.17,9.96 237.46,12.67 232.52,12.67 231.83,11.98 229.42,11.98 228.26,10.82 227.76,10.82 227.34,10.82 226.84,10.82 226.84,10.82 225.85,10.82 225.46,10.43 207.76,10.43 206.27,11.93 201.3,11.93 199.93,10.57 197.3,10.57 v2(196.68,9.94)
  BOTTOM w0.102: QT2.2 183.6,13.01 183.24,12.65 183.24,12.26 183.54,11.96 185.05,10.46 185.05,6.43 v2(185.4,6.07)
TP_INT#: length 165.7
  TOP w0.102: v1(289.62,21.95) 289.68,22.01 UE5.38 292.22,22.01 292.34,21.89 292.4,21.89 292.57,21.73 292.57,21.67 292.87,21.36 292.87,20.3 293.61,19.56 v2(293.61,19.23) ; RE661.2 196.34,15.92 v2(196.35,15.93)
  IN1 w0.089: 195.8,16.96 195.8,17.24 194.97,18.08
  IN1 w0.102: 195.8,16.96 195.8,16.63 196.35,16.08 v2(196.35,15.93) ; v2(183.75,30.83) 183.75,30.27 187.24,26.79 187.65,26.79 188.67,25.77 188.67,23.3 191.72,20.25 194.9,20.25 195.41,19.74 195.59,19.74 195.73,19.6 195.73,19.2 195.14,18.62 195.14,18.53 194.97,18.35 194.97,18.08
  IN2 w0.089: 192.1,31.28 192.34,31.04 193.43,31.04 193.68,31.3 196.54,31.3 199.08,28.76 200.03,28.76 200.16,28.63 206.57,28.63 206.83,28.88 206.83,29.33 207.27,29.77 209.05,29.77 209.3,30.03 211.15,30.03 212.57,31.44 214.02,31.44 215.67,33.09 v2(216.8,33.09)
  IN2 w0.102: 192.1,31.28 191.98,31.4 189.29,31.4 188.93,31.04 183.97,31.04 v2(183.75,30.83)
  IN4 w0.089: v2(216.8,33.09) 217.45,33.09 217.68,33.32 217.98,33.32 218.19,33.11 218.47,32.83 219.04,32.83 219.08,32.78 219.18,32.78
  IN4 w0.102: 219.18,32.78 219.51,32.78 219.66,32.63 222.51,32.63 223.72,33.84 225.69,33.84 226.96,35.11 228.1,35.11 228.61,34.6 228.97,34.6 228.97,34.6 229.36,34.6 229.88,34.08 229.88,33.8 231.48,32.2 231.48,26.2 232.16,25.52 232.16,24.88 234.23,22.81 235.85,22.81 236.87,21.8 240.08,21.8 240.83,21.05 240.83,20.87 243.39,18.3 245.96,18.3 246.28,17.99 248.44,17.99 248.76,18.3 254.32,18.3 254.87,18.85 257.32,18.85 257.6,19.13 258.21,19.13 258.93,19.84 265.28,19.84 265.96,20.53 271.37,20.53 271.9,21.06 292.37,21.06 293.61,19.82 v2(293.61,19.23)
  BOTTOM w0.089: v2(216.8,33.09) 216.72,33.01 216.29,33.01 216.14,33.16 216.14,33.17 216.12,33.19 216.12,33.36 216.14,33.38 216.14,33.61 215.92,33.84 215.78,33.84 UH1.BE15
  BOTTOM w0.102: JTP.8 193.32,14.04 194.45,15.17 195.59,15.17 v2(196.35,15.93)
TP_LED_B#: length 234.7
  TOP w0.102: v2(114.16,27.5) 113.83,27.5 R153.2 ; R146.2 111.82,27.39 112.04,27.6 113.01,27.6 R153.2 ; R153.2 113.53,27.08 Q28.5 ; UE3.14 v2(232.8,161.16)
  TOP w0.127: v2(114.16,27.5) 114.59,27.5 v1(114.73,27.64)
  IN2 w0.102: v2(232.8,161.16) 225.89,161.16 225.19,160.46 223.22,160.46 222.53,159.76 218.46,159.76 218.07,159.36 217.62,159.36 216.8,158.54 214.62,158.54 213.56,159.6 213.05,159.6 212.7,159.25 212.7,158.8 212.4,158.51 210.72,158.51 209.3,157.1 209.3,156.51 207.68,154.88 207.68,152.42 197.48,142.22 197.48,137.77 193.99,134.28 193.99,130.93 186.42,123.36 186.42,116.82 186.13,116.53 186.13,114.69 184.27,112.84 184.27,106.96 182.02,104.71 182.02,99.75 182.53,99.24 v2(182.79,99.24)
  IN3 w0.102: v2(182.79,99.24) 181.09,99.24 176.09,94.24 176.09,91.57 174.44,89.92 174.44,88.32 173.85,87.72 173.85,53.55 174.13,53.27 174.13,42.23 172.15,40.25 171.17,40.25 170.73,39.81 170.73,33.03 167.66,29.96 115.93,29.96 114.16,28.18 v2(114.16,27.5)
TP_LED_B#_DRV: length 5.1
  TOP w0.102: v1(110.93,24.83) 111.4,24.36 R144.2 112.47,23.71 113.42,23.71 113.53,23.83 Q28.2 113.53,24.68 113.67,24.82 113.95,24.82 114.18,24.59 Q28.3
TP_LED_B#_DRV#: length 99.6
  TOP w0.102: v2(124.2,27.86) 123.83,27.49 v1(121.1,27.49) 120.82,27.77 116.72,27.77 114.47,25.52 112.99,25.52 112.88,25.62 Q28.6 112.88,26.81 R153.1
  IN1 w0.508: v2(124.2,27.86) 128.21,31.86 181.55,31.86 186.42,27 186.42,24.27 191.02,19.68 193.24,19.68 194.57,18.34 194.57,16.99 195.08,16.49 195.24,16.49 195.25,16.48 195.35,16.48 195.71,16.12 195.71,15.17 195.89,14.99 195.89,14.88 195.91,14.86 v2(195.91,14.44)
  BOTTOM w0.305: JTP.3 195.82,14.36 v2(195.91,14.44)
TP_LED_EN: length 127.4
  TOP w0.127: UE5.25 295.94,21.85 v2(295.66,21.58) ; v2(288.05,6.34) v1(288.64,6.34)
  IN2 w0.127: v2(237.49,9.69) 237.55,9.69 238.88,11.02 249.54,11.02 250.07,11.55 251.73,11.55 252.55,12.37 252.55,13.01 253.38,13.83 270.73,13.83 271.79,14.89 276.32,14.89 277.57,13.64 278.33,13.64 279.69,12.28 279.69,6.87 280.22,6.34 v2(288.05,6.34)
  IN3 w0.127: v2(295.66,21.58) 295.66,21.19 295.1,20.63 289.19,20.63 288.17,19.61 288.17,11.57 288.78,10.96 288.78,7.07 v2(288.05,6.34)
  BOTTOM w0.127: v2(237.49,9.69) 237.77,9.69 238.06,9.4 238.06,6.71 237.4,6.05 227.43,6.05 226.93,5.55 206.47,5.55 205.56,4.64 Q2410.2
TP_LED_G#: length 227.4
  TOP w0.102: UE3.11 232.52,159.66 v2(232.67,159.5) ; R154.2 117.09,26.98 R152.2 117.65,27.54 118.59,27.54 v2(118.86,27.27) 118.86,26.48 118.87,26.47 Q29.5
  TOP w0.127: v2(232.67,159.5) 232.76,159.5 v1(233.28,160.02)
  IN2 w0.102: v2(182.79,98.54) 183.48,98.54 184.45,99.51 184.45,103.95 185.54,105.04 185.54,112.31 187.4,114.16 187.4,116 187.69,116.29 187.69,122.83 195.26,130.41 195.26,133.76 198.38,136.88 198.75,137.25 198.75,141.7 208.95,151.89 208.95,154.36 210.57,155.97 211.08,155.97 211.13,156.02 211.17,156.02 211.22,156.07 214.46,156.07 215.3,156.91 216.66,156.91 216.78,156.79 219.68,156.79 219.69,156.77 221.98,156.77 222.39,156.77 223.08,156.77 224.61,158.3 231.02,158.3 232.23,159.5 v2(232.67,159.5)
  IN3 w0.102: v2(182.79,98.54) 182.76,98.54 182.7,98.48 180.86,98.48 176.73,94.35 176.73,91.3 175.08,89.65 175.08,88.06 174.48,87.46 174.48,59.2 175.59,58.09 175.59,55.09 176.39,54.28 176.39,48.03 175.97,47.61 175.97,43.17 172.28,39.49 172.28,33.69 167.92,29.33 120.4,29.33 118.86,27.78 v2(118.86,27.27)
TP_LED_G#_DRV: length 6
  TOP w0.102: R150.2 116.15,23.93 v1(116.53,23.55) 118.69,23.55 118.87,23.73 Q29.2 118.87,24.62 119.01,24.76 119.39,24.76 119.52,24.63 Q29.3
TP_LED_G#_DRV#: length 93.4
  TOP w0.381: v2(125.1,27.86) 122.7,25.45 v1(121.64,25.45) 118.6,25.45 118.22,25.84 Q29.6 118.22,26.97 R152.1
  IN1 w0.508: v2(125.1,27.86) 128.47,31.23 181.29,31.23 185.78,26.73 185.78,23.76 185.71,23.68 185.71,22.97 189.12,19.55 190.24,19.55 190.75,19.04 193.02,19.04 193.9,18.16 193.9,15.62 194.26,15.27 194.71,15.27 195.25,14.72 195.25,14.62 195.27,14.6 v2(195.27,14.48)
  BOTTOM w0.305: JTP.4 195.32,14.43 v2(195.27,14.48)
TP_LED_R#: length 236.8
  TOP w0.102: v2(233.5,159.5) 232.97,158.98 232.44,158.98 232.26,159.16 UE3.10 ; v2(111.29,26.91) 110.94,26.57 110.94,25.77 110.52,25.35 R147.2 108.76,25.35 108.39,25.72 Q34.5 108.39,27.02 R151.2
  TOP w0.127: v2(111.29,26.91) v1(111.29,27.7)
  IN2 w0.102: v2(233.5,159.5) 233.5,159.63 232.86,160.26 230.7,160.26 230.12,159.68 223.35,159.68 222.79,159.12 219.06,159.12 218.66,158.73 217.62,158.73 216.99,158.09 215.58,158.09 214.89,157.41 214.35,157.41 214.35,157.41 213.84,157.41 213.84,157.41 213.5,157.41 213.03,157.88 210.98,157.88 209.94,156.84 209.94,156.24 208.31,154.62 208.31,152.16 198.12,141.96 198.12,137.51 194.63,134.02 194.63,130.67 187.05,123.09 187.05,116.56 186.76,116.26 186.76,114.43 184.91,112.57 184.91,105.3 183.82,104.21 183.82,100.6 183.16,99.94 182.83,99.94 182.83,99.91 v2(182.79,99.91)
  IN3 w0.102: v2(111.29,26.91) 114.97,30.6 167.39,30.6 170.09,33.29 170.09,51.96 171.59,53.46 171.59,61.01 172.28,61.71 172.28,63.68 173.21,64.61 173.21,87.99 173.81,88.59 173.81,90.18 175.46,91.83 175.46,94.06 181.31,99.91 v2(182.79,99.91)
TP_LED_R#_DRV: length 4.1
  TOP w0.102: Q34.2 108.39,23.46 108.55,23.3 v1(108.66,23.3) 108.84,23.3 109.04,23.5 Q34.3 109.04,24.76 109.17,24.88 109.52,24.88 R145.2
TP_LED_R#_DRV#: length 105.9
  TOP w0.102: v2(126,27.86) v1(121.47,23.33) 120.99,22.85 108.53,22.85 107.26,24.12 107.26,24.69 107.74,25.17 Q34.6 107.74,27.13 R151.1
  IN1 w0.508: v2(194.64,14.41) 194.45,14.6 193.87,14.6 193.18,15.29 193.18,16.65 193.15,16.68 193.15,16.75 192.74,17.16 191.74,17.16 189.98,18.92 188.86,18.92 185.07,22.7 185.07,23.95 185.15,24.02 185.15,26.47 181.03,30.59 128.74,30.59 v2(126,27.86)
  BOTTOM w0.305: v2(194.64,14.41) 194.82,14.23 JTP.5
TRIP_+1VALWP: length 1.5
  TOP w0.254: PR303.2 241.82,21.31 PU300.2
TRONL_LED_B_DRV#: length 309.2
  TOP w0.102: v3(35.33,53.86) 35.64,53.55 v2(36.2,53.55) ; v2(307.35,31.09) 306.71,31.73 306.71,33.64 307.22,34.14 UE8.5
  IN2 w0.102: v2(36.2,53.55) 36.24,53.55 36.88,52.91 36.88,52.31 37.35,51.84 42.4,51.84 42.6,52.05 45.42,52.05 46.96,50.51 55.38,50.51 55.8,50.93 66.27,50.93 67.59,49.61 82.08,49.61 83.64,51.17 85.8,51.17 86.24,50.72 91.13,50.72 91.7,51.29 97.29,51.29 97.8,50.78 107.89,50.78 109.91,52.79 171.92,52.79 172.21,52.51 172.21,50.85 173.14,49.92 174.57,49.92 175.03,49.46 178.88,49.46 180.04,50.62 186.61,50.62 190,54 194.69,54 195.64,53.05 199.88,53.05 202.39,55.56 207.42,55.56 212.49,50.49 223.12,50.49 224.36,49.24 227.19,49.24 227.83,48.59 243.52,48.59 245.77,46.34 269.18,46.34 274.35,41.16 275.63,41.16 279.27,37.52 282.13,37.52 283.52,36.12 283.52,35.51 286.31,32.72 290.67,32.72 293.39,30 296.18,30 297.84,28.34 303.37,28.34 305.27,30.24 306.5,30.24 v2(307.35,31.09)
  BOTTOM w0.102: JTRONL.5 40.27,49.94 40.1,49.78 36.46,49.78 36.27,49.96 JTRONL.10
  BOTTOM w0.107: JTRONL.10 36.27,51.87 36.62,52.22 36.62,53.13 v2(36.2,53.55)
TRONL_LED_G_DRV#: length 301.2
  TOP w0.102: UE8.4 306.72,33.97 305.76,33.01 305.76,32.36 v1(306.04,32.08) 306.76,31.35 v2(306.76,31.09)
  IN2 w0.102: v2(41.07,52.53) 41.46,52.91 42.04,52.91 42.44,52.51 45.61,52.51 47.15,50.97 55.19,50.97 55.61,51.38 66.46,51.38 67.18,50.66 82.49,50.66 83.49,51.67 86.09,51.67 86.58,51.18 90.94,51.18 91.51,51.74 97.48,51.74 97.99,51.24 107.7,51.24 109.72,53.25 172.11,53.25 172.67,52.7 172.67,51.56 173.09,51.13 174.01,51.13 175.22,49.92 178.69,49.92 180.24,51.46 181.71,51.46 182.16,51.91 187.25,51.91 189.81,54.46 194.88,54.46 195.83,53.51 199.69,53.51 202.88,56.7 206.93,56.7 212.68,50.94 226.2,50.94 228.09,49.05 237.28,49.05 238.09,49.87 241.45,49.87 242.27,49.05 243.71,49.05 243.97,48.78 243.97,48.78 245.96,46.8 269.36,46.8 274.54,41.62 275.82,41.62 279.27,38.17 282.13,38.17 283.98,36.31 283.98,36.01 286.81,33.18 290.86,33.18 293.58,30.45 296.37,30.45 297.17,29.66 298.75,29.66 299.61,28.8 302.7,28.8 305.4,31.5 306.36,31.5 v2(306.76,31.09)
  BOTTOM w0.102: 41.07,51.93 v2(41.07,52.53)
  BOTTOM w0.107: JTRONL.4 41.07,51.93 ; JTRONL.9 37.07,52.2 37,52.27 37,52.61 37.24,52.85 37.37,52.85 37.66,53.14 40.46,53.14 v2(41.07,52.53)
TRONL_LED_R_DRV#: length 299.7
  TOP w0.102: v2(306.18,31.09) 306.18,31.45 305.44,32.19 305.44,33.2 306.22,33.97 v1(306.22,34.06) UE8.3
  IN2 w0.102: v2(306.18,31.09) 305.56,30.47 305.18,30.47 303.27,28.57 297.93,28.57 296.27,30.23 293.48,30.23 290.76,32.95 286.72,32.95 283.75,35.91 283.75,36.22 282.03,37.94 279.18,37.94 275.73,41.39 274.45,41.39 269.27,46.57 245.87,46.57 243.75,48.69 243.61,48.82 242.17,48.82 241.36,49.64 238.19,49.64 237.37,48.82 227.93,48.82 227.28,49.47 224.45,49.47 223.21,50.71 212.59,50.71 206.84,56.47 202.97,56.47 199.78,53.28 195.74,53.28 194.78,54.23 189.9,54.23 186.52,50.85 183.31,50.85 182.57,51.6 182.17,51.6 181.81,51.24 180.33,51.24 178.79,49.69 175.13,49.69 173.92,50.9 173,50.9 172.44,51.46 172.44,52.6 172.02,53.02 109.81,53.02 107.8,51.01 97.89,51.01 97.39,51.51 91.6,51.51 91.04,50.95 86.48,50.95 86,51.44 83.59,51.44 82.58,50.44 67.09,50.44 66.37,51.16 55.7,51.16 55.29,50.74 47.06,50.74 45.52,52.28 42.1,52.28 v2(41.87,52.51) 41.74,52.51 41.36,52.12 40.59,52.12 39.82,52.89 38.25,52.89 37.98,52.62 37.98,52.44 v2(37.99,52.44)
  BOTTOM w0.107: JTRONL.3 v2(41.87,52.51) ; JTRONL.8 37.87,52.33 37.98,52.44 v2(37.99,52.44)
TRONR_LED_B_DRV#: length 45.2
  TOP w0.102: v2(309.22,33) 310.1,33 310.21,33.1 310.21,36.15 310.08,36.28 UE8.9
  TOP w0.107: v2(279.58,30.03) v1(279.58,30.93) 279.58,31.44 279.35,31.68 278.71,31.68 v2(278.27,31.23)
  IN1 w0.102: v2(279.58,30.03) 280.14,30.58 289.24,30.58 292.54,33.88 294.27,33.88 294.69,34.31 305.42,34.31 306.77,32.96 309.18,32.96 v2(309.22,33)
  BOTTOM w0.107: JTRONR.5 277.97,31.53 v2(278.27,31.23) ; JTRONR.10 281.97,31.09 281.86,30.98 280.54,30.98 v2(279.58,30.03)
TRONR_LED_G_DRV#: length 41.5
  TOP w0.102: UE8.8 v1(308.72,34.12) 308.72,33.56 308.62,33.46 v2(308.03,33.46)
  IN1 w0.102: v2(308.03,33.46) 306.92,34.57 294.63,34.57 294.17,34.11 292.44,34.11 289.14,30.81 279.78,30.81 v2(279,30.03)
  BOTTOM w0.102: 280.18,31.21 281,31.21 281.17,31.38 281.17,32.19
  BOTTOM w0.107: 280.18,31.21 v2(279,30.03) 278.3,30.72 277.27,30.72 277.17,30.83 JTRONR.4 ; JTRONR.9 281.17,32.19
TRONR_LED_R_DRV#: length 51.1
  TOP w0.102: UE8.6 307.72,34.32 306.94,33.55 306.94,32.15 307.76,31.33 307.76,30.43 307.35,30.03 v1(305.76,30.03) 305.44,29.71 304.94,29.71 304.49,30.15 303.09,30.15 302.78,30.47 302.78,31.8 302.33,32.25 301.63,32.25 300.78,31.39 299.25,31.39 298.94,31.71 298.94,32.09 295.82,35.2 v2(295.82,38.28)
  IN1 w0.102: v2(279.15,33.52) 279.45,33.23 287.52,33.23 290.95,36.66 290.95,37.46 291.96,38.46 295.64,38.46 v2(295.82,38.28)
  BOTTOM w0.107: JTRONR.3 276.37,33.27 277.39,34.29 278.38,34.29 v2(279.15,33.52) 280.11,33.52 280.37,33.26 JTRONR.8
TS_EN: length 345.5
  TOP w0.102: v2(168.79,173.41) 169.25,173.87 169.25,174.93 167.93,176.25 167.93,179.47 168.12,179.66 JEDP.34 ; v1(331.67,48.76) v2(331.67,48) 332.04,47.63 UE6.14
  IN4 w0.089: 202.45,44.76 202.32,44.76 ; 208.35,43.68 208.35,42.72 208.81,42.26 210.01,42.26
  IN4 w0.102: v2(168.79,173.41) 168.41,173.03 168.41,171.5 169.59,170.32 169.59,160.86 169.29,160.56 169.29,159.74 169.88,159.15 172.25,159.15 172.95,158.45 175.1,158.45 175.97,159.31 178.49,159.31 180.24,157.56 180.44,157.56 180.63,157.56 182.51,155.68 185.05,155.68 185.48,155.25 186.65,155.25 190.62,151.27 190.62,151.08 190.62,150.73 194.34,147.01 194.34,129.68 193.68,129.03 193.68,128.23 192.87,127.42 192.87,126.82 187.27,121.22 187.27,117.21 187.14,117.08 186.1,116.04 186.1,111.79 185.59,111.27 185.59,109.73 184.73,108.87 184.73,105.65 184.39,105.31 184.39,101.06 184.59,100.85 184.59,97.45 187.51,94.53 187.51,82.99 186.95,82.43 186.95,78.38 187.51,77.82 187.51,70.23 188.03,69.7 188.03,65.36 186.06,63.39 186.06,62.91 186.06,62.72 185.85,62.51 185.85,57.79 186.88,56.76 188.27,56.76 189.56,55.47 192.77,55.47 198.4,49.85 198.4,46.27 198.9,45.76 201.32,45.76 202.32,44.76 ; v2(331.67,48) 330.97,48.7 328.9,48.7 328.18,47.97 328.18,46.92 329.03,46.07 329.03,43.6 330.57,42.05 331.14,42.05 331.42,41.77 331.42,41.2 332.48,40.13 332.48,37.13 330.95,35.59 329.15,35.59 328.76,35.2 326.03,35.2 323.96,33.12 319.63,33.12 319.43,32.92 310.24,32.92 309.64,32.32 304.89,32.32 304.31,31.74 297.19,31.74 296.09,30.64 284.34,30.64 283.24,31.74 276.78,31.74 275.08,30.04 269.29,30.04 265.59,26.34 264.81,26.34 264.5,26.04 261.75,26.04 260.16,24.45 258.22,24.45 257.32,25.36 257.32,25.38 255.95,26.75 247.8,26.75 246.71,27.84 243.49,27.84 243.1,28.23 243.1,29.84 241.13,31.81 241.13,34.96 238.16,37.93 236.51,37.93 235.16,39.27 233.62,39.27 231.99,40.9 231.86,41.04 230.59,41.04 230.59,41.04 230.16,41.04 229.42,40.3 227.38,40.3 227,39.92 224.13,39.92 223.06,40.99 222.69,40.99 222.68,40.99 219.1,40.99 218.97,40.85 218.97,40.8 218.56,40.4 214.04,40.4 213.73,40.7 211.57,40.7 210.01,42.26 ; 208.35,43.68 208.35,44.74 207.69,45.4 203.85,45.4 203.21,44.76 202.45,44.76
TSENSE_2PH: length 34.3
  TOP w0.203: v2(121.95,146.54) 122.14,146.35 PU500.25
  IN1 w0.254: v2(145.9,152.73) 145.57,152.73 145.51,152.66 143.72,152.66 142.15,151.08 140.81,151.08 138.77,153.11 132.25,153.11 129.39,150.25 129.39,149.58 129.39,149.26 129.19,149.07 129.19,146.82 128.15,145.77 122.72,145.77 v2(121.95,146.54)
  BOTTOM w0.203: v2(121.95,146.54) 122.21,146.54 122.51,146.84 v1(122.51,147.22) 122.51,148.11 PC531.1
  BOTTOM w0.254: v2(145.9,152.73) 145.9,152.17 PR568.1
TSENSE_4PH: length 39.8
  TOP w0.203: PU500.14 126.54,146.18 126.7,146.34 126.7,146.56 126.83,146.69 126.83,146.67 126.85,146.67 126.85,146.66 v2(126.84,146.66)
  IN1 w0.254: v2(156.02,151.74) 155.79,151.74 155.59,151.95 153.43,151.95 151.34,154.03 145.8,154.03 145.19,153.42 139.55,153.42 139.09,153.88 131.94,153.88 130.77,152.71 129.8,152.71 128.81,151.72 128.81,151.41 127.36,149.96 127.36,149.21 127.11,148.96 126.95,148.96 126.6,148.61 126.6,148.06 126.25,147.7 126.25,146.97 126.54,146.67 126.85,146.67 126.85,146.66 v2(126.84,146.66)
  BOTTOM w0.203: PC529.1 126.83,145.75 126.83,146.66 v2(126.84,146.66)
  BOTTOM w0.254: v2(156.02,151.74) 156.02,152.25 155.53,152.73 PR567.1
TYPEC_DET#: length 24.5
  TOP w0.102: QU1.1 296.79,64.32 RU26.2 297.99,64.32 v2(298.12,64.19) 298.12,65.18 v1(298.67,65.73) ; UE10.18 316.26,61.92 v2(315.71,62.47)
  IN6 w0.102: v2(298.12,64.19) 299.24,64.19 300.96,62.46 305.06,62.46 305.43,62.09 306.96,62.09 307.23,62.37 313.64,62.37 313.94,62.07 315.3,62.07 v2(315.71,62.47)
UART_2_PRXD_DTXD: length 175.2
  TOP w0.089: v2(211.51,24.34) 211.43,24.34 211.34,24.25 211.34,23.95 211.12,23.74 211.02,23.74 210.69,23.41 210.69,22.65 210.46,22.42 209.92,22.42 209.81,22.31 209.81,21.45 210.72,20.54 210.72,19.94 210.47,19.69 210.47,19.52 210.27,19.32 210.27,18.23 210,17.96 210,17.8 v2(210.2,17.61)
  TOP w0.102: RC62.1 203.65,10.96 203.65,11.15 v2(203.5,11.31) 203.89,11.69 JWDB.3
  IN1 w0.102: v2(203.5,11.31) 203.5,11.32 204.11,11.93 207.25,11.93 207.82,11.36 215,11.36 216.32,12.68 238.44,12.68 240.34,14.58 251.02,14.58 252.09,15.65 255.7,15.65 256.03,15.33 257.52,13.83 270.97,13.83 272.13,14.99 278.32,14.99 279.09,15.75 280.58,15.75 283.38,18.55 291.14,18.55 292.79,16.89 297.48,16.89 297.94,16.44 298.59,16.44 298.71,16.56 v2(298.71,16.8)
  IN4 w0.089: v2(211.51,24.34) 211.36,24.49 211.36,24.73 211.53,24.9 212.19,24.9 212.33,24.76 214.38,24.76 215.91,26.28 215.91,31.23 216.5,31.83 216.5,32.14 216.71,32.35 217.16,32.35 217.4,32.6 217.71,32.6 217.79,32.5 v2(217.77,32.32)
  BOTTOM w0.089: 208.46,16.96 208.48,16.97 209.58,16.97 209.74,16.96 210,17.22 210,17.4 v2(210.2,17.61) ; UH1.BD20 214.8,31.54 215.52,31.54 215.65,31.67 216.09,31.67 216.5,32.08 216.5,32.14 216.55,32.18 216.55,32.19 216.62,32.26 216.62,32.26 216.72,32.36 217.23,32.36 217.41,32.55 217.68,32.55 217.77,32.46 v2(217.77,32.32)
  BOTTOM w0.102: v2(203.5,11.31) 203.64,11.17 203.64,10.93 204.04,10.53 207.79,10.53 207.99,10.73 208.03,10.77 208.03,16.47 208.43,16.86 208.43,16.92 208.46,16.96 ; v2(298.71,16.8) 298.92,17 298.92,17.76 298.76,17.92 298.76,19.03 298.05,19.75 298.05,20.93 298.54,21.41 298.54,25.1 300.41,26.98 300.41,29.79 302.89,32.26 304.02,32.26 306.49,34.72 306.49,36.84 306.26,37.07 306.26,39.06 306.99,39.8 306.99,41.13 306.99,41.13 306.99,41.66 306.99,41.66 306.99,41.79 305.85,42.92 JWLAN.22
UART_2_PTXD_DRXD: length 173.7
  TOP w0.089: v2(210.96,24.33) 211.06,24.33 211.16,24.23 211.16,24.03 211.05,23.92 210.95,23.92 210.51,23.48 210.51,22.72 210.39,22.6 209.85,22.6 209.64,22.38 209.64,21.38 210.54,20.47 210.54,20.01 210.3,19.76 210.3,19.6 210.09,19.39 210.09,18.3 209.83,18.03 209.83,17.81 v2(209.62,17.61)
  TOP w0.102: RC63.1 203.71,10.55 203.71,10.7 203.88,10.87 203.88,11.1 v2(204.08,11.31) 204.69,11.91 JWDB.2
  IN1 w0.102: v2(204.08,11.31) 204.08,11.59 204.2,11.7 207.16,11.7 207.73,11.13 215.1,11.13 216.42,12.45 238.53,12.45 240.43,14.35 251.11,14.35 252.18,15.42 255.61,15.42 255.8,15.23 257.43,13.6 271.06,13.6 272.22,14.76 278.42,14.76 279.18,15.52 280.68,15.52 283.47,18.32 291.04,18.32 292.69,16.67 297.39,16.67 297.84,16.21 298.69,16.21 298.94,16.46 v2(299.19,16.46)
  IN4 w0.089: v2(210.96,24.33) 211.18,24.56 211.18,24.8 211.45,25.07 212.26,25.07 212.4,24.93 214.31,24.93 215.73,26.35 215.73,31.31 216.32,31.9 216.32,32.22 216.64,32.53 217.08,32.53 217.33,32.78 217.61,32.78 v2(217.83,32.96)
  BOTTOM w0.089: v2(217.83,32.96) 217.6,32.73 217.34,32.73 217.15,32.54 216.65,32.54 216.55,32.44 216.55,32.44 216.37,32.26 216.37,32.26 216.32,32.22 216.32,32.15 216.02,31.85 215.56,31.85 215.48,31.77 UH1.BE20 ; 208.2,16.96 208.39,17.15 209.59,17.15 209.67,17.14 209.82,17.29 209.82,17.4 v2(209.62,17.61)
  BOTTOM w0.102: v2(204.08,11.31) 203.87,11.09 203.87,11.02 204.13,10.76 207.7,10.76 207.81,10.87 207.81,16.56 208.2,16.96 ; v2(299.19,16.46) 299.14,16.5 299.14,17.86 298.99,18.01 298.99,19.13 298.28,19.84 298.28,20.83 298.76,21.31 298.76,25 300.64,26.88 300.64,29.7 302.98,32.03 304.12,32.03 306.71,34.63 306.71,36.93 306.49,37.16 306.49,38.97 307.22,39.7 307.22,41.22 307.22,41.22 307.22,41.56 307.22,41.57 307.22,41.79 308.07,42.64 JWLAN.24
UG_3V: length 15.9
  TOP w0.102: v2(53.48,31.23) 54.12,31.23 v1(54.35,31.46)
  IN4 w1.016: 57.16,44.89 58.16,43.89 58.16,42.45 52.9,37.2 52.9,32.5
  vias: v2(53.25,30.69) v2(55.95,46.22) v2(56.4,45.78)
UG_5V: length 7.7
  IN4 w1.016: 50.62,44.82 50.61,44.82 46.61,40.82 46.61,39.74
  BOTTOM w0.102: v2(51.51,45.01) 51.51,44.26 v1(51.38,44.14)
  vias: v2(47.06,38.73) v2(47.06,38.09) v2(51.76,45.61)
UG_+1VALWP: length 6.1
  TOP w0.102: v2(253.34,20.82) 253.26,20.82 v1(252.93,20.49)
  IN1 w1.016: 253.01,20.02 252.66,19.68 250.85,19.68 249.13,21.39 248.32,21.39 248.29,21.36
  vias: v2(247.32,21.94) v2(247.32,21.31) v2(253.25,21.4)
USART_RX: length 198.3
  TOP w0.102: v2(315,22.03) 315,22.04 315.51,22.04 RE6.1 316.3,21.26 UE1.31
  IN4 w0.102: v2(315,22.03) 315.17,21.86 316.2,21.86 323.69,14.37 323.69,13.61 323.25,13.17 323.25,12.67 323.48,12.44 323.68,12.44 v2(323.92,12.2)
  IN6 w0.102: v2(167.62,16.18) 167.8,16 167.8,15.33 169.7,13.43 182.11,13.43 186.1,9.44 187.02,9.44 188.2,8.26 189.19,8.26 189.59,7.86 189.72,7.72 192.61,7.72 193.78,6.55 203.22,6.55 203.48,6.28 230.27,6.28 230.41,6.42 230.41,6.42 230.65,6.66 253.82,6.66 254.41,7.26 256.57,7.26 257.8,8.48 257.8,9.37 260.49,12.07 272.06,12.07 272.4,12.41 280.07,12.41 281.12,11.36 289.91,11.36 290.3,11.74 294.84,11.74 296.2,13.1 296.65,13.1 296.67,13.07 301.36,13.07 305,9.44 317.43,9.44 319.62,11.62 321.32,11.62 321.65,11.29 322.27,11.29 323.35,12.37 323.74,12.37 v2(323.92,12.2)
  BOTTOM w0.102: JELC1.2 167.4,27.86 167.67,27.59 167.67,26.31 167.78,26.21 167.78,16.34 v2(167.62,16.18)
USART_TX: length 194.4
  TOP w0.102: UE1.30 316.79,21.36 RE7.1 317.46,21.5 v2(317.95,21.01)
  IN4 w0.102: v2(317.95,21.01) 317.95,20.43 323.92,14.46 323.92,13.52 323.48,13.07 323.48,12.77 323.58,12.67 323.81,12.67 v2(323.92,12.78)
  IN6 w0.102: v2(323.92,12.78) 323.74,12.6 323.26,12.6 322.18,11.52 321.74,11.52 321.41,11.85 319.52,11.85 317.34,9.67 305.09,9.67 301.46,13.3 296.77,13.3 296.74,13.33 296.1,13.33 294.74,11.97 290.2,11.97 289.82,11.59 281.22,11.59 280.17,12.64 272.3,12.64 271.96,12.3 260.4,12.3 256.22,8.12 254.95,8.12 254.91,8.08 254.41,8.08 254.17,7.84 254.17,7.34 253.73,6.89 230.56,6.89 230.18,6.51 203.57,6.51 203.31,6.78 193.88,6.78 192.7,7.95 189.82,7.95 189.28,8.49 188.29,8.49 187.11,9.67 186.2,9.67 182.2,13.66 169.79,13.66 168.03,15.42 168.03,16.01 v2(168.2,16.18)
  BOTTOM w0.102: JELC1.3 168.2,27.91 167.9,27.61 167.9,26.41 168,26.31 168,16.38 v2(168.2,16.18)
