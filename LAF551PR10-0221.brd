# Allegro board LAF551PR10-0221.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
EN_TPLED on TOP (solid shape): 207.64,9.85 207.64,7.58 207.51,7.45 206.98,7.45 206.66,7.76 204.71,7.76 204.61,7.86 204.61,8.06 204.73,8.18 205.05,8.18 205.18,8.31 205.18,8.37 205.3,8.5 205.91,8.5 206.24,8.5 206.33,8.59 206.33,8.61 206.45,8.72 206.45,9.04 206.33,9.15 206.33,9.2 206.29,9.24 206.29,9.93 206.44,10.07 207.41,10.07
GPU_B+ on TOP (solid shape): outline of 222 points within 159,145.18 200.26,152.72
GPU_B+ on TOP (solid shape): outline of 789 points within 87.64,11.28 119.96,24.18
GPU_B+ on TOP (solid shape): outline of 1801 points within 261.84,9.55 277.26,34.34
GPU_B+ on BOTTOM (solid shape): 273.38,36.33 273.38,33.07 272.72,32.41 269.41,32.41 269.11,32.7 269.11,34.05 269.39,34.33 270.71,34.33 270.9,34.52 270.9,36.19 271.15,36.44 273.26,36.44
GPU_B+ on BOTTOM (solid shape): 264.75,25.01 264.75,24.69 263.65,23.59 263.65,23.16 263.5,23.02 261.49,23.02 261.45,23.05 261.45,23.92 261.45,24.21 261.68,24.44 262.29,24.44 262.47,24.62 262.47,24.96 262.64,25.14 264.63,25.14
GPU_B+ on BOTTOM (solid shape): 168.01,151.97 171.48,151.97 172.2,152.69 173.83,152.69 173.99,152.53 175.79,152.53 175.94,152.69 178.7,152.69 179.3,152.08 185.95,152.08 185.98,152.05 186.17,152.05 187.1,151.13 188.01,151.13 188.4,150.74 189.21,150.74 189.43,150.96 189.44,150.96 189.55,151.07 189.67,151.07 189.8,151.2 194.25,151.2 196.35,149.1 201.23,149.1 201.47,148.85 202.85,148.85 203.17,148.53 203.17,146.51 203.03,146.36 200.54,146.36 200.24,146.06 199.13,146.06 199.12,146.06 198.08,146.06 198.08,146.06 195.42,146.06 194.9,146.59 193.86,147.63 190.94,147.63 190.8,147.49 189.71,147.49 189.21,147.98 188.34,147.98 187.97,148.35 187.97,150.12 187.9,150.19 185.23,150.19 185.18,150.14 185.17,150.14 185.09,150.05 178.44,150.05 178.31,149.91 175.74,149.91 175.51,149.91 175.51,149.93 174.37,149.93 174.37,149.91 173.84,149.91 173.63,150 173.43,149.91 167.19,149.91 167.12,149.99 165.74,149.99 165.67,149.91 165.46,149.91 165.22,150.04 164.99,149.91 159.44,149.91 159.39,149.96 159.39,149.98 159.37,149.98 158.82,150.54 158.82,152.46 159.04,152.69 167.29,152.69
GPU_B+ on IN1 (solid shape): outline of 5378 points within 87.58,9.2 119.33,75.43
GPU_B+ on IN2 (solid shape): outline of 9927 points within 102.12,71.24 168.64,153.03
GPU_B+ on IN3 (solid shape): 118.99,15.68 118.99,10.58 118.31,9.9 116.98,9.9 115.58,11.29 115.58,15.8 115.78,16 118.67,16
GPU_B+ on IN3 (solid shape): 130.84,11.48 130.85,11.46 130.89,11.42 130.93,11.38 130.98,11.36 131.03,11.33 131.08,11.32 131.14,11.32 131.19,11.32 131.25,11.33 131.3,11.36 131.34,11.38 131.39,11.42 131.42,11.46 131.44,11.48 136.53,11.48 137.3,10.72 137.3,7.29 136.79,6.79 128.79,6.79 127.96,7.61 127.96,8.18 128.09,8.31 128.09,9.71 130.56,9.71 130.56,8.88 130.88,8.56 134.31,8.56 134.69,8.94 134.69,9.71 134.37,10.02 130.88,10.02 130.56,9.71 128.09,9.71 128.09,10.6 128.98,11.48
GPU_B+ on IN3 (solid shape): outline of 271 points within 153.49,4.25 203.59,15.42
GPU_B+ on IN3 (solid shape): outline of 910 points within 223.4,6.02 276.74,13.4
GPU_B+ on IN4 (solid shape): 119.36,15.68 119.36,12.08 120.27,11.17 120.27,10.87 118.84,9.44 118.58,9.44 116.15,11.87 115.64,12.38 115.64,15.93 115.79,16.07 118.96,16.07
GPU_B+ on IN4 (solid shape): outline of 262 points within 183.73,4.25 203.59,9.93
GPU_B+ on IN4 (solid shape): outline of 987 points within 224.93,4.42 276.77,13.19
GPU_B+ on GND3: 157.98,3.48 155.5,5.96 121.02,5.96 115.58,11.4 115.58,15.7 115.87,15.99 118.78,15.99 119.2,15.57 119.2,12.14 122.65,8.69 158.15,8.69 159.67,7.17 171.37,7.17 173.05,8.84 173.05,10.68 175.95,13.58 182.21,13.58 187.55,8.25 189.01,8.25 189.96,7.29 224.4,7.29 225.73,8.63 251.26,8.63 253.73,11.1 255.32,11.1 256.72,12.5 260.21,12.5 260.91,13.2 271.18,13.2 272,12.37 275.75,12.37 276.87,11.25 276.87,9.62 276.26,9.01 271.64,9.01 269.67,10.98 260.83,10.98 258.64,8.8 258.64,5.96 230.85,5.96 228.88,3.99 184.01,3.99 181.98,6.02 177.51,6.02 174.97,3.48 ; 1 cut-out
GPU_B+ on IN5: 197.41,146.1 196.77,146.74 178.55,146.74 177.34,147.95 160.71,147.95 158.95,149.7 158.95,152.67 159.69,153.41 166.65,153.41 168.18,151.88 171.63,151.88 172.45,152.71 199.17,152.71 201.05,150.82 201.05,146.53 200.63,146.1
GPU_PH1 on TOP (solid shape): 258.63,146.83 258.63,145.41 258.43,145.2 257.34,145.2 257.18,145.35 257.18,147.13 257.29,147.23 258.23,147.23
GPU_PH1 on BOTTOM (solid shape): 252.93,150.04 252.93,148.83 253.12,148.64 256.8,148.64 258.88,146.57 259.75,146.57 259.79,146.53 259.79,143.31 259.72,143.25 257.63,143.25 257.63,144.13 256.87,144.13 256.87,143.25 254.64,143.25 251.91,145.98 251.91,150.04 251.98,150.1 252.87,150.1
GPU_PH2 on TOP (solid shape): 244.93,146.61 244.93,145.43 244.56,145.06 243.48,145.06 243.28,145.27 243.28,146.93 243.47,147.12 244.42,147.12
GPU_PH2 on BOTTOM (solid shape): 239.15,149.98 239.15,148.77 239.34,148.58 243.02,148.58 245.1,146.5 245.97,146.5 246.01,146.47 246.01,143.25 245.94,143.18 243.85,143.18 243.85,144.06 243.09,144.06 243.09,143.18 240.86,143.18 238.13,145.91 238.13,149.98 238.2,150.04 239.09,150.04
GPU_PH3 on TOP (solid shape): 231.15,146.64 231.15,145.23 230.95,145.02 229.76,145.02 229.56,145.23 229.56,146.87 229.75,147.06 230.74,147.06
GPU_PH3 on BOTTOM (solid shape): 225.45,149.93 225.45,148.69 225.62,148.52 229.31,148.52 231.38,146.44 232.25,146.44 232.29,146.4 232.29,143.18 232.23,143.12 230.13,143.12 230.13,144 229.37,144 229.37,143.12 224.86,143.12 224.47,143.51 224.47,149.88 224.6,150.01 225.38,150.01
GPU_PH4 on BOTTOM (solid shape): 211.78,149.91 211.78,148.71 211.97,148.52 215.65,148.52 217.72,146.45 218.6,146.45 218.64,146.41 218.64,143.18 218.58,143.12 216.48,143.12 216.48,144 215.72,144 215.72,143.12 213.5,143.12 212.36,144.25 212.36,144.28 212.25,144.58 211.95,144.69 211.92,144.69 210.77,145.85 210.77,149.91 210.83,149.98 211.72,149.98
GPU_SNB1 on TOP (solid shape): 260.38,145.42 260.38,143.65 260.23,143.5 257.46,143.5 257.32,143.64 257.32,144.47 257.5,144.64 258.45,144.64 258.46,144.65 258.66,144.65 259.26,145.25 259.28,145.26 259.28,145.48 259.37,145.58 260.22,145.58
GPU_SNB2 on TOP (solid shape): 246.45,145.46 246.45,143.65 246.33,143.53 243.59,143.53 243.48,143.64 243.48,144.59 243.49,144.61 244.75,144.61 245.48,145.33 245.48,145.43 245.56,145.52 246.4,145.52
GPU_SNB3 on TOP (solid shape): 232.66,145.32 232.66,143.56 232.57,143.48 229.73,143.48 229.66,143.54 229.66,144.57 229.75,144.66 231.11,144.66 231.61,145.15 231.85,145.39 232.59,145.39
GPU_SNB4 on BOTTOM (solid shape): 207.96,144.4 207.96,142.01 207.91,141.96 207.32,141.96 207.23,142.05 207.23,142.84 206.8,143.27 206.8,144.64 206.87,144.71 207.65,144.71
GT_SW1 on BOTTOM (solid shape): 141.77,146.73 141.77,145.36 141.9,145.24 145.64,145.24 145.77,145.11 145.77,141.4 145.71,141.33 144.4,141.33 144.2,141.53 143.75,141.53 143.57,141.35 141.26,141.35 140.81,141.81 140.81,146.69 140.93,146.82 141.69,146.82
HP2_D_L_C on TOP (solid shape): 27.38,28.87 27.38,27.23 27.25,27.11 26.68,27.11 26.55,27.23 26.55,28.17 25.8,28.92 25.22,28.92 25.07,29.08 25.07,29.63 25.1,29.66 26.59,29.66
HP2_D_L_C on BOTTOM (solid shape): 27.44,28.12 27.44,26.6 26.87,26.03 23.44,26.03 21.85,24.44 21.85,22.71 21.74,22.6 19.57,22.6 19.44,22.72 19.44,24.66 20.92,26.14 21.77,26.14 22.81,27.17 25.92,27.17 26.36,27.61 26.36,27.99 26.62,28.25 27.31,28.25
HP2_D_R_C on TOP (solid shape): 25.84,26.33 26.05,26.33 26.17,26.22 26.17,25.2 25.98,25.01 25.02,25.01 24.88,25.15 24.88,25.6 25.07,25.8 25.07,26.3 25.11,26.34 25.84,26.34
HP2_D_R_C on BOTTOM (solid shape): 26.62,25.33 26.62,22.79 26.3,22.47 24.33,22.47 24.08,22.72 24.08,25.26 24.39,25.58 26.36,25.58
ISENSEP_L_R on TOP (solid shape): 38.87,5.33 38.87,4.31 38.86,4.31 38.74,4.19 38.74,4.19 38.55,4 37.85,4 37.16,4.69 36.97,4.69 36.84,4.82 36.83,4.82 36.83,5.33 36.9,5.4 37.66,5.4 37.79,5.52 38.68,5.52
ISENSEP_L_R on TOP (solid shape): 34.22,18.88 34.22,18.68 34.09,18.55 33.92,18.55 33.71,18.33 33.71,17.86 33.66,17.81 33.11,17.81 33.07,17.86 33.07,18.44 33.2,18.57 33.2,18.89 33.34,19.03 34.06,19.03
ISENSEP_L_R on BOTTOM (solid shape): 38.98,4.47 38.98,3.28 38.87,3.18 37.48,3.18 37.44,3.22 37.44,3.98 37.45,4.05 37.44,4.13 37.44,4.5 37.6,4.65 38.79,4.65
ISENSEP_L_R on IN1 (solid shape): 34.19,18.93 34.19,17.75 33.94,17.49 33.35,17.49 33.12,17.72 33.12,18.91 33.29,19.08 34.04,19.08
ISENSEP_L_R on IN1 (solid shape): 38.43,5.14 38.55,5.14 38.55,5.13 38.8,4.89 38.8,4.38 38.42,4 37.79,4 37.54,4.25 37.53,4.25 36.9,4.88 36.9,5.84 37.73,5.84
ISENSEP_R_R on TOP (solid shape): 29.26,18.41 29.26,18.06 29.22,18.02 29.22,17.48 29.07,17.33 28.49,17.33 28.39,17.43 28.39,17.84 28.26,17.97 28.26,18.35 28.39,18.48 29.19,18.48
ISENSEP_R_R on TOP (solid shape): 33.22,4.14 33.22,3.04 33.16,2.98 31.57,2.98 31.5,3.04 31.5,3.36 31.63,3.48 32.71,3.48 32.71,3.8 32.69,3.83 32.17,3.83 32.1,3.89 32.1,4.35 32.15,4.4 32.97,4.4
ISENSEP_R_R on BOTTOM (solid shape): 33.17,5.19 33.17,3.38 32.76,2.98 31.63,2.98 31.44,3.17 31.44,3.47 32.21,4.24 32.21,5.12 32.31,5.23 33.14,5.23
ISENSEP_R_R on IN1 (solid shape): 29.3,18.42 29.3,17.19 29.1,16.99 28.48,16.99 28.24,17.23 28.24,18.49 28.3,18.55 29.18,18.55
ISENSEP_R_R on IN1 (solid shape): 33.03,3.29 32.71,2.97 31.57,2.97 31.44,3.1 31.44,3.48 32.01,4.05 32.01,4.44 33.03,4.44
LG_3V on TOP (solid shape): 47.06,33.77 47.06,33.07 46.36,32.38 46.11,32.38 45.92,32.57 45.92,33.37 46.45,33.9 46.94,33.9
LG_3V on BOTTOM (solid shape): 55.89,45.33 55.89,45.02 55.76,44.89 55.19,44.89 54.55,45.53 54.55,46.29 54.68,46.41 54.81,46.41
LG_3V on IN1 (solid shape): 48.27,32.76 47.82,32.31 46.24,32.31 45.86,32.69 45.86,33.33 46.05,33.52 48.27,33.52
LG_3V on IN1 (solid shape): 55.89,45.33 55.89,44.76 56.84,43.81 56.84,43.24 56.59,42.99 56.27,42.99 55,44.26 55,45.14 54.81,45.33 54.81,45.72 54.93,45.84 55.38,45.84
LG_5V on TOP (solid shape): 48.65,37.96 48.65,37.45 48.63,37.38 48.62,37.32 48.62,37.3 48.38,37.06 47.99,37.06 47.84,36.91 46.9,36.91 46.74,37.06 46.74,37.46 46.94,37.65 47.57,37.65 47.7,37.77 47.7,38.03 47.76,38.09 48.52,38.09
LG_5V on BOTTOM (solid shape): 53.16,46.29 53.16,45.53 52.97,45.33 52.97,44.98 52.69,44.7 52.46,44.7 52.33,44.83 52.33,45.78 52.9,46.35 53.09,46.35
LG_5V on IN1 (solid shape): 48.65,38.79 48.65,37.33 48.46,37.14 48.08,37.14 47.63,37.58 47.63,38.85 48.59,38.85
LG_5V on IN1 (solid shape): 53.03,45.72 53.03,45.04 52.66,44.67 52.66,43.72 52.43,43.49 52.02,43.49 51.95,43.56 51.95,44.76 52.27,45.08 52.27,45.65 52.46,45.84 52.9,45.84
LG_+1VALWP on TOP (solid shape): 256.62,21.19 257.36,21.19 257.48,21.07 257.48,19.78 257.32,19.62 256.29,19.62 256.14,19.78 256.14,21.09 256.31,21.25 256.56,21.25
LG_+1VALWP on TOP (solid shape): 247.13,19.41 247.13,19.15 247.28,19 247.28,18.85 247.28,18.41 246.81,17.94 246.3,17.94 245.79,18.44 245.79,19.84 245.92,19.97 246.57,19.97
LG_+1VALWP on IN1 (solid shape): 256.92,21.02 256.92,20.26 256.66,20.01 255.49,20.01 255.3,20.2 255.3,20.91 255.69,21.29 256.65,21.29
LG_+1VALWP on IN1 (solid shape): 248,19.85 248,19.21 247.42,18.62 247.25,18.46 246.99,18.46 246.41,19.03 246.41,19.29 247.21,20.09 247.76,20.09
LINE1_L on BOTTOM (solid shape): 26.25,32.17 27.13,32.17 27.18,32.22 29.09,32.22 29.12,32.18 29.12,32.02 29.09,31.98 27.66,31.98 27.54,32.01 27.42,31.98 27.28,31.98 27.17,31.87 26.13,31.87 25.98,31.71 25.98,31.3 25.72,31.04 23.63,31.04 23.06,30.47 23.06,29.33 22.11,28.38 21.67,28.38 21.48,28.43 21.3,28.38 20.92,28.38 20.82,28.39 20.73,28.38 19.19,28.38 19.06,28.5 19.06,30.85 19.19,30.98 21.92,30.98 23.17,32.24 26.19,32.24
LINE1_R on BOTTOM (solid shape): 29.12,31.75 29.12,31.65 29.06,31.59 27.41,31.59 27.01,31.19 27.01,28.6 26.91,28.5 26.51,28.5 26.45,28.44 23.98,28.44 23.97,28.46 23.97,30.84 23.98,30.85 25.85,30.85 26.11,31.11 26.11,31.61 26.23,31.74 27.26,31.74 27.33,31.82 29.06,31.82
LX_1.0VS_VGAP on BOTTOM (solid shape): 246.97,48.54 246.97,47.02 247.56,46.43 247.56,44.26 247.53,44.24 246.83,44.24 246.78,44.29 243.1,44.29 242.78,43.97 242.21,43.97 242.13,44.05 242.13,44.97 242.29,45.13 242.29,45.43 242.59,45.74 244.12,45.74 244.33,45.95 244.33,48.52 244.83,49.01 246.5,49.01
LX_3V on TOP (solid shape): 49.84,31.37 52.09,31.37 52.21,31.26 52.21,28.76 49.79,26.34 44.01,26.34 43.58,26.77 43.58,29.23 43.68,29.33 45.22,29.33 46.43,30.53 46.43,32.12 46.68,32.38 48.84,32.38
LX_3V on BOTTOM (solid shape): 51.82,31.87 51.82,27.55 50.55,26.28 44.59,26.28 44.27,26.6 44.27,29.58 46.87,32.19 51.51,32.19
LX_3V on BOTTOM (solid shape): 57.35,47.94 57.79,47.94 57.86,47.87 57.86,47.3 57.79,47.23 57.42,47.23 57.41,47.24 56.4,47.24 56.27,47.37 55,47.37 54.93,47.43 54.93,47.56 55,47.62 56.01,47.62 56.33,47.94 57.35,47.94
LX_3V on IN4 (solid shape): 57.98,46.73 57.98,46.48 57.86,46.35 56.71,46.35 56.01,47.05 56.01,47.68 56.14,47.81 56.9,47.81
LX_3V on IN4 (solid shape): 51.37,28.53 51.37,28.48 50.41,27.52 49.62,27.52 49.54,27.52 49.46,27.52 48.99,27.52 48.9,27.52 48.82,27.52 48.48,27.52 48.36,27.64 48.36,27.66 48.37,27.74 48.36,27.82 48.36,28.19 48.63,28.45 49.84,28.45 50.62,29.23 50.67,29.23
LX_5V on TOP (solid shape): 43.41,39.39 45.91,39.39 46.05,39.26 46.05,37.71 46.3,37.46 46.3,35.25 46.22,35.17 41.8,35.17 40.62,36.35 40.62,38.74 40.29,39.07 40.29,39.41 40.62,39.74 43.06,39.74
LX_5V on BOTTOM (solid shape): 47.13,37.2 47.13,34.09 46.94,33.9 42.55,33.9 39.7,36.76 39.7,39.04 40.3,39.65 44.68,39.65
LX_5V on BOTTOM (solid shape): 50.98,47.82 51.14,47.77 51.3,47.82 51.43,47.82 51.66,47.6 52.74,47.6 52.78,47.56 52.78,47.43 52.71,47.37 50.67,47.37 50.43,47.13 49.96,47.13 49.88,47.2 49.88,47.76 49.94,47.82
LX_5V on IN4 (solid shape): 51.63,47.62 51.63,47.18 50.93,46.48 50.3,46.48 50.11,46.67 50.11,47.3 50.62,47.81 51.44,47.81
LX_5V on IN4 (solid shape): 44.4,39.93 44.4,39.23 43.82,38.66 43.32,38.66 43.19,38.79 43.19,39.04 42.93,39.3 42.93,39.93 43.51,40.5 43.82,40.5
LX_+1.8VGS on BOTTOM (solid shape): 231.2,50.11 231.2,48.44 232.48,47.17 232.48,45.24 233.03,44.69 233.03,43.8 232.89,43.67 230.9,43.67 230.6,43.37 229.95,43.37 229.91,43.41 229.91,44.31 230.03,44.44 230.03,45.4 230.55,45.72 230.02,46.02 230.02,46.29 229.62,46.69 229.62,50.12 229.66,50.17 231.14,50.17
LX_CHG on TOP (solid shape): 62.05,25.58 62.05,24.82 61.98,24.76 60.44,24.76 60.4,24.72 59.1,24.72 59.04,24.77 59.04,24.88 59.11,24.95 59.95,24.95 60.97,25.96 61.67,25.96
LX_CHG on TOP (solid shape): 69.11,25.7 69.11,22.8 69.27,22.63 69.5,22.63 69.6,22.53 71.95,22.53 72.53,21.96 72.53,20.69 72.34,20.5 66.24,20.5 65.67,21.07 65.67,25.96 65.92,26.22 68.59,26.22
LX_CHG on BOTTOM (solid shape): outline of 100 points within 63.8,21.58 69.68,27.71
LX_CHG on IN1 (solid shape): 61.86,25.75 62.11,25.75 62.11,24.88 61.98,24.76 60.91,24.76 60.58,25.08 60.58,25.48 61.06,25.96 61.64,25.96
LX_CHG on IN1 (solid shape): 66.81,23.68 66.81,22.86 66.1,22.15 66.1,21.85 66,21.75 65.77,21.75 65.52,21.99 65.52,23.5 65.22,23.8 65.22,23.87 65.79,24.44 66.05,24.44
LX_VCCIO on BOTTOM (solid shape): 121.33,116.88 121.33,114.31 121.56,114.08 122.36,114.08 122.61,113.68 122.87,114.08 127.36,114.08 127.55,113.89 127.55,112.49 127.32,112.26 125.06,112.26 123.58,110.78 120.86,110.78 120.44,111.2 120.44,116.84 120.62,117.02 121.19,117.02
Net_264 on IN1 (solid shape): 247.28,163.12 246.01,163.12 246.01,164.39 247.28,164.39
Net_264 on IN1 (solid shape): 249.82,163.12 248.55,163.12 248.55,164.39 249.82,164.39
Net_264 on IN1 (solid shape): 252.36,163.12 251.09,163.12 251.09,164.39 252.36,164.39
Net_264 on IN1 (solid shape): 254.9,163.12 253.63,163.12 253.63,164.39 254.9,164.39
Net_264 on IN1 (solid shape): 257.44,163.12 256.17,163.12 256.17,164.39 257.44,164.39
Net_264 on IN1 (solid shape): 259.98,163.12 258.71,163.12 258.71,164.39 259.98,164.39
Net_1917 on TOP (solid shape): 157.78,15.14 149.78,15.14 149.78,23.14 157.78,23.14
Net_1918 on TOP (solid shape): 147.64,22.05 132.64,22.05 132.64,32.05 147.64,32.05
NVVDD_B+ on TOP (solid shape): 222.58,152.45 222.58,151.18 222.39,150.99 217.12,150.99 216.99,151.12 216.99,152.45 217.15,152.61 222.42,152.61
NVVDD_B+ on TOP (solid shape): 262.96,154.75 263.03,154.75 263.36,154.42 263.37,154.42 263.72,154.07 263.72,151.31 263.53,151.12 258.26,151.12 258.14,151.25 258.14,152.58 259.79,154.23 259.79,154.4 260.16,154.78 262.96,154.78
NVVDD_B+ on TOP (solid shape): 236.23,153.8 236.23,151.12 236.04,150.93 230.77,150.93 230.64,151.06 230.64,152.39 232.48,154.23 232.49,154.23 232.49,154.44 232.51,154.46 232.51,154.59 232.52,154.63 232.55,154.67 235.37,154.67
NVVDD_B+ on TOP (solid shape): 246.84,154.71 246.9,154.71 247.48,154.71 247.53,154.71 248.11,154.71 248.17,154.71 248.75,154.71 248.8,154.71 249.13,154.71 249.94,153.9 249.94,151.25 249.75,151.06 244.48,151.06 244.36,151.18 244.36,152.74 246.33,154.71
NVVDD_B+ on BOTTOM (solid shape): 209.24,148.14 209.24,148.04 209.5,147.79 209.5,145.02 209.3,144.83 205.05,144.83 204.86,145.02 204.86,147.18 204.92,147.25 207.46,147.25 207.49,147.27 207.49,147.91 207.72,148.14 209.05,148.14
NVVDD_B+ on BOTTOM (solid shape): 244.29,152.71 246.13,152.71 246.45,152.39 249.37,152.39 251.55,150.22 251.55,149.86 251.42,149.74 249.92,149.74 249.74,149.91 244.8,149.91 244.61,150.1 244.61,150.61 244.1,151.12 241.37,151.12 241.25,151.25 241.25,152.39 241.37,152.52 242.64,152.52 242.77,152.64 242.77,153.53 242.83,153.6 243.4,153.6
NVVDD_B+ on BOTTOM (solid shape): 230.58,152.64 232.42,152.64 232.74,152.33 236.04,152.33 236.23,152.14 236.23,151.29 236.64,150.88 237.12,150.88 237.63,150.37 237.63,149.79 237.58,149.74 236.15,149.74 236.04,149.85 231.08,149.85 230.89,150.04 230.89,150.55 230.39,151.06 227.66,151.06 227.53,151.18 227.53,152.33 227.66,152.45 228.93,152.45 229.05,152.58 229.05,153.47 229.12,153.53 229.69,153.53
NVVDD_B+ on BOTTOM (solid shape): 258.07,152.77 259.91,152.77 260.23,152.45 263.53,152.45 263.72,152.26 263.72,151.79 264.85,150.67 264.85,150.66 265.37,149.69 266.11,148.88 266.12,148.87 266.12,148.26 265.85,147.98 264.42,147.98 264.41,148 264.08,148 263.89,148.19 263.89,149.43 263.34,149.98 258.58,149.98 258.39,150.17 258.39,150.68 257.88,151.18 255.15,151.18 255.02,151.31 255.02,152.43 255.06,152.43 255.06,152.49 255.15,152.58 256.42,152.58 256.55,152.71 256.55,153.6 256.61,153.66 257.18,153.66
NVVDD_B+ on BOTTOM (solid shape): 217.14,155.03 217.2,154.86 217.33,154.74 217.17,154.28 217.62,154.09 217.65,154.08 217.81,153.91 222,153.91 222.51,153.4 222.51,152.42 222.57,152.37 222.57,152.14 222.58,152.14 222.58,150.32 222.7,150.19 223.73,150.19 224.01,149.91 224.01,149.13 223.96,149.08 222.64,149.08 221.87,149.85 217.43,149.85 217.24,150.04 217.24,150.55 216.73,151.06 214,151.06 213.88,151.18 213.88,152.33 214,152.45 215.27,152.45 215.4,152.58 215.4,153.47 215.46,153.53 215.46,154.07 215.46,154.07 215.46,154.83 215.51,154.87 215.59,154.94 215.65,155.02 215.66,155.03
NVVDD_B+ on IN6 (solid shape): outline of 4452 points within 207.46,144.45 264.93,152.95
NVVDD_B+ on IN5: 207.08,145.53 207.08,153.43 208.2,154.55 241.27,154.55 241.78,154.04 264.51,154.04 264.87,153.68 264.87,150.59 264.44,150.17 213.71,150.17 209.07,145.53
NVVDDS_B+ on TOP (solid shape): outline of 587 points within 274.47,36.19 290.2,49.63
NVVDDS_B+ on BOTTOM (solid shape): 278.3,40.32 278.3,36.57 278.1,36.38 275.37,36.38 275.02,36.73 272.88,36.73 272.49,37.12 272.49,40.53 272.64,40.68 272.66,40.69 277.92,40.69
NVVDDS_B+ on BOTTOM (solid shape): 289.41,50.89 290.55,50.89 290.9,50.54 290.9,41.14 290.67,40.91 290.67,40.83 290.6,40.76 289.66,40.76 289.54,40.87 289.54,41.3 289.24,41.61 287.92,41.61 287.77,41.46 287.77,40.24 287.97,40.03 288.01,40.03 288.04,40.01 288.32,40 288.37,40 288.4,40.01 288.88,40.01 288.91,40 288.96,40 289.11,40.01 289.14,40.03 289.26,39.91 289.26,39.5 289.19,39.42 287.26,39.42 287.03,39.65 287.03,40.35 286.88,40.5 285.63,40.5 285.38,40.76 285.38,46.19 286.57,46.19 286.57,44.57 286.82,44.32 287.42,44.32 287.69,44.59 287.69,45.97 287.7,46 287.7,46.05 287.7,46.1 287.7,46.15 287.69,46.17 287.69,46.23 287.64,46.27 287.62,46.3 287.58,46.35 287.49,46.42 287.38,46.43 287.31,46.43 287.28,46.42 286.81,46.42 286.57,46.19 285.38,46.19 285.38,46.98 288.17,46.98 288.17,46.01 288.76,45.42 289.22,45.42 289.59,45.79 289.59,47.04 289.33,47.3 288.49,47.3 288.17,46.98 285.38,46.98 285.38,50.64 285.42,50.69 285.99,50.69 286.12,50.56 286.12,50.23 286.33,50.02 287.96,50.02 288.25,50.3 288.25,50.74 288.46,50.95 289.34,50.95
NVVDDS_BST1 on TOP (solid shape): 305.52,54.78 305.76,54.78 305.82,54.7 305.91,54.63 306.87,53.67 306.87,53.43 307.11,53.19 307.11,52.42 307.03,52.34 306.41,52.34 306.36,52.4 306.36,53.37 305.19,54.54 304.55,54.54 304.49,54.6 304.49,54.73 304.55,54.79 305.51,54.79
NVVDDS_BST2 on TOP (solid shape): 302.38,54.68 302.38,54.38 300.89,52.89 299.8,52.89 299.68,53.01 299.68,53.84 299.72,53.88 299.9,53.88 300.45,54.43 301.15,54.43 301.49,54.77 302.28,54.77
NVVDDS_LG1 on TOP (solid shape): 303.95,54.32 303.95,53.44 304.67,52.72 304.67,51.93 304.55,51.82 303.99,51.82 303.92,51.88 303.92,52.8 303.73,52.99 303.73,54.32 303.76,54.35 303.92,54.35
NVVDDS_LG1 on BOTTOM (solid shape): 295.59,46.85 295.59,45.97 295.43,45.81 294.58,45.81 294.43,45.95 294.41,45.98 294.41,46.97 294.59,47.15 295.29,47.15
NVVDDS_LG1 on BOTTOM (solid shape): 295.02,41.22 295.02,40.77 294.92,40.68 294.92,40.16 294.81,40.05 294.01,40.05 293.86,40.19 293.86,40.54 294.13,40.81 294.13,41.15 294.37,41.39 294.85,41.39
NVVDDS_LG1 on IN1 (solid shape): 296.32,46.55 296.32,45.61 296.27,45.56 294.5,45.56 294.43,45.63 294.43,46.5 294.53,46.6 296.28,46.6
NVVDDS_LG1 on IN1 (solid shape): 304.85,52.69 304.85,52.34 304.16,51.65 304.01,51.65 303.34,52.32 303.34,52.45 303.61,52.72 303.61,53.15 303.88,53.41 304.12,53.41
NVVDDS_LG1 on IN2 (solid shape): 295.63,46.32 295.63,45.08 295.46,44.91 294.75,44.91 294.5,45.16 294.5,46.33 294.66,46.49 295.47,46.49
NVVDDS_LG1 on IN2 (solid shape): 294.65,41.94 294.65,41.33 294.95,41.03 294.95,40.14 294.82,40.01 294.07,40.01 293.86,40.21 293.86,40.52 293.62,40.76 293.62,41.9 293.79,42.06 294.53,42.06
NVVDDS_LG2 on TOP (solid shape): 303.15,54.3 303.15,53.48 303.17,53.46 303.17,52.99 303.15,52.97 303.15,52.86 303.09,52.81 303.09,51.82 302.3,51.82 302.23,51.89 302.23,52.79 302.93,53.5 302.93,54.29 302.98,54.34 303.11,54.34
NVVDDS_LG2 on BOTTOM (solid shape): 282.08,45.83 282.08,45.17 282.01,45.1 282.01,44.76 281.81,44.56 281.79,44.56 281.66,44.53 281.55,44.46 281.21,44.46 281,44.67 281,45.86 281.07,45.93 281.97,45.93
NVVDDS_LG2 on BOTTOM (solid shape): 282.22,51.44 282.22,51.18 281.86,50.82 281.86,50.37 281.67,50.18 281.24,50.18 281.02,50.4 281.02,51.2 281.09,51.33 281.11,51.48 281.11,51.51 281.22,51.62 282.04,51.62
NVVDDS_LG2 on IN1 (solid shape): 303.37,53.02 303.37,52.79 302.65,52.07 302.38,52.07 301.87,51.57 301.67,51.57 301.2,52.04 301.2,52.36 301.67,52.83 302.18,52.83 302.79,53.45 302.94,53.45
NVVDDS_LG2 on IN1 (solid shape): 282.38,51.58 283.03,51.58 283.91,50.7 283.91,50.68 283.37,50.14 283,50.14 282.63,50.51 281.14,50.51 281.05,50.6 281.05,51.24 281.1,51.37 281.11,51.5 281.1,51.53 281.16,51.59 282.38,51.59
NVVDDS_LG2 on IN2 (solid shape): 281.88,46.84 281.88,45.99 282.13,45.74 282.13,45.38 282.01,45.26 281.23,45.26 280.98,45.5 280.98,46.83 281.1,46.94 281.78,46.94
NVVDDS_LG2 on IN2 (solid shape): 282.22,51.34 282.22,51.08 281.9,50.76 281.9,49.93 281.81,49.84 280.94,49.84 280.87,49.91 280.87,51.1 280.9,51.11 281.05,51.24 281.11,51.44 281.11,51.46 281.2,51.55 282.01,51.55
NVVDDS_SW1 on TOP (solid shape): 304.36,54.28 304.36,53.95 306.53,51.79 306.53,50.19 306.44,50.11 305.98,50.11 305.85,50.24 305.85,50.68 305.44,51.08 305.44,51.2 305.24,51.4 305.19,51.47 305.11,51.53 305.01,51.63 305.01,52.55 304.78,52.78 304.78,52.8 304.68,53.01 304.47,53.11 304.45,53.11 304.14,53.43 304.14,54.31 304.17,54.35 304.3,54.35
NVVDDS_SW2 on TOP (solid shape): 302.75,54.31 302.75,53.49 302.36,53.1 302.34,53.1 302.21,53.01 302.12,52.87 302.12,52.86 300.98,51.72 300.98,50.95 300.71,50.68 300.01,50.68 299.91,50.79 299.91,51.49 299.67,51.72 299.67,52.6 299.84,52.76 300.94,52.76 302.52,54.35 302.71,54.35
NVVDDS_VIDBUF on TOP (solid shape): 306.21,59.43 306.21,58.47 304.3,56.57 304.17,56.57 304.11,56.63 304.11,57.39 305.57,58.86 305.57,59.43 305.63,59.49 306.14,59.49
ON/OFF# on TOP (solid shape): 212.65,168.54 212.65,167.35 212.65,167.35 212.65,166.97 212.5,166.82 212.5,166.46 212.4,166.37 212.15,166.37 212.07,166.45 212.07,166.8 211.98,166.88 211.98,168.55 212.12,168.69 212.51,168.69
OUT_A on TOP (solid shape): 36.36,8.47 36.36,7.49 36.53,7.32 37,7.32 37.12,7.2 37.12,7.2 37.66,6.66 37.66,5.71 37.59,5.65 36.9,5.65 36.83,5.71 36.83,6.2 36.67,6.37 36.8,6.76 36.48,7.01 36.36,7.14 36.28,7.28 36.14,7.37 36.14,8.47 36.19,8.52 36.31,8.52
OUT_A on BOTTOM (solid shape): 40.06,7.77 40.06,7.72 39.31,6.98 38.87,6.98 38.55,6.66 38.55,6.28 38.43,6.15 37.53,6.15 36.79,6.89 36.79,6.89 36.71,6.98 36.71,7.23 36.79,7.3 37.4,7.3 37.67,7.04 38.49,7.04 38.87,7.42 38.87,7.83 39.42,8.37 39.46,8.37
OUT_B on TOP (solid shape): 35.16,8.45 35.16,7.55 35.66,7.05 35.76,6.79 36.03,6.68 36.11,6.61 36.24,6.38 36.5,6.3 36.52,6.28 36.52,4.88 36.52,4.88 36.52,4.31 36.58,4.25 36.58,4.05 36.39,3.86 36.2,3.86 35.94,4.12 35.94,5.27 35.5,5.71 35.5,6.6 35.27,6.83 35.27,7.01 34.95,7.33 34.95,8.45 35,8.5 35.11,8.5
OUT_C on TOP (solid shape): 33.15,8.47 33.15,7.45 32.66,6.97 32.66,6.49 32.73,6.42 32.73,5.45 32.91,5.27 33.66,5.27 33.82,5.12 33.82,4.47 33.78,4.44 33.28,4.44 33.09,4.63 32.2,4.63 32.14,4.69 32.14,5.26 32.05,5.35 32.05,6.75 32.15,6.84 32.15,7.25 32.28,7.38 32.69,7.38 32.95,7.64 32.95,8.47 33,8.52 33.1,8.52
OUT_D on TOP (solid shape): 27.14,9.26 28.08,9.26 28.08,8.37 27.89,8.18 26.81,8.18 26.68,8.31 26.68,9.2 26.81,9.33 27.07,9.33
OUT_D on TOP (solid shape): 31.96,8.48 31.96,7.55 32.02,7.49 32.02,6.93 31.88,6.79 31.88,5.26 31.95,5.19 31.95,4.82 31.89,4.75 31.38,4.75 31.31,4.82 30.81,4.82 30.74,4.89 30.74,6.59 30.81,6.66 30.98,6.66 31.74,7.42 31.74,8.47 31.79,8.52 31.92,8.52
OUT_D on IN1 (solid shape): outline of 174 points within 26.42,4.63 32.01,9.33
P1 on TOP (solid shape): 70.32,41.04 70.32,37.84 70.14,37.66 69.48,37.66 68.87,37.05 68.87,36.69 68.9,36.66 68.94,36.59 68.98,36.53 68.98,36.33 68.89,36.25 68.56,36.25 67.45,36.25 67.24,36.05 66.54,36.05 66.43,36.16 66.43,39.61 66.75,39.93 67.3,39.93 67.87,40.5 67.87,40.55 67.89,40.57 67.89,41.14 68.23,41.48 69.88,41.48
P1 on BOTTOM (solid shape): 69.02,41.13 69.02,40 69.01,39.99 68.97,39.81 69.01,39.62 69.02,39.61 69.02,39.45 69.43,39.04 70.37,39.04 70.49,38.92 70.49,35.93 70.18,35.61 68.73,35.61 68.23,36.11 68.13,36.28 67.96,36.38 67.63,36.71 66.82,36.71 66.56,36.97 66.56,40.24 67.89,41.57 68.57,41.57
P1 on IN1 (solid shape): 69.35,41.27 69.35,36.5 69.03,36.19 67.76,36.19 67.45,36.5 67.45,41.2 67.83,41.58 69.03,41.58
P1 on IN3 (solid shape): 69.6,41.39 69.6,36.44 69.22,36.06 67.95,36.06 67.57,36.44 67.57,41.33 67.83,41.58 69.41,41.58
P1 on IN4 (solid shape): 69.73,41.39 69.73,36.38 69.54,36.19 67.76,36.19 67.45,36.5 67.45,41.24 67.47,41.3 67.48,41.37 67.89,41.77 69.35,41.77
P2 on TOP (solid shape): outline of 89 points within 58.62,36.19 65.67,43.68
P2 on BOTTOM (solid shape): 59.91,44.55 60.64,44.55 61.29,45.2 62.87,45.2 64.14,43.93 64.14,42.05 66.07,40.12 66.07,35.91 65.83,35.67 61.56,35.67 61.51,35.61 61.16,35.61 60.97,35.8 60.97,39.81 60.35,40.42 59.13,40.42 59.13,43.74 58.36,43.74 58.36,40.42 57.03,40.42 56.78,40.67 56.78,44.89 57.1,45.2 59.27,45.2
P2 on IN1 (solid shape): 63.76,42.92 63.76,41.33 63.51,41.08 60.84,41.08 60.52,41.39 60.52,42.85 60.84,43.17 63.51,43.17
P2 on IN3 (solid shape): 63.89,42.92 63.89,41.39 63.64,41.14 60.71,41.14 60.52,41.33 60.52,43.04 60.65,43.17 63.64,43.17
P2 on IN4 (solid shape): 63.89,42.92 63.89,41.14 63.64,40.88 60.78,40.88 60.52,41.14 60.52,42.92 60.84,43.23 63.57,43.23
POK on BOTTOM (solid shape): 227.59,39.35 227.59,38.48 226.74,37.63 223.66,37.63 223.17,38.12 223.17,39.32 223.2,39.37 223.3,39.47 227.46,39.47
PQ700_D on TOP (solid shape): 69.6,42.54 69.6,41.71 69.51,41.62 68.14,41.62 67.76,41.23 67.76,40.65 67.7,40.59 67.66,40.52 67.65,40.51 67.52,40.38 66.49,40.38 66.43,40.44 66.43,41.39 66.83,41.79 66.83,42.59 66.96,42.73 69.41,42.73
PQ703_S on TOP (solid shape): 82.24,33.84 82.24,30.92 82.05,30.72 80.91,30.72 80.65,30.98 78.62,30.98 78.56,31.04 78.56,31.49 78.3,31.74 77.22,31.74 76.72,32.25 76.72,33.9 77.16,34.34 81.73,34.34
PQ703_S on BOTTOM (solid shape): outline of 132 points within 72.34,23.36 80.97,33.56
PSID-1 on TOP (solid shape): 318.21,52.63 318.21,52.12 317.83,51.74 317.83,50.73 317.89,50.66 318.52,50.66 318.65,50.54 318.65,49.33 318.52,49.2 317.89,49.2 317.51,49.58 317.51,50.03 316.94,50.6 316.94,52.51 317.25,52.82 318.02,52.82
PSID-2 on TOP (solid shape): 316.56,53.27 316.56,51.55 315.1,50.09 313.83,50.09 313.57,50.35 313.57,50.79 314.46,51.68 314.46,52.57 314.65,52.76 315.48,52.76 315.67,52.95 315.67,53.27 315.92,53.52 316.3,53.52
PSID-3 on TOP (solid shape): 315.16,49.01 315.16,48.44 314.91,48.19 312.3,48.19 312.17,48.31 312.17,48.76 312.3,48.89 313.19,48.89 313.57,49.27 314.91,49.27
PSID-4 on TOP (solid shape): 317.25,49.9 317.25,49.14 317.57,48.82 318.91,48.82 319.86,49.77 320.3,49.77 320.62,49.46 320.62,48.44 320.3,48.12 316.43,48.12 315.6,48.95 315.6,49.84 315.98,50.22 316.94,50.22
PWR_R# on TOP (solid shape): 211.15,172.01 211.15,170.3 211.01,170.16 210.66,170.16 210.48,170.34 210.48,171.78 209.87,172.39 209.87,172.7 210,172.83 210.33,172.83
PWR_VGA_CORE_BOOT2 on BOTTOM (solid shape): 246.98,38.02 246.98,37.01 246.9,36.93 246.9,36.89 245.79,35.78 245.48,35.78 245.41,35.85 245.41,36.62 245.48,36.69 245.53,36.72 245.6,36.72 245.69,36.63 245.82,36.63 245.83,36.62 246.26,36.72 246.26,37.17 246.25,37.18 246.25,37.21 246.07,37.38 246.01,37.38 246,37.4 246,37.55 245.97,37.59 245.97,38.05 246,38.09 246.91,38.09
PWR_VGA_CORE_BOOT2_1 on BOTTOM (solid shape): 248.22,39.51 248.22,38.84 248.15,38.76 246.02,38.76 245.95,38.83 245.95,39.41 246.14,39.6 248.13,39.6
PWR_VGA_CORE_LGATE1 on BOTTOM (solid shape): 265.32,29.02 265.88,29.02 266.1,28.81 266.1,28.17 265.79,27.87 265.11,27.87 264.99,27.98 264.99,28.92 265.16,29.09 265.26,29.09
PWR_VGA_CORE_PHASE1 on BOTTOM (solid shape): 264.49,35.93 264.49,32.82 264.91,32.4 264.91,29.26 264.82,29.18 264.82,28.25 264.12,27.55 263.13,27.55 262.99,27.69 262.99,27.81 262.67,28.13 262.07,28.13 262.01,28.19 262.01,32.76 261.19,33.58 260.55,33.58 260.33,33.8 260.33,36.22 260.49,36.38 264.04,36.38
PWR_VGA_CORE_PHASE2 on TOP (solid shape): 253.56,35.93 253.56,33.96 253.5,33.9 253.06,33.9 252.93,34.03 252.93,34.41 252.61,34.73 252.1,34.73 251.91,34.53 251.91,34.09 251.72,33.9 250.9,33.9 250.77,34.03 250.77,35.87 250.96,36.06 253.44,36.06
PWR_VGA_CORE_PHASE2 on BOTTOM (solid shape): 248.12,38.03 248.12,37.42 247.53,36.83 247.53,35.99 247.28,35.74 247.01,35.74 246.67,35.41 245.88,35.41 245.82,35.47 245.82,35.59 245.87,35.63 245.87,35.63 247.19,36.95 247.19,38.06 247.22,38.08 248.07,38.08
PWR_VGA_CORE_PHASE2 on BOTTOM (solid shape): 256.49,36.12 256.49,33.96 255.47,32.95 255.47,28.25 255.22,27.99 253.21,27.99 252.59,27.99 252.41,28.17 252.41,32.29 252.41,32.29 252.41,32.83 251.48,33.76 251.47,33.79 251.44,33.83 251.41,33.87 251.38,33.9 251.34,33.92 251.31,33.94 250.93,34.31 251.93,34.31 251.93,34.25 251.93,34.2 251.95,34.15 251.97,34.1 252,34.06 252.04,34.02 252.08,33.99 252.13,33.96 252.18,33.94 252.23,33.93 252.28,33.92 252.33,33.93 252.39,33.94 252.44,33.96 252.48,33.99 252.52,34.02 252.56,34.06 252.59,34.1 252.61,34.15 252.63,34.2 252.64,34.25 252.64,34.31 252.63,34.36 252.61,34.41 252.59,34.46 252.56,34.5 252.52,34.54 252.48,34.58 252.44,34.6 252.39,34.62 252.33,34.63 252.28,34.64 252.23,34.63 252.18,34.62 252.13,34.6 252.08,34.58 252.04,34.54 252,34.5 251.97,34.46 251.95,34.41 251.93,34.36 251.93,34.31 250.93,34.31 250.64,34.6 250.64,36.06 251.02,36.44 256.17,36.44
RING2 on TOP (solid shape): 28.92,24.03 28.92,22.66 29.05,22.53 29.54,22.53 29.68,22.39 29.68,21.79 29.54,21.64 28.25,21.64 28.18,21.71 28.18,23.21 28.18,23.23 28.01,23.4 28.01,24.06 28.07,24.11 28.84,24.11
RING2 on BOTTOM (solid shape): 26.65,33.14 26.73,33.1 26.75,33.01 26.74,32.87 26.78,32.74 26.79,32.72 27.02,32.56 27.29,32.61 27.5,32.61 27.69,32.55 27.89,32.61 29.06,32.61 29.12,32.55 29.12,32.45 29.04,32.36 27.26,32.36 27.25,32.35 27.13,32.35 27.08,32.3 26.32,32.3 26.24,32.38 26.07,32.38 25.91,32.55 25.91,33.13 25.92,33.14
RING2 on IN1 (solid shape): 28.33,22.91 28.33,22.73 28.52,22.53 29.28,22.53 29.41,22.41 29.41,21.83 29.22,21.64 27.63,21.64 27.31,21.96 27.31,23.1 28.14,23.1
RING2 on IN1 (solid shape): 26.85,32.64 26.85,32.04 26.58,31.78 24.59,31.78 24.4,31.96 24.4,33.1 24.55,33.25 24.62,33.25 24.67,33.26 26.22,33.26
RING2_R on TOP (solid shape): 28.06,23.16 28.06,21.22 28.33,20.95 28.33,19.36 28.01,19.04 27.31,19.04 27.16,19.2 27.16,19.54 27.16,19.61 27.16,19.68 27.16,20.47 26.9,20.72 26.9,23 27.11,23.21 28.01,23.21
RING2_R on TOP (solid shape): 22.16,21.78 22.16,21.19 21.38,20.42 20.02,20.42 19.48,19.88 18.78,19.88 18.6,20.06 18.6,20.08 18.23,20.45 17.47,20.45 17.24,20.68 17.24,21.5 17.43,21.69 18.61,21.69 19.14,21.17 19.41,21.17 19.73,21.48 20.74,21.48 21.14,21.89 22.06,21.89
RING2_R on BOTTOM (solid shape): 29.02,19.88 29.02,19.27 28.96,19.22 28.25,19.22 28.08,19.04 27.31,19.04 27.12,19.23 27.12,19.42 27.25,19.55 27.5,19.55 27.89,19.93 28.96,19.93
RING2_R on IN1 (solid shape): 17.87,21.63 17.87,20.45 17.29,19.88 16.47,19.88 16.35,19.99 16.35,21.43 16.62,21.69 17.8,21.69
RING2_R on IN1 (solid shape): 22.17,22.89 22.17,21.59 21.93,21.35 21.14,21.35 20.95,21.54 20.95,22.7 21.22,22.96 22.09,22.96
RING2_R on IN1 (solid shape): 28.28,20.4 28.28,19.41 27.89,19.02 27.36,19.02 27.14,19.24 27.14,19.48 27.13,19.76 26.93,19.95 26.91,19.97 26.91,20.3 27.52,20.91 27.77,20.91
RJ45_CT on TOP (solid shape): 263.5,167.17 263.5,166.44 263.27,166.22 248.15,166.22 247.82,166.55 247.82,167.27 247.94,167.39 263.28,167.39
RJ45_CT on BOTTOM (solid shape): 264.19,167.16 264.19,164.26 264.17,164.24 261.86,164.24 261.82,164.27 261.82,167.35 262.01,167.53 263.82,167.53
SA_SW on BOTTOM (solid shape): 180.83,143.36 180.86,143.36 180.86,142.29 181.04,142.11 181.04,142.02 181.13,142.02 181.19,141.96 184.82,141.96 184.87,141.91 184.87,136.83 184.76,136.72 183.6,136.72 183.6,137.61 182.83,137.61 182.83,136.72 180.26,136.72 180.17,136.81 180.17,143.37 180.26,143.36 180.67,143.36 180.72,143.37 180.77,143.39 180.83,143.39
SLEEVE on BOTTOM (solid shape): 29.64,23.67 29.64,22.7 29.28,22.34 28.14,22.34 27.12,21.33 26.74,21.33 26.45,21.03 26.45,20.19 26.41,20.16 25.99,20.16 25.9,20.24 25.9,21.05 26.04,21.2 26.04,21.77 26.17,21.9 26.68,21.9 27.06,22.28 27.06,22.89 27.37,23.19 28.24,23.19 28.96,23.91 29.4,23.91
SLEEVE on IN1 (solid shape): 29.05,33.36 29.05,32.01 28.92,31.87 27.17,31.87 26.99,32.05 26.99,32.68 26.85,32.82 26.85,33.38 26.99,33.52 28.89,33.52
SLEEVE on IN1 (solid shape): 31.41,24.05 31.41,23.33 31.12,23.04 31.12,23.04 30.87,23.14 30.62,23.04 30.48,23.04 30.24,23.14 30,23.05 29.98,23.04 29.92,23.04 29.57,22.69 29.06,22.69 28.84,22.91 28.84,24.09 29.03,24.28 31.18,24.28
SLEEVE_R on TOP (solid shape): 21.18,19.97 21.18,18.41 20.28,17.5 19.72,17.5 19.12,18.1 17.61,18.1 17.45,18.27 17.45,19.37 17.5,19.42 18.14,19.42 18.35,19.33 18.55,19.42 19.36,19.42 20.07,20.13 21.01,20.13
SLEEVE_R on BOTTOM (solid shape): 31.13,22.78 31.13,22.21 30.26,21.34 30.25,21.34 30.21,21.31 29.98,21.34 29.8,21.19 29.32,21.19 29.02,20.88 27.57,20.88 27.31,20.63 27.31,20.31 27.19,20.18 26.68,20.18 26.66,20.21 26.66,20.99 26.74,21.07 27.06,21.07 27.65,21.67 28.26,21.67 28.27,21.66 28.46,21.61 28.64,21.67 28.89,21.67 29.18,21.62 29.41,21.8 29.41,21.81 29.48,21.88 29.48,22.23 29.92,22.66 29.92,22.91 30.04,23.04 30.87,23.04
SLEEVE_R on IN3 (solid shape): 17.95,19.04 17.95,17.9 17.6,17.54 16.63,17.54 16.54,17.63 16.54,18.82 16.82,19.1 17.89,19.1
SLEEVE_R on IN3 (solid shape): 21.04,20.78 21.04,19.66 20.93,19.55 20.1,19.55 19.87,19.78 19.87,20.96 19.9,20.98 20.84,20.98
SLEEVE_R on IN3 (solid shape): 31.33,22.82 31.33,22.11 30.49,21.26 30.48,21.26 29.72,20.5 28.71,20.5 28.71,21.39 28.84,21.52 29.08,21.52 29.17,21.61 29.19,21.62 29.34,21.71 29.44,21.87 29.44,21.88 29.65,22.09 29.65,22.89 29.84,23.08 31.07,23.08
SNB_1.0VS_VGAP on BOTTOM (solid shape): 248.19,47.36 248.19,46.54 248.26,46.47 248.95,46.47 249.02,46.41 249.02,45.58 248.95,45.52 248.26,45.52 247.75,46.03 247.75,46.4 247.75,46.52 247.49,46.77 247.49,47.43 247.56,47.49 248.07,47.49
SNB_1.2V on TOP (solid shape): 98.5,37.9 98.5,36.44 97.74,35.68 97.1,35.68 96.97,35.8 96.97,36.57 96.66,36.88 96.66,37.9 96.78,38.03 98.37,38.03
SNB_3V on TOP (solid shape): 44.27,33.01 44.27,32.12 44.4,31.99 45.28,31.99 45.41,31.87 45.41,30.92 45.28,30.79 43.51,30.79 43.13,31.17 43.13,33.01 43.19,33.07 44.21,33.07
SNB_5V on TOP (solid shape): 44.52,34.41 44.52,33.42 44.41,33.3 42.07,33.3 41.8,33.57 41.8,34.67 41.86,34.73 44.2,34.73
SNB_+1VALWP on BOTTOM (solid shape): 258.89,20.87 258.89,19.9 258.77,19.78 258.07,19.78 257.83,19.53 257.83,18.81 257.77,18.75 257.16,18.75 257.11,18.8 257.11,20.84 257.26,20.99 258.78,20.99
SNUB_CHG on TOP (solid shape): 64.02,23.04 64.02,22.53 64.27,22.28 65.22,22.28 65.35,22.15 65.35,20.76 65.16,20.56 64.27,20.56 64.18,20.66 64.18,20.91 63.45,21.64 63.45,23.1 63.51,23.17 63.89,23.17
SPK_L+_CONN on TOP (solid shape): 30.67,18.92 30.67,18.6 30.61,18.54 30.34,18.54 30.21,18.41 30.21,17.88 30.12,17.8 29.54,17.8 29.47,17.86 29.47,18.34 29.47,18.34 29.47,18.78 29.59,18.91 29.59,18.92 29.66,18.98 30.61,18.98
SPK_L+_CONN on TOP (solid shape): 48.71,14.79 48.71,14.21 48.59,14.09 48.18,14.09 47.94,13.85 47.59,13.85 47.5,13.84 47.41,13.81 44.54,13.81 44.33,14.02 44.33,14.85 44.54,15.05 48.44,15.05
SPK_L+_CONN on BOTTOM (solid shape): 48.83,16.69 48.83,14.86 48.78,14.82 48.78,14.22 48.31,13.75 47.88,13.75 47.57,14.06 47.57,14.6 48.01,15.04 48.01,16.68 48.25,16.91 48.6,16.91
SPK_L+_CONN on BOTTOM (solid shape): 36.07,7.26 36.16,7.26 36.67,6.75 36.67,6.42 36.58,6.34 36.29,6.34 36.22,6.27 36.22,4.66 36.19,4.63 35.6,4.63 35.53,4.69 35.53,6.91 35.89,7.26 36.07,7.26
SPK_L+_CONN on IN1 (solid shape): 45.67,14.85 45.67,14.21 45.41,13.96 43.82,13.96 43.63,13.77 43.38,13.77 43.06,14.09 43.06,14.6 43.57,15.1 45.41,15.1
SPK_L+_CONN on IN1 (solid shape): 36.73,7.89 36.73,7.86 36.71,7.84 36.69,7.82 36.71,7.8 36.71,7.48 36.65,7.42 36.54,7.42 36.41,7.29 36.41,7.04 36.59,6.86 36.65,6.79 36.71,6.74 36.71,6.33 36.66,6.27 35.81,6.27 35.42,6.66 35.42,8.01 35.81,8.39 36.23,8.39
SPK_L+_CONN on IN3 (solid shape): 30.81,18.87 30.81,18.41 31.06,18.15 31.06,17.39 30.81,17.14 30.11,17.14 29.57,17.68 29.57,18.91 29.77,19.12 30.55,19.12
SPK_L+_CONN on IN3 (solid shape): 37.28,8.5 37.28,7.86 37.03,7.61 36.71,7.61 36.46,7.36 36.46,6.91 36.71,6.66 36.71,6.4 36.52,6.21 35.63,6.21 35.44,6.4 35.44,7.86 36.27,8.69 37.09,8.69
SPK_L-_CONN on TOP (solid shape): 32.93,18.86 32.93,18.68 32.77,18.52 32.77,17.85 32.73,17.81 32.1,17.81 32.06,17.85 32.06,18.55 31.93,18.68 31.93,18.87 32.08,19.02 32.77,19.02
SPK_L-_CONN on TOP (solid shape): 46.24,12.9 47.28,12.9 47.48,12.7 48.57,12.7 48.75,12.53 48.75,11.82 48.62,11.69 46.03,11.69 45.28,12.44 45.28,13.33 45.41,13.45 45.68,13.45
SPK_L-_CONN on BOTTOM (solid shape): 39.75,5.78 39.75,4.94 39.56,4.75 39.19,4.75 39.06,4.88 37.45,4.88 37.4,4.93 37.4,5.82 37.48,5.9 38.42,5.9 38.42,5.9 39.63,5.9
SPK_L-_CONN on BOTTOM (solid shape): 50.08,16.71 50.08,12.61 49.19,11.72 47.65,11.72 47.51,11.87 47.51,12.73 47.63,12.86 48.7,12.86 49.13,13.28 49.13,14.85 49.28,15.01 49.28,16.73 49.47,16.92 49.87,16.92
SPK_L-_CONN on IN1 (solid shape): 39.58,7.16 39.58,5 39.32,4.75 39.07,4.75 39,4.82 39,5.13 38.37,5.76 38.37,6.85 38.74,7.22 39.51,7.22
SPK_L-_CONN on IN1 (solid shape): 45.87,13.33 45.87,12.2 45.72,12.05 43.64,12.05 43.51,12.18 43.51,12.88 44.05,13.42 45.78,13.42
SPK_L-_CONN on IN3 (solid shape): 32.96,18.92 32.96,17.08 32.77,16.89 32.07,16.89 31.88,17.08 31.88,18.34 31.95,18.41 31.95,18.92 32.08,19.05 32.83,19.05
SPK_L-_CONN on IN3 (solid shape): 39.59,6.39 39.59,4.86 39.44,4.72 38.97,4.72 38.24,5.45 38.24,6.59 38.36,6.72 39.25,6.72
SPK_R+_CONN on TOP (solid shape): 27.5,13.4 27.94,13.4 28.07,13.27 28.07,12.82 28.01,12.76 26.81,12.76 26.74,12.83 26.74,13.71 26.81,13.77 27.12,13.77
SPK_R+_CONN on TOP (solid shape): 48.75,10.86 48.75,10.14 48.61,10.01 47.51,10.01 47.28,9.78 45.69,9.78 45.19,9.28 44.75,9.28 44.34,9.69 44.34,9.95 45.38,10.99 48.62,10.99
SPK_R+_CONN on TOP (solid shape): 30.55,6.59 30.55,5.01 30.23,4.69 27,4.69 26.74,4.94 26.74,5.83 26.87,5.96 27.95,5.96 28.01,5.9 28.01,5.61 28.2,5.42 29.38,5.42 29.85,5.9 29.85,6.53 29.98,6.66 30.49,6.66
SPK_R+_CONN on BOTTOM (solid shape): 51.32,16.71 51.32,14.88 51.48,14.72 51.48,11.78 49.69,10 47.76,10 47.57,10.19 47.57,11.15 47.7,11.27 49.4,11.27 50.55,12.43 50.52,12.46 50.52,16.7 50.74,16.93 51.1,16.93
SPK_R+_CONN on IN3 (solid shape): 28.2,6.34 28.2,6.09 28.01,5.9 28.01,5.39 27.82,5.2 26.87,5.2 26.74,5.32 26.74,6.02 27.63,6.91
SPK_R+_CONN on IN3 (solid shape): 27.63,13.33 28.26,13.33 28.51,13.08 28.51,12.19 28.39,12.06 27.76,12.06 27.51,12.31 27.5,12.31 27.06,12.75 26.87,12.75 26.74,12.88 26.74,13.71 26.81,13.77 27.19,13.77
SPK_R+_CONN on IN4 (solid shape): 45.79,10.34 45.79,9.64 45.49,9.34 43.62,9.34 43.57,9.39 43.57,10.28 43.71,10.42 45.72,10.42
SPK_R+_CONN on IN4 (solid shape): 28.14,6.28 28.14,6.09 27.94,5.89 27.94,5.48 27.72,5.26 26.87,5.26 26.8,5.33 26.81,5.47 26.81,6.15 27.44,6.79 27.63,6.79
SPK_R-_CONN on TOP (solid shape): 28.04,16.03 28.04,15.52 27.82,15.29 26.87,15.29 26.74,15.42 26.74,16.18 27,16.44 27.64,16.44
SPK_R-_CONN on TOP (solid shape): 47.6,8.58 48.62,8.58 48.75,8.45 48.75,7.82 48.62,7.69 45.38,7.69 45.19,7.88 45.19,8.7 45.38,8.9 47.28,8.9
SPK_R-_CONN on BOTTOM (solid shape): 31.38,5.21 31.38,3.74 31.19,3.55 30.7,3.55 30.13,2.98 28.77,2.98 28.65,3.1 28.65,3.48 28.9,3.74 29.6,3.74 30.23,4.37 30.23,4.88 30.65,5.3 31.29,5.3
SPK_R-_CONN on BOTTOM (solid shape): 52.59,16.7 52.59,15.23 52.84,14.98 52.84,10.84 50.74,8.73 48.97,8.73 48.78,8.54 48.78,8.06 48.59,7.87 47.67,7.87 47.54,8 47.54,9.48 47.86,9.8 50.24,9.8 51.82,11.38 51.82,14.94 51.77,14.99 51.77,16.74 51.96,16.93 52.36,16.93
SPK_R-_CONN on IN3 (solid shape): 28.52,15.99 28.52,15.1 28.39,14.98 27.57,14.98 27.25,15.29 26.93,15.29 26.74,15.48 26.74,16.31 26.93,16.5 28.01,16.5
SPK_R-_CONN on IN3 (solid shape): 30.68,3.36 30.36,3.03 29.61,3.03 29.6,3.03 28.78,3.03 28.58,3.23 28.58,3.61 28.71,3.74 29.47,3.74 29.66,3.93 29.66,5.45 30.68,5.45
SPK_R-_CONN on IN4 (solid shape): 31.19,3.61 30.55,2.98 28.84,2.98 28.71,3.1 28.71,3.61 28.84,3.74 29.73,3.74 29.85,3.86 29.85,4.25 30.23,4.63 31.19,4.63
SPK_R-_CONN on IN4 (solid shape): 45.98,8.75 45.98,7.61 45.86,7.48 44.46,7.48 44.2,7.74 44.2,8.5 44.97,8.5 45.41,8.94 45.79,8.94
SW_1.2V on TOP (solid shape): outline of 334 points within 86.88,38.34 98.45,43.55
SW_1.2V on BOTTOM (solid shape): 91.59,45.04 91.59,44.92 90.8,44.13 90.55,43.88 90.55,43.67 90.18,43.3 89.3,43.3 89.23,43.37 89.23,44.22 89.31,44.3 90.1,44.3 90.69,44.88 90.69,45.04 90.75,45.1 91.53,45.1
SW_1.2V on BOTTOM (solid shape): outline of 83 points within 87.18,35.01 92.32,42.03
SW_1.2V on IN4 (solid shape): 90.93,44.64 90.93,44.32 90.26,43.66 90.26,43.25 89.86,42.85 89.2,42.85 89.2,43.71 89.86,44.37 90.17,44.37 90.56,44.76 90.81,44.76
SW_1.2V on IN4 (solid shape): 90.24,42.15 90.24,41.77 90.43,41.58 90.43,41.33 90.63,41.13 90.63,40.95 90.43,40.76 90.12,40.76 89.23,41.65 89.23,42.22 90.18,42.22
SW_+1VALWP on TOP (solid shape): 254.64,23.63 254.64,21.96 254.6,21.92 253.44,21.92 253.36,21.83 253.03,21.83 252.9,21.71 252.9,21.62 252.87,21.58 252.87,20.76 252.83,20.75 252.65,20.45 252.9,20.21 253.08,20.17 253.25,20.25 255.6,20.25 255.85,19.99 255.85,17.71 255.53,17.39 252.93,17.39 251.47,18.85 250.45,18.85 249.44,19.87 247.61,19.87 246.8,20.68 245.76,20.68 245.76,20.86 245.88,20.98 247.11,20.98 247.13,20.98 247.21,20.96 247.29,20.95 247.37,20.96 247.45,20.98 247.46,20.98 249.84,20.98 250.07,20.76 251.11,20.76 251.33,20.97 251.33,23 251.75,23.42 252.81,23.42 253.17,23.78 254.49,23.78
SW_+1VALWP on BOTTOM (solid shape): outline of 94 points within 251.34,19.19 258.93,23.71
TBT_SVR_IND on TOP (solid shape): 175.01,171.25 175.4,171.25 175.81,170.84 176.41,170.84 176.47,170.77 176.47,170.64 176.41,170.58 176.28,170.58 176.09,170.39 176.09,170.26 176.04,170.21 175.6,170.21 175.59,170.22 175.53,170.25 175.47,170.26 175.17,170.26 174.81,169.9 169.62,169.9 169.19,170.34 169.19,171.55 169.72,172.08 174.19,172.08
TBT_SVR_IND on BOTTOM (solid shape): 175.19,171.33 175.19,170.03 174.98,169.82 169.45,169.82 169.07,170.2 169.07,171.36 169.36,171.64 174.88,171.64
UG_3V on TOP (solid shape): 53.79,31.3 53.79,30.47 53.62,30.29 52.49,30.29 52.4,30.38 52.4,31.23 52.51,31.35 53.15,31.35 53.29,31.49 53.6,31.49
UG_3V on BOTTOM (solid shape): 56.65,45.97 56.65,45.72 56.46,45.53 56.01,45.53 55,46.54 55,46.73 55.06,46.8 55.82,46.8
UG_3V on IN4 (solid shape): 53.41,32.25 53.29,32.12 53.29,31.87 53.79,31.36 53.79,31.04 53.29,30.53 52.84,30.53 52.14,31.23 52.14,32.31 52.4,32.57 53.41,32.57
UG_3V on IN4 (solid shape): 57.98,44.76 57.98,44.51 57.54,44.06 57.28,44.06 56.66,44.69 56.66,45.23 56.45,45.44 56.03,45.44 55.63,45.84 55.63,46.29 55.82,46.48 56.27,46.48
UG_5V on TOP (solid shape): 47.32,39.21 47.32,38.03 47.13,37.84 46.49,37.84 46.3,38.03 46.3,39.26 46.49,39.45 47.08,39.45
UG_5V on BOTTOM (solid shape): 52.78,46.71 52.78,46.64 52.17,46.03 52.17,44.97 51.95,44.75 51.27,44.75 51.15,44.87 51.15,45.71 51.52,46.08 51.52,46.55 51.75,46.78 52.7,46.78
UG_5V on IN4 (solid shape): 47.13,38.98 47.32,38.79 47.32,38.03 47.13,37.84 46.3,37.84 46.11,38.03 46.11,39.87 47.13,39.87
UG_5V on IN4 (solid shape): 52.01,46.35 52.01,45.27 51.19,44.45 50.81,44.45 50.36,44.89 50.36,45.33 51.51,46.48 51.89,46.48
UG_+1VALWP on TOP (solid shape): 254.64,21.63 254.64,20.69 254.35,20.4 253.44,20.4 252.99,20.84 252.99,21.53 253.12,21.66 253.5,21.66 253.63,21.78 254.49,21.78
UG_+1VALWP on TOP (solid shape): 247.54,22.14 247.54,21.19 247.49,21.14 247.47,21.14 247.44,21.12 247.37,21.09 247.29,21.08 247.21,21.09 247.14,21.12 247.11,21.14 246.58,21.14 246.55,21.16 245.89,21.16 245.79,21.26 245.79,21.38 245.88,21.47 246.54,21.47 246.59,21.52 246.63,21.52 246.83,21.72 246.83,22.17 246.91,22.24 247.44,22.24
UG_+1VALWP on IN1 (solid shape): 248.46,21.91 248.46,21.2 248.13,20.87 247.3,20.87 247.06,21.11 247.06,22.04 247.25,22.23 248.14,22.23
UG_+1VALWP on IN1 (solid shape): 253.7,21.4 253.7,19.99 253.34,19.62 253.11,19.62 252.51,20.22 252.51,20.45 252.64,20.61 252.66,20.81 252.65,20.96 252.58,21.1 252.64,21.21 252.66,21.33 252.66,21.35 252.94,21.63 253.48,21.63
VGND on TOP (solid shape): 24.2,51.81 24.2,51.49 24.15,51.14 24.44,50.92 24.46,50.92 24.96,50.41 24.96,50.28 24.9,50.22 24.9,49.9 24.94,49.87 24.94,49.86 25.03,49.72 25.16,49.63 25.17,49.63 25.35,49.46 25.35,49.39 24.96,49.01 24.84,49.01 24.45,49.4 24.46,49.44 24.4,49.86 23.98,49.92 23.95,49.9 23.88,49.97 23.79,49.97 23.78,49.97 23.56,50.04 23.35,49.97 23.19,49.97 22.49,50.66 22.49,50.84 22.52,50.91 22.59,50.94 22.94,51.29 22.59,51.65 22.52,51.68 22.49,51.75 22.49,51.78 22.52,51.99 22.42,52.18 22.42,52.49 22.42,52.49 22.25,52.85 21.85,52.82 20.9,52.82 20.77,52.95 20.77,53.33 20.9,53.46 22.55,53.46
VGND on GND1, GND6: 20.77,52.88 20.79,52.86 21.56,52.86 22.53,51.9 22.53,50.64 24.17,49 25,49 25.35,49.34 25.35,50.84 26.03,51.53 26.03,51.86 23.9,53.99 23.9,57.52 23.51,57.9 21.02,57.9 20.77,57.66
N04520 on TOP (solid shape): 30.23,51.43 30.23,50.41 30.17,50.35 29.41,50.35 29.25,50.5 28.68,50.5 28.44,50.74 28.44,50.77 28.42,50.77 28.39,50.79 28.39,51.24 28.46,51.3 28.48,51.3 29.13,51.41 29.75,51.61 29.76,51.62 30.04,51.62
N04520 on TOP (solid shape): 23.56,55.43 23.56,55.42 24.17,53.51 25.55,52.05 25.55,52.05 26.04,51.55 26.04,51.34 25.96,51.25 25.92,51.13 25.92,51.11 25.6,50.79 25.54,50.79 23.88,52.44 23.82,52.44 22.49,53.78 22.49,54.35 22.42,54.41 20.84,54.41 20.77,54.47 20.77,54.98 20.84,55.05 21.73,55.05 21.92,55.24 22.17,55.24 22.55,55.62 23.38,55.62
N04520 on IN4 (solid shape): 27.57,53.08 28.07,53.03 28.57,53.08 28.57,53.08 29.79,53.08 30.17,52.7 30.17,50.92 30.04,50.79 28.58,50.79 28.38,51 28.38,51.02 28.23,51.34 27.87,51.37 27.86,51.36 27.65,51.36 27.44,51.43 27.24,51.36 27.06,51.36 26.86,51.43 26.65,51.36 26.48,51.36 26.27,51.43 26.07,51.36 25.92,51.36 25.54,50.98 24.84,50.98 24.76,51.06 24.83,51.37 24.62,51.6 24.58,51.62 24.58,52.82 24.84,53.08 27.57,53.08
N102835 on BOTTOM (solid shape): 23.44,55.05 23.44,53.08 23.31,52.95 22.49,52.95 22.42,53.01 22.42,53.65 22.3,53.78 21.85,53.78 21.79,53.84 21.79,54.54 21.85,54.6 22.17,54.6 22.3,54.73 22.3,54.92 22.49,55.11 23.38,55.11
N16758539 on TOP (solid shape): 303.55,54.3 303.55,54.18 303.55,54.17 303.55,52.84 303.56,52.82 303.67,52.82 303.79,52.7 303.79,50.85 303.86,50.79 304.95,50.79 305.09,50.66 305.09,49.99 304.94,49.84 302.99,49.84 302.89,49.95 302.89,50.53 303.27,50.92 303.27,52.81 303.33,52.87 303.33,54.31 303.38,54.36 303.49,54.36
N16760382 on TOP (solid shape): 300.43,59.24 300.43,58.41 302.4,56.44 302.4,56.19 302.33,56.12 301.44,56.12 301.32,56.25 301.32,56.51 299.28,58.54 298.71,58.54 298.44,58.81 298.44,59.47 298.52,59.55 300.11,59.55
N17230179 on TOP (solid shape): 299.12,53.75 299.12,51.84 298.96,51.68 298.34,51.68 298.19,51.83 298.19,53.42 298.18,53.43 298.18,53.91 298.2,53.93 298.93,53.93
N17235867 on TOP (solid shape): 307.56,58.99 307.5,58.93 307.01,58.93 306.85,58.78 306.85,58.04 306.68,57.87 306.68,57.34 306.17,56.82 305.63,56.82 305.44,56.63 305.44,56.19 305.38,56.12 304.62,56.12 304.55,56.19 304.55,56.51 306.37,58.32 306.37,59.46 306.5,59.59 307.56,59.59
N18370426 on TOP (solid shape): 197.73,10.66 197.73,8.53 197.61,8.41 195.6,8.41 195.47,8.53 195.47,8.98 195.47,8.99 195.47,9.5 195.55,9.58 196.44,9.58 196.5,9.64 196.53,9.62 197.03,10 196.43,10.2 196.36,10.27 195.55,10.27 195.46,10.36 195.46,10.69 195.54,10.77 197.62,10.77
N19111564 on BOTTOM (solid shape): 171.95,167.85 171.95,167.12 172.14,166.93 173.1,166.93 173.26,166.76 173.26,164.99 173.11,164.84 172.6,164.84 172.12,165.31 172.03,165.65 171.7,165.74 171.69,165.74 171.55,165.74 171.33,165.97 171.33,166.65 171.5,166.82 171.5,167.86 171.54,167.9 171.9,167.9
N19529526 on TOP (solid shape): 40.65,10.68 40.65,10.02 39.93,9.29 37.21,9.29 37.15,9.36 37.15,9.48 37.21,9.55 38.11,9.55 38.77,10.21 39.25,10.21 39.44,10.4 39.44,10.72 39.59,10.87 40.46,10.87
