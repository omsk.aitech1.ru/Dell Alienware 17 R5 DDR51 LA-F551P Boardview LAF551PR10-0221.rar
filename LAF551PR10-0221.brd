# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_CTRL_DAT_R: length 5.3
  BOTTOM w0.102: RV653.1 v1(214.73,160.72)
  BOTTOM w0.114: RV650.2 216.01,162.26 215.86,162.1 QV96.6 215.63,161.46 215.4,161.69 RV653.1
HDMI_DOWN: length 16.8
  TOP w0.102: v2(222.21,165.18) v1(221.51,165.18)
  TOP w0.254: LX8.2 LX7.2 LX2.2 LX1.2 214.58,162.21 LX6.2 LX5.2 216.92,162.14 LX4.2 219.17,162.14 ; v2(218.6,161.57) 218.86,161.57 219.17,161.88 219.17,162.14 ; 219.17,162.14 LX3.2
  IN2 w0.254: v2(222.21,165.18) 221.29,165.18 219.01,162.89 219.01,161.98 v2(218.6,161.57)
  BOTTOM w0.254: v2(222.21,165.18) 222.17,165.22 QX1.1
HDMI_HPD: length 28.4
  IN6 w0.102: v2(209.74,165.19) 210.14,164.79 210.14,164.01 211.14,163.01 211.27,162.88 218.35,162.88 218.91,163.43 218.91,165.46 219.95,166.5 219.95,167.1 221.88,169.03 221.88,175.06 221.43,175.5 221.43,175.79 JHDMI.19
  BOTTOM w0.102: RX6.2 CX2.1 209.28,163.31 210.12,164.15 210.12,164.57 210.09,164.6 v1(210.09,164.72) 209.74,165.06 v2(209.74,165.19)
HDMI_HPD_PCH: length 181.1
  IN1 w0.089: 197.83,45.7 198.07,45.46 198.07,44.31 198.45,43.93 198.45,42.66 200.85,40.26 203.77,40.26 204.35,39.68 204.35,38.41 206.23,36.53 207.75,36.53 208.23,36.06 208.23,34.34 208.75,33.82 211.35,33.82 211.65,33.52 212.04,33.52 212.86,32.69 v2(213.05,32.69)
  IN1 w0.102: 197.83,45.7 197.75,45.77 197.75,47.7 197.75,47.71 197.75,48.7 197,49.44 196.99,49.44 196.8,49.44 194.98,51.26 194.98,52.29 192.74,54.52 192.74,58.67 192.22,59.19 192.22,59.53 192.29,59.6 192.29,59.6 192.47,59.78 193.09,59.78 193.8,60.5 193.8,64.2 v2(193.76,64.25)
  IN2 w0.102: v2(193.76,64.25) 193.76,63.37 193.23,62.85 192.49,62.85 192.25,63.09 192.25,63.24 190.73,64.76 190.19,64.76 190.17,64.79 189.33,64.79 185.33,68.79 184.19,68.79 182.86,70.12 181.02,70.12 180.5,70.63 180.5,73.52 179.6,74.42 179.6,81.11 181.86,83.37 181.86,84.64 185.48,88.26 185.48,93.68 181.36,97.8 181.36,105 183.4,107.04 183.4,121.52 191.13,129.25 191.13,134.65 196.24,139.76 196.24,142.18 205.7,151.64 205.7,154.59 206.76,155.65 207.51,155.65 208.64,156.78 208.64,157.43 209.41,158.19 209.41,159.21 209.9,159.71 v2(210.37,159.71)
  BOTTOM w0.089: UH1.BD21 214.72,31.22 214.29,31.65 214.29,32.09 213.69,32.69 v2(213.05,32.69)
  BOTTOM w0.102: v2(193.76,64.25) 194.3,64.25 v1(194.36,64.19) ; QX3.3 210.53,163.51 211.11,162.93 211.11,161.73 210.97,161.59 210.97,160.82 UX2.1 ; UX2.1 211.22,160.56 v2(210.37,159.71) ; UX2.1 211.39,160.4 211.39,160.32 212.14,159.57 213.94,159.57 RX8.1
HDMI_L_CLKN: length 2.2
  BOTTOM w0.089: RV673.1 218.42,170.54 218.42,169.71 RV500.2 218.22,169.5 LV3.2 218.38,168.53 RV641.2
HDMI_L_CLKP: length 2.2
  BOTTOM w0.089: RV640.2 217.55,168.53 LV3.3 217.72,169.48 RV500.1 217.52,169.72 217.52,170.55 RV674.1
HDMI_L_TX_N0: length 2.2
  BOTTOM w0.089: RV643.2 213.58,168.53 LV4.2 213.42,169.5 RV501.2 213.64,169.72 213.64,170.5 RV27.1
HDMI_L_TX_N1: length 2.2
  BOTTOM w0.089: RV29.1 215.99,170.56 215.99,169.72 RV502.2 215.83,169.57 LV5.2 215.86,168.7 RV642.2
HDMI_L_TX_N2: length 2.2
  BOTTOM w0.089: RV33.1 211.31,170.54 211.31,169.72 RV503.2 211.03,169.44 LV6.2 211.2,168.53 RV645.2
HDMI_L_TX_P0: length 2.2
  BOTTOM w0.089: RV646.2 212.75,168.53 LV4.3 212.92,169.48 RV501.1 212.72,169.72 212.72,170.53 RV28.1
HDMI_L_TX_P1: length 2.3
  BOTTOM w0.089: RV30.1 215.07,169.72 RV502.1 215.33,169.42 LV5.3 215.31,168.7 RV639.2
HDMI_L_TX_P2: length 2.2
  BOTTOM w0.089: RV34.1 210.4,170.54 210.4,169.72 RV503.1 210.53,169.54 LV6.3 210.36,168.53 RV638.2
HDMI_TX_N0: length 9.9
  IN6 w0.076: v2(213.43,172.15) 213.24,172.33 213.24,172.96 212.92,173.28 212.48,173.28 211.53,174.23 211.53,174.74 211.91,175.12 215.49,175.12 215.72,175.35 215.72,175.7 JHDMI.9
  BOTTOM w0.089: RV27.2 213.28,171.77 213.28,172 v2(213.43,172.15)
HDMI_TX_N1: length 3.9
  BOTTOM w0.089: JHDMI.6 214.24,174.17 214.24,173.83 215.63,172.44 215.63,171.83 RV29.2
HDMI_TX_N2: length 6
  BOTTOM w0.089: RV33.2 210.96,171.81 210.96,174.23 211.84,175.12 212.38,175.12 212.67,175.41 212.67,175.65 JHDMI.3
HDMI_TX_P0: length 9.9
  IN6 w0.076: v2(212.84,172.15) 213.02,172.33 213.02,172.87 212.83,173.06 212.39,173.06 211.3,174.14 211.3,174.84 211.82,175.35 215.4,175.35 215.49,175.44 215.49,175.73 JHDMI.7
  BOTTOM w0.089: RV28.2 213.04,171.81 213.04,171.95 v2(212.84,172.15)
HDMI_TX_P1: length 3.9
  BOTTOM w0.089: JHDMI.4 213.98,174.19 213.98,173.75 215.39,172.34 215.39,171.82 RV30.2
HDMI_TX_P2: length 5.9
  BOTTOM w0.089: JHDMI.1 212.43,175.79 212.43,175.51 212.28,175.36 211.74,175.36 210.71,174.33 210.71,171.8 RV34.2
HP2_D_L1_JK: length 28.4
  TOP w0.254: LA12.1 21.34,25.7 CA50.1 21.12,26.24 20.86,26.5 19.2,26.5 18.77,26.93 18.77,30.12 v1(19.66,31.01) v2(20.07,31.42)
  BOTTOM w0.254: v2(20.07,31.42) 20.07,31.79 20.06,31.8 DA6.3 19.6,32.79 18.49,31.68 18.49,30.79 16.23,28.53 16.23,19.57 15.45,18.8 JACK2.1
HP2_D_L_C:
  vias: v1(26.68,28.9) v2(26.93,27.99) v2(26.93,27.36)
HP2_D_L_R: length 6.7
  TOP w0.254: RA46.1 24.46,30.64 RA43.2 24.46,29.14 24.79,28.81 RA41.2 24.46,28.37 24.2,28.12 24.2,27.3 23.9,26.99 v1(23.72,26.99) 22.96,26.99 RA44.1 22.68,26.72 LA12.2
HP2_D_R1_JK: length 30.2
  TOP w0.254: v2(20.87,32.06) 19.82,32.06 18.36,30.6 18.36,26.39 v1(18.63,26.12) 18.71,26.12 19.35,25.48 20.57,25.48 21.18,24.87 CA48.1 21.63,24.36 LA11.1
  IN1 w0.254: v2(20.99,32.79) 20.56,32.79 16.91,29.15 8.82,29.15 JACK2.2
  BOTTOM w0.254: v2(20.99,32.79) DA6.2 21.99,32.01 21.73,31.74 21.22,31.74 20.9,32.06 v2(20.87,32.06)
HP2_D_R_C: length 0.7
  TOP w0.127: v2(25.15,25.33) v1(25.15,24.65)
  vias: v2(25.79,25.33)
HP2_D_R_R: length 8
  TOP w0.254: v2(23.69,27.61) 23.07,27.61 22.68,28.01 RA47.1 ; v2(24.71,27.8) 24.79,27.73 RA40.2 24.69,26.82 24.69,26.26 RA42.2 24.35,26.02 v1(23.57,25.24) 22.68,24.36 LA11.2 22.71,24.03 23.22,24.03 RA45.1
  IN3 w0.254: v2(24.71,27.8) 23.88,27.8 v2(23.69,27.61)
HP_LINE1_JD: length 7.4
  TOP w0.102: v2(36.56,31.79) 34.9,31.79 v1(34.22,31.12)
  TOP w0.107: RA34.1 RA36.1 37.14,32.37 v2(36.56,31.79)
  BOTTOM w0.107: UA1.9 36.47,31.71 v2(36.56,31.79) 37.16,31.79 RA34.1 RA32.2
HP_MUTE#: length 28.9
  TOP w0.203: UA2.B1 20.19,30.53 19.25,29.58 v1(19.25,29.06) v2(19.25,27.27) ; UA3.B1 19.12,25 v2(18.73,25.39)
  TOP w0.254: v2(19.25,27.27) 19.33,27.19 19.85,27.19 RA13.2
  IN1 w0.254: v2(19.25,27.27) 19.25,27.19 18.73,26.67 v2(18.73,25.39)
  IN3 w0.254: v2(18.73,25.39) 20.32,25.39 21.59,24.12 30.87,24.12 31.76,23.23 34.49,23.23 v2(36.09,24.83)
  BOTTOM w0.254: DA2.1 36.55,24.37 v2(36.09,24.83)
HPOUT-L: length 14.7
  IN6 w0.254: v2(27.52,30.57) 27.66,30.57 28.41,29.82 28.41,27.13 24.9,23.61 v2(24.9,21.96)
  BOTTOM w0.203: v2(27.52,30.57) 27.6,30.57 27.94,30.91 UA1.32
  BOTTOM w0.254: RA35.1 25.47,20.13 25.47,20.82 24.9,21.39 v2(24.9,21.96)
HPOUT-R: length 22.2
  TOP w0.254: RA37.1 20.02,22.32 v2(19.44,21.73)
  IN6 w0.254: v2(19.44,21.73) 19.92,22.22 22.93,22.22 24.46,20.69 26.17,20.69 27.63,22.16 27.63,25.2 28.99,26.55 28.99,30.08 27.87,31.19 v2(27.52,31.19)
  BOTTOM w0.203: v2(27.52,31.19) 27.64,31.31 UA1.33
HPOUT_JD: length 38.8
  TOP w0.107: v2(39.86,30.59) v1(39.41,31.04) 38.83,31.04 RA34.2
  IN2 w0.254: JACK1.6 10.73,15.6 12.57,17.44 15.15,17.44 16.51,18.8 16.51,21.26 17.26,22.01 18.2,22.01 18.67,22.48 23.77,22.48 29.38,28.1 31.53,28.1 32.19,28.76 34.02,28.76 35.03,29.76 36.43,29.76 36.62,29.58 37.16,29.58 38.17,30.59 v2(39.86,30.59)
I2C0_SCL_EC: length 345.4
  TOP w0.114: v2(284.48,8.06) 284.66,7.87 285.33,7.87 RE668.2 ; v2(41.41,14.33) 41.19,14.11 41.07,14.11 40.89,14.29 40.89,15.05 41.63,15.79 41.63,18.51 41.23,18.9 40.21,18.9 39.95,18.64 39.95,18.46 39.59,18.11 RA56.1 ; JIO.12 326.13,17.16 326.27,17.01 326.5,17.01 v2(326.69,17.2)
  IN6 w0.081: v2(326.69,17.2) 326.5,17.01 326.01,17.01 325.72,16.72 325.72,10.66 324.76,9.69 324.36,9.69 323.74,10.31 322.56,10.31 322.1,10.77 319.44,10.77 318.41,9.73 318.41,9.07 316.27,6.94 299.14,6.94 298.54,7.55 285.94,7.55 285.64,7.84 284.69,7.84 v2(284.48,8.06) 284.26,7.84 283.64,7.84 279.51,11.96 272.58,11.96 272.24,11.62 260.77,11.62 258.25,9.09 258.25,8.11 256.35,6.22 230.84,6.22 230.46,5.84 203.29,5.84 203.03,6.1 193.6,6.1 192.42,7.28 189.54,7.28 189.14,7.67 189,7.81 188.01,7.81 186.83,8.99 185.92,8.99 182.35,12.56 177.13,12.56 175.08,10.52 175.08,8.86 172.62,6.4 139.07,6.4 137.8,7.67 109.21,7.67 103.81,13.07 57.29,13.07 54.68,15.68 44.14,15.68 42.57,14.11 41.63,14.11 v2(41.41,14.33) 41.13,14.04 40.86,14.04 39.36,12.55 38.12,12.55 37.52,13.15 37.52,15.09 38.74,16.31 38.74,19.1 37.2,20.65 37.2,29.83 v2(36.96,30.06)
  BOTTOM w0.114: UA1.12 36.16,30.51 36.37,30.3 36.73,30.3 v2(36.96,30.06)
I2C0_SCL_EC_R: length 8.2
  TOP w0.114: UA4.8 38.25,11.81 38.35,11.92 v2(38.49,11.92) 39.24,11.92 39.75,12.42 39.75,14.93 39.57,15.11 v1(39.57,15.6) RA56.2
  BOTTOM w0.114: RA50.2 38.84,11.92 v2(38.49,11.92)
I2C0_SDA_EC: length 345.3
  TOP w0.114: JIO.11 326.17,16.66 326.28,16.77 326.54,16.77 v2(326.69,16.61) ; v2(284.48,7.47) 284.63,7.63 285.36,7.63 RE669.2 ; v2(41.44,13.73) 41.3,13.87 40.97,13.87 40.65,14.19 40.65,15.15 41.39,15.89 41.39,18.41 41.13,18.66 40.31,18.66 40.19,18.54 40.19,18.37 RA55.1
  IN6 w0.081: v2(36.54,30.71) 36.54,29.85 36.96,29.44 36.96,20.53 38.49,19 38.49,16.35 37.31,15.17 37.31,13.04 38.03,12.32 39.32,12.32 39.33,12.34 39.45,12.34 40.94,13.83 41.34,13.83 v2(41.44,13.73) 41.62,13.9 42.66,13.9 44.23,15.47 54.6,15.47 57.2,12.86 103.72,12.86 109.12,7.47 137.72,7.47 138.99,6.2 172.71,6.2 175.29,8.78 175.29,10.43 177.21,12.35 182.26,12.35 185.83,8.78 186.75,8.78 187.92,7.6 188.91,7.6 188.93,7.58 189.45,7.07 192.33,7.07 193.51,5.89 202.94,5.89 203.21,5.63 230.54,5.63 230.93,6.01 256.44,6.01 258.45,8.02 258.45,9.01 260.86,11.41 272.33,11.41 272.67,11.75 279.42,11.75 283.55,7.63 284.32,7.63 v2(284.48,7.47) 284.64,7.64 285.56,7.64 285.85,7.34 298.45,7.34 299.06,6.73 316.36,6.73 318.62,8.99 318.62,9.65 319.53,10.56 322.01,10.56 322.47,10.1 323.66,10.1 324.27,9.48 324.84,9.48 325.93,10.57 325.93,16.63 326.1,16.8 326.5,16.8 v2(326.69,16.61)
  BOTTOM w0.114: UA1.11 36.34,30.91 v2(36.54,30.71)
I2C0_SDA_EC_R: length 9.5
  TOP w0.114: RA55.2 40.43,17.19 40.07,16.83 40.07,15.31 40.15,15.22 40.15,13.25 40.59,12.81 v1(40.59,12.44) 39.43,11.28 v2(38.49,11.28) 38.45,11.28 38.31,11.41 UA4.7
  BOTTOM w0.114: RA53.2 39.09,11.28 v2(38.49,11.28)
I2C_0_SCL: length 77.9
  IN2 w0.089: v2(217.31,30.61) 217.1,30.41 216.61,30.41 215.23,29.03 210.91,29.03 210.66,28.78 208.88,28.78 208.43,28.32 208.43,26.61 208.08,26.26 207.06,26.26 206.77,25.97 200.34,25.97 198.78,27.54 197.1,27.54 196.99,27.42 196.93,27.42 196.88,27.38 195.69,27.38 194.76,28.31 194.76,29.99 194.55,30.2 194.13,30.2 v2(194,30.34)
  IN3 w0.102: v2(204.84,15.39) 204.66,15.21 204.66,14.82 204.83,14.64 204.83,13.38 204.49,13.03 196.52,13.03 196.1,13.45 193.94,13.45 189.07,18.31 189.07,18.46 188.75,18.79 187.3,18.79 186.8,18.29 186.8,17.6 v2(186.86,17.53)
  IN4 w0.089: v2(194,30.34) 194.18,30.15 194.43,30.15 194.62,29.96 194.62,27.48 193.99,26.84 193.99,23.24 193.39,22.65 193.32,22.65 193.29,22.62 193.27,22.62
  IN4 w0.102: 193.27,22.62 189.91,22.62 186.69,19.4 186.69,17.71 v2(186.86,17.53)
  BOTTOM w0.089: UH1.BC22 214.74,31 214.76,30.98 216.09,30.98 216.35,30.72 216.35,30.5 216.44,30.41 217.1,30.41 v2(217.31,30.61)
  BOTTOM w0.102: v2(204.84,15.39) 204.63,15.18 204.63,15.02 205.02,14.62 205.02,14.18 205.18,14.02 RPC7.2 ; v2(186.86,17.53) 186.8,17.47 186.8,16.79 RE71.1
I2C_0_SCL_R: length 16.1
  TOP w0.102: RE659.2 188.72,5.83 190.14,5.83 190.5,5.47 190.5,5.29 v2(190.65,5.15)
  BOTTOM w0.102: v2(190.65,5.15) 190.47,5.33 190.47,8.42 189.8,9.09 189.8,11.92 189.7,12.02 189.7,12.17 189.82,12.29 JTP.15 189.82,13.45 189.68,13.6 189.68,14.08 189.45,14.32 187.59,14.32 186.8,15.1 186.8,15.32 RE71.2
I2C_0_SDA: length 76.8
  IN2 w0.089: v2(217.31,30.03) 217.1,30.23 216.68,30.23 215.31,28.85 210.99,28.85 210.73,28.6 208.96,28.6 208.61,28.25 208.61,26.54 208.16,26.09 207.14,26.09 206.84,25.79 200.27,25.79 198.7,27.36 197.18,27.36 197.06,27.24 197,27.24 196.96,27.2 195.62,27.2 194.59,28.24 194.59,29.92 194.47,30.03 194.23,30.03 v2(194,29.79)
  IN3 w0.102: v2(204.25,15.39) 204.43,15.21 204.43,15.21 204.43,14.72 204.61,14.55 204.61,13.48 204.39,13.26 196.61,13.26 196.19,13.68 194.03,13.68 189.3,18.41 189.3,18.55 188.84,19.02 187.2,19.02 186.57,18.39 186.57,17.82 v2(186.28,17.53)
  IN4 w0.089: v2(194,29.79) 194.18,29.98 194.36,29.98 194.45,29.89 194.45,27.55 193.81,26.91 193.81,23.32 193.32,22.83 193.29,22.83 193.28,22.83 193.28,22.84 193.29,22.85 193.27,22.85
  IN4 w0.102: v2(186.28,17.53) 186.46,17.71 186.46,19.5 189.81,22.85 193.27,22.85
  BOTTOM w0.089: UH1.BF23 215.76,30.71 215.85,30.81 216.02,30.81 216.18,30.65 216.18,30.42 216.37,30.23 217.1,30.23 v2(217.31,30.03)
  BOTTOM w0.102: RPC7.1 204.68,14.05 204.8,14.16 204.8,14.53 204.4,14.92 204.4,15.25 v2(204.25,15.39) ; v2(186.28,17.53) 186.57,17.24 186.57,16.82 186.27,16.51 RE653.1
I2C_0_SDA_R: length 15.8
  TOP w0.102: RE660.2 188.77,5.6 v4(189.39,5.6) 190.04,5.6 190.27,5.38 190.27,5.36 v2(190.06,5.15)
  BOTTOM w0.102: RE653.2 186.22,15.6 186.57,15.24 186.57,15.01 187.49,14.09 189.35,14.09 189.45,13.99 189.45,13.62 189.32,13.5 JTP.16 189.32,12.32 189.47,12.17 189.47,11.92 189.57,11.82 189.57,8.99 190.24,8.32 190.24,5.33 v2(190.06,5.15)
I2C_CLK: length 383.9
  TOP w0.114: v2(225.07,162.22) 225.26,162.03 225.98,162.03 226.11,162.16 UE3.25 ; UE4.25 189.6,24.61 189.43,24.78 189.43,25.06 189.54,25.17 189.75,25.17 v2(189.97,24.95) ; v2(305.89,29.07) 305.76,28.95 305.76,28.74 305.88,28.63 307.01,28.63 307.88,29.51 309.5,29.51 309.76,29.25 309.76,28.9 RE2.2 ; UE8.25 304.15,39.78 304.02,39.65 303.43,39.65 303.04,39.26 303.04,38.42 302.78,38.15 302.59,38.15 v2(302.46,38.28) ; UE1.42 312.97,15.58 313.1,15.45 313.89,15.45 314.14,15.2 314.14,14.05 v2(314.29,13.9)
  IN1 w0.081: v2(181.62,26.79) 181.59,26.79 181.4,26.98 181.07,26.98 180.98,26.9 180.98,25.39 181.87,24.5 181.87,18.6 182.51,17.96 183.65,17.96 185.15,16.46 185.53,16.47 186.91,16.47 187.42,15.96 187.42,15.71 188.26,14.86 189.25,14.86 189.76,15.38 190.49,15.38 v2(190.51,15.36) 190.51,15.17 190.64,15.03 191.66,15.03 193.47,13.23 193.59,13.23 193.59,13.23 196.22,13.23 196.5,13.11 198.2,13.11 198.68,12.63 206.17,12.63 206.5,12.96 215.23,12.96 215.74,13.48 218.75,13.48 221.31,13.48 221.35,13.51 238.16,13.51 240.11,15.46 250.71,15.46 251.42,16.18 251.42,16.56 251.77,16.91 255.18,16.91 255.97,17.7 258.67,17.7 259.28,17.1 259.28,16.27 260.49,15.06 264.92,15.06 265.5,15.64 271.71,15.64 271.85,15.78 275.73,15.78 276.9,16.95 280.07,16.95 283.6,20.48 297.74,20.48 298.57,21.3 309.63,21.3 310.31,21.98 311.12,21.98 311.89,21.21 311.89,20.86 v2(312.11,20.64)
  IN3 w0.127: v2(312.11,20.64) 311.97,20.77 311.97,21.15 310.65,22.47 308.48,22.47 306.22,24.73 306.22,28.04 305.76,28.5 305.76,28.95 v2(305.89,29.07) 305.7,29.26 305.7,29.47 304.49,30.68 304.49,33.96 303.35,35.11 303.35,37.82 303.07,38.09 302.65,38.09 v2(302.46,38.28) ; v2(181.62,26.79) 181.75,26.92 182.78,26.92 183.33,27.47 183.33,29.24 182.83,29.75 182.83,32.02 184.26,33.46 185.74,33.46 186.27,33.98 186.27,35.28 185.38,36.17 185.38,37.53 185.81,37.96 185.81,39.51 185.28,40.05 185.28,51.39 183.75,52.92 183.75,54.67 183.41,55.01 183.41,65.28 183.71,65.59 183.71,67.55 183.46,67.81 183.46,70.22 185.35,72.11 185.35,88.62 186.47,89.75 186.47,96.59 186.13,96.93 186.13,100.66 186.32,100.86 186.32,103.93 186.32,103.93 186.32,104.54 186.32,104.54 186.32,104.82 188.96,107.46 188.96,109.01 190.84,110.9 190.84,111.63 191.23,112.02 191.23,112.25 192.26,113.27 195.57,113.27 196.43,114.14 197.95,114.14 199.45,115.63 199.45,116.13 201.28,117.96 201.28,119.32 201.52,119.57 201.86,119.57 202.24,119.95 202.24,120.61 202.65,121.02 202.87,121.02 203.27,121.42 203.27,122.95 205.66,125.34 206.15,125.34 207.69,126.88 207.69,127.27 207.69,127.46 207.69,128.45 207.33,128.82 207.33,131.09 206.96,131.46 206.96,133.91 207.72,134.67 207.72,143.42 205.86,145.28 205.86,149.51 206.89,150.54 206.89,150.93 207.97,152.01 207.97,155.36 210.94,158.32 213.63,158.32 213.75,158.44 213.94,158.44 215.37,159.87 216.34,159.87 216.84,160.37 217.29,160.37 217.64,160.01 225.41,160.01 226.38,160.98 226.38,161.79 226.1,162.07 225.22,162.07 v2(225.07,162.22)
  IN6 w0.081: v2(189.97,24.95) 189.78,25.14 189.57,25.14 189.49,25.06 189.49,24.35 191.33,22.51 191.33,16.82 190.17,15.66 190.17,15.42 190.24,15.36 v2(190.51,15.36)
  BOTTOM w0.114: RM1.2 225.61,163.35 225.61,163.1 225.23,162.72 225.23,162.39 v2(225.07,162.22) ; v2(312.11,20.64) 311.94,20.46 311.94,20.17 312.24,19.87 312.24,19.46 312.87,18.82 312.87,15.83 314.13,14.57 314.13,14.06 v2(314.29,13.9)
I2C_DAT: length 384.4
  TOP w0.114: RE1.2 309.51,28.9 309.51,29.15 309.4,29.26 307.98,29.26 307.11,28.39 305.78,28.39 305.52,28.64 305.52,28.86 v2(305.3,29.07) ; UE8.26 304.13,39.28 304,39.41 303.53,39.41 303.28,39.16 303.28,38.32 302.88,37.91 302.68,37.91 v2(302.46,37.7) ; v2(189.97,25.53) 189.85,25.41 189.44,25.41 189.19,25.16 189.19,24.68 189.19,24.68 189.1,24.59 UE4.26 ; v2(313.71,13.9) 313.9,14.1 313.9,15.1 313.79,15.21 313.11,15.21 312.98,15.08 UE1.43 ; UE3.26 226.11,161.66 225.98,161.78 225.21,161.78 v2(225.07,161.64)
  IN1 w0.081: v2(311.53,20.64) 311.68,20.79 311.68,21.12 311.03,21.77 310.4,21.77 309.72,21.1 298.65,21.1 297.83,20.27 283.69,20.27 280.16,16.74 276.99,16.74 275.81,15.57 271.93,15.57 271.79,15.43 265.58,15.43 265,14.85 260.41,14.85 259.07,16.19 259.07,17.01 258.59,17.49 256.05,17.49 255.27,16.71 251.86,16.71 251.63,16.47 251.63,16.26 251.63,16.26 251.63,16.09 250.79,15.25 240.2,15.25 238.25,13.31 221.44,13.31 221.4,13.27 221.23,13.27 218.84,13.27 218.84,13.27 215.83,13.27 215.31,12.75 206.58,12.75 206.26,12.42 198.59,12.42 198.11,12.9 196.46,12.9 196.17,13.02 193.51,13.02 193.38,13.02 191.58,14.82 190.56,14.82 190.42,14.96 190.34,14.96 190.33,14.98 190.27,14.98 v2(190.17,14.88) 190.13,14.92 190.13,15.09 190.05,15.17 189.85,15.17 189.34,14.65 188.18,14.65 187.21,15.62 187.21,15.88 186.83,16.26 185.62,16.26 185.53,16.26 185.06,16.26 183.57,17.75 182.42,17.75 181.66,18.51 181.66,24.42 180.78,25.3 180.78,26.98 180.98,27.19 181.4,27.19 181.59,27.37 v2(181.62,27.37)
  IN3 w0.127: v2(311.53,20.64) 311.72,20.83 311.72,21.04 310.55,22.22 308.37,22.22 305.96,24.63 305.96,27.94 305.51,28.4 305.51,28.87 v2(305.3,29.07) 305.44,29.21 305.44,29.37 304.24,30.58 304.24,33.86 303.09,35 303.09,37.71 302.97,37.84 302.6,37.84 v2(302.46,37.7) ; v2(225.07,161.64) 225.24,161.81 226,161.81 226.13,161.69 226.13,161.08 225.31,160.26 217.75,160.26 217.39,160.62 216.73,160.62 216.24,160.12 215.26,160.12 213.83,158.7 213.64,158.7 213.53,158.58 210.83,158.58 207.72,155.46 207.72,152.12 206.64,151.04 206.64,150.64 205.61,149.61 205.61,145.18 207.46,143.32 207.46,134.78 206.7,134.02 206.7,131.35 207.07,130.98 207.07,128.72 207.44,128.35 207.44,127.56 207.44,127.27 207.44,126.98 206.05,125.59 205.56,125.59 203.02,123.05 203.02,121.53 202.76,121.28 202.55,121.28 201.99,120.72 201.99,120.06 201.76,119.82 201.42,119.82 201.02,119.43 201.02,118.06 199.2,116.23 199.2,115.74 197.85,114.39 196.33,114.39 195.46,113.53 192.15,113.53 190.98,112.35 190.98,112.13 190.59,111.74 190.59,111 188.7,109.12 188.7,107.56 186.07,104.93 186.07,104.64 186.07,104.64 186.07,103.83 186.07,103.83 186.07,100.96 185.88,100.77 185.88,96.82 186.22,96.48 186.22,89.85 185.09,88.72 185.09,72.21 183.21,70.33 183.21,67.7 183.46,67.45 183.46,65.69 183.16,65.39 183.16,54.9 183.49,54.57 183.49,52.81 185.02,51.28 185.02,39.94 185.56,39.41 185.56,38.07 185.12,37.64 185.12,36.07 186.02,35.17 186.02,34.09 185.64,33.71 184.16,33.71 182.57,32.12 182.57,29.65 183.08,29.14 183.08,27.58 182.68,27.17 181.82,27.17 v2(181.62,27.37)
  IN6 w0.081: v2(190.17,14.88) 190.17,15.13 190.16,15.15 190.15,15.15 189.97,15.33 189.97,15.74 191.13,16.9 191.13,22.42 189.28,24.27 189.28,25.14 189.49,25.34 189.78,25.34 v2(189.97,25.53)
  BOTTOM w0.114: RM2.2 225.85,163.27 225.85,163 225.48,162.62 225.48,162.05 v2(225.07,161.64) ; v2(313.71,13.9) 313.89,14.08 313.89,14.47 312.63,15.73 312.63,18.72 312,19.36 312,19.77 311.7,20.07 311.7,20.46 v2(311.53,20.64)
I2C_INT: length 237.4
  TOP w0.114: v2(138.88,5.64) v1(139.4,5.64) 139.89,5.64 140.07,5.46 DK3.2 140.3,5.87 RE656.2 141.11,6.26 v2(141.11,5.26) ; UE5.98 304.24,12.01 300.17,16.08 v2(300.17,16.29)
  IN4 w0.127: v2(300.17,16.29) 300.17,16.25 299.93,16.01 299.93,15.75 299.46,15.28 295.51,15.28 290.2,20.59 272.2,20.59 271.67,20.06 271.17,20.06 266.16,20.06 265.47,19.37 260.24,19.37 259.53,18.66 257.79,18.66 257.51,18.38 255.06,18.38 254.52,17.83 248.95,17.83 247.92,16.81 246.79,16.81 245.77,17.83 243.19,17.83 242.62,18.41 240.46,20.56 237.08,20.56 237,20.65 235.95,20.65 235.02,21.58 235.02,22.1 234.78,22.34 234.03,22.34 231.25,25.12 231.25,25.25 231.01,25.49 230.88,25.49 230.29,26.08 230.29,32.73 229.41,33.61 229.41,33.88 229.16,34.13 228.71,34.13 227.86,33.28 227.86,30.91 226.32,29.37 225.25,29.37 224.88,29.74 224.88,32.1 224.67,32.3 224.05,32.3 222.61,30.85 221.4,30.85 220.95,30.41 220.95,28.07 222.4,26.62 222.4,25.95 221.92,25.48 221.92,25.27 221.6,24.95 217.88,24.95 217.31,24.37 217.31,24.22 215.26,22.17 215.26,21.61 215.26,21.45 215.26,21.44 215.26,21.38 214.89,21.01 214.83,21.01 214.82,21 214.38,21 213.6,20.22 213.59,20.22 213.37,20 213.37,19.68 213.47,19.58 213.47,19.05 211.71,17.28 211.71,17.24 211.25,16.78 211.25,16.36 210.63,15.74 208.78,15.74 206.99,17.53 206.99,17.76 206.28,18.47 205.75,18.47 205.48,18.74 202.74,18.74 202.37,19.1 201.72,19.1 201.65,19.17 197.24,19.17 196.35,20.06 196.35,20.47 195.75,21.07 195.34,21.07 194.13,22.28 191.65,22.28 189.77,20.4 189.77,20.07 189.35,19.65 189.35,17.73 188.68,17.06 185.7,17.06 183.18,19.57 142.38,19.57 141.63,20.32 v2(141.63,21.58)
  BOTTOM w0.114: JPK.15 141.11,4.65 v2(141.11,5.26) ; v2(138.88,5.64) 138.88,5.91 138.55,6.24 138.55,14.27 143.38,19.09 143.38,21.76 143.09,22.05 142.03,22.05 141.63,21.64 v2(141.63,21.58)
I2CC_SCL: length 17.1
  IN1 w0.081: v2(194.3,118.69) 194.51,118.48 194.85,118.48 199.16,122.79 200.85,122.79 201.21,122.44 204.33,122.44 v2(205.81,120.96)
  BOTTOM w0.114: QG7.3 205.38,121.39 v2(205.81,120.96) ; UG11.6 193.69,118.73 193.9,118.52 194.13,118.52 v2(194.3,118.69) 194.37,118.63 194.53,118.63 RG60.2
I2CC_SCL_R: length 35.6
  IN6 w0.081: 224.11,122.12 224.47,121.76 224.47,120.8 224.44,120.78 224.44,118.77 224.54,118.67 ; v2(206.19,120.27) 206.16,120.3 206.16,120.41 206.95,121.2 207.2,121.2 207.4,121.41 207.4,122.23 209.52,124.35 211.05,124.35 213.45,121.96 215.24,121.96 215.85,121.35 217.93,121.35 218.79,122.21 218.84,122.21 219.95,123.32 222.91,123.32 223.87,122.36
  IN6 w0.089: 224.54,118.67 224.56,118.66 224.56,115.56 v2(224.97,115.15) ; 223.87,122.36 224.11,122.12
  BOTTOM w0.1: UG9.BG9 v2(224.97,115.15)
  BOTTOM w0.114: QG7.4 203.99,121.39 204.92,120.45 205.49,120.45 205.81,120.13 206.05,120.13 v2(206.19,120.27) 206.19,120.38 206.82,121.01 RG12.2
I2CC_SDA: length 14
  IN1 w0.081: v2(194.3,118.11) 194.46,118.27 194.93,118.27 199.25,122.59 200.76,122.59 201.12,122.23 202.26,122.23 v2(202.6,121.89)
  BOTTOM w0.114: v2(202.6,121.89) 202.6,122.57 202.71,122.69 QG7.6 ; UG11.7 193.72,118.08 193.93,118.28 194.13,118.28 v2(194.3,118.11) 194.49,118.3 194.92,118.3 RG61.2
I2CC_SDA_R: length 32.2
  IN6 w0.081: 224.63,119.05 224.63,120.72 224.64,120.73 224.64,121.88 223,123.52 219.87,123.52 217.86,121.52 215.92,121.52 215.31,122.13 215.06,122.13 215.02,122.16 213.53,122.16 211.14,124.56 209.43,124.56 207.19,122.32 207.19,121.49 207.11,121.41 206.72,121.41 206.64,121.49 206.64,121.92 v2(206.2,122.36)
  IN6 w0.089: v2(224.94,115.75) 224.74,115.96 224.74,118.73 224.63,118.84 224.63,119.05
  BOTTOM w0.1: UG9.BH9 v2(224.94,115.75)
  BOTTOM w0.114: RG11.2 206.33,122.42 206.28,122.36 v2(206.2,122.36) 205.87,122.69 QG7.1
I2S_DATA_OUT: length 334.9
  TOP w0.107: RA33.2 39.06,34.8 39.06,34.29 39.5,33.85 v2(39.5,33.77) ; JIO.18 326.37,20.16 v2(326.45,20.07) ; v2(38.42,14.48) 38.42,14.39 38.24,14.21 UA4.14
  IN2 w0.102: v2(38.42,14.48) 38.83,14.07 39.54,14.07 40.39,13.22 42.37,13.22 44.7,15.55 54.75,15.55 55.92,14.38 82.98,14.38 84.62,16.02 96.47,16.02 99.4,18.95 126.17,18.95 127.78,20.56 169.2,20.56 169.65,21.01 181.39,21.01 181.55,20.86 182.6,20.86 183.65,19.8 188.73,19.8 192.13,16.4 192.13,16.27 193.96,14.44 193.96,14.18 194.61,13.54 196.04,13.54 196.17,13.68 196.62,14.12 196.62,14.59 197.5,15.47 201.2,15.47 201.47,15.74 202.95,15.74 203.77,16.56 207.09,16.56 208.66,14.99 214.15,14.99 214.4,14.75 237.46,14.75 239.51,16.79 246.08,16.79 246.63,16.23 247.99,16.23 251.29,19.54 257.03,19.54 258.84,21.34 259.03,21.34 259.03,21.34 266.1,21.34 266.28,21.16 266.88,21.16 267.38,21.67 269.41,21.67 269.46,21.62 271.77,21.62 272,21.39 272.01,21.39 273.4,20.01 275.2,20.01 275.92,19.29 275.92,18.53 276.34,18.11 276.34,18.11 276.57,17.87 276.94,17.87 277.21,17.6 277.66,17.15 278.22,17.15 278.6,17.15 279.68,16.07 282.78,16.07 292.38,16.07 293.37,15.08 294.19,15.08 294.81,14.47 297.53,14.47 297.69,14.62 299.5,14.62 299.64,14.76 299.78,14.76 303.36,14.76 304.7,13.41 306.82,13.41 308.39,14.98 308.63,14.98 310.14,16.49 310.53,16.49 310.72,16.49 312.4,18.18 312.57,18.34 312.57,18.86 313.44,19.73 320.37,19.73 321.42,18.68 323.6,18.68 323.68,18.6 325.43,18.6 326.41,19.57 326.41,19.72 326.45,19.76 v2(326.45,20.07)
  IN6 w0.102: v2(39.5,33.77) 38.54,32.81 38.54,30.29 39.89,28.95 39.89,16.44 38.42,14.97 v2(38.42,14.48)
I2S_DATA_OUT_R: length 4.4
  TOP w0.107: RA33.1 38.12,34.39 38.11,34.39 36.71,34.39 36.62,34.3 36.32,34.3 36.22,34.19 v1(36.22,34.06) 36.22,33.57 v2(36.56,33.23)
  BOTTOM w0.107: UA1.5 36.48,33.31 v2(36.56,33.23)
I2S_LRCK: length 337.8
  TOP w0.107: v2(39.06,14.98) 39.06,14.21 v1(38.98,14.14) 38.93,14.09 38.93,13.58 38.74,13.39 38.34,13.39 37.97,13.01 UA4.11 ; JIO.16 324.75,19.16 324.73,19.18 v2(324.62,19.18)
  IN2 w0.102: v2(324.62,19.18) 321.24,19.18 320.46,19.96 313.34,19.96 312.34,18.95 312.34,18.44 312.17,18.27 310.62,16.72 310.05,16.72 308.59,15.26 308.22,15.26 306.61,13.64 304.8,13.64 303.58,14.86 303.45,14.99 300.07,14.99 299.5,14.99 299.49,14.98 299.36,14.85 297.59,14.85 297.44,14.69 294.9,14.69 294.37,15.23 294.29,15.31 293.47,15.31 292.48,16.3 282.68,16.3 279.83,16.3 279.56,16.56 278.75,17.38 278.69,17.38 278.69,17.38 278.13,17.38 278.13,17.38 277.76,17.38 277.31,17.83 277.17,17.96 277.17,19.08 276.64,19.61 275.92,19.61 275.3,20.23 273.51,20.23 271.89,21.85 269.55,21.85 269.5,21.9 267.12,21.9 266.76,22.26 259.43,22.26 256.94,19.76 251.2,19.76 248.2,16.77 247.75,16.77 247.45,16.46 246.73,16.46 246.17,17.02 239.36,17.02 237.31,14.98 221.99,14.98 221.22,15.74 220.22,15.74 219.85,15.37 218.54,15.37 218.19,15.72 214.49,15.72 214,15.22 208.75,15.22 207.19,16.78 202.19,16.78 201.11,15.7 197.59,15.7 197.59,15.7 197.4,15.7 196.39,14.69 196.39,14.21 195.94,13.77 194.7,13.77 194.19,14.28 194.19,14.9 193.34,15.75 193.34,16.34 192.57,17.11 191.87,17.11 188.33,20.65 187.4,20.65 186.97,21.09 181.64,21.09 181.49,21.24 169.55,21.24 169.1,20.79 127.68,20.79 126.07,19.18 99.31,19.18 96.37,16.25 84.52,16.25 82.88,14.61 56.02,14.61 54.85,15.78 39.85,15.78 v2(39.06,14.98)
  IN6 w0.102: v2(38.87,36.97) 38.36,36.46 38.36,35.61 39.38,34.6 40.73,34.6 41,34.32 41,33.64 40.5,33.13 40.5,30.01 40.12,29.63 40.12,16.04 v2(39.06,14.98)
  BOTTOM w0.107: v2(38.87,36.97) 37.93,36.97 RA30.2
I2S_LRCK_R: length 3.2
  BOTTOM w0.102: RA30.1 v1(38.29,36.42)
  BOTTOM w0.107: UA1.1 36.13,34.91 36.42,35.2 37.06,35.2 37.27,35.41 RA30.1
I2S_OUT: length 335.6
  TOP w0.107: UA4.12 37.96,13.41 38.36,13.82 v2(38.49,13.82) ; v2(327.09,20.07) 326.67,19.66 JIO.17
  IN2 w0.102: v2(327.09,20.07) 326.64,19.63 326.64,18.92 325.31,17.59 324.37,17.59 323.64,18.31 323.64,18.32 323.51,18.45 321.32,18.45 320.27,19.5 313.53,19.5 312.8,18.76 312.8,18.25 312.75,18.2 312.75,18.2 310.81,16.26 310.7,16.26 309.95,15.51 309.95,15.17 307.97,13.18 304.61,13.18 303.26,14.53 299.88,14.53 299.74,14.39 297.78,14.39 297.63,14.24 294.71,14.24 294.1,14.85 293.28,14.85 293.14,14.98 292.29,15.84 282.87,15.84 279.58,15.84 279.2,16.23 264.93,16.23 264.8,16.09 263.87,15.17 252.82,15.17 251.61,13.95 240.59,13.95 239.84,13.21 217.05,13.21 216.2,12.36 201.35,12.36 199.86,10.87 193.29,10.87 191.98,12.18 191.98,13.45 192.43,13.9 192.43,14.57 192.43,14.76 190.82,16.37 186.64,16.37 185.43,17.58 182.94,17.58 179.74,20.78 169.74,20.78 169.29,20.33 127.87,20.33 126.26,18.72 99.5,18.72 96.56,15.79 84.71,15.79 83.07,14.15 55.77,14.15 54.6,15.32 44.79,15.32 42.46,12.99 40.29,12.99 39.44,13.84 38.51,13.84 v2(38.49,13.82)
  IN6 w0.102: v2(38.92,33.77) 38.31,33.16 38.31,30.05 39.57,28.8 39.57,16.5 37.99,14.93 37.99,14.32 v2(38.49,13.82)
  BOTTOM w0.102: v2(38.49,13.82) 39.51,13.82 v1(39.61,13.92)
  BOTTOM w0.107: RA31.2 39.06,34.4 39.06,33.91 v2(38.92,33.77)
I2S_OUT_R: length 3.6
  BOTTOM w0.102: RA31.1 38.07,35.26 v1(38.9,35.26)
  BOTTOM w0.107: RA31.1 36.76,34.4 36.46,34.11 UA1.3
I_SYS: length 203
  TOP w0.203: PU500.24 122.54,146.28 122.47,146.35 122.47,146.68 122.03,147.12 v2(121.95,147.12) 121.95,147.7 121.75,147.9 PR578.1 ; v2(54.49,24.83) PU700.9
  IN1 w0.254: v2(114.92,142.04) 114.54,141.66 114.54,73.4 109.47,68.32 109.47,47.65 109.44,47.63 109.44,44.35 111.64,42.15 111.64,36.82 110.12,35.3 107.17,35.3 106.46,34.59 106.46,30.06 107.49,29.04 107.49,25.77 v2(107.32,25.61)
  IN3 w0.254: v2(121.95,147.12) 121.86,147.12 120.74,146 117.86,146 114.92,143.06 v2(114.92,142.04)
  IN6 w0.254: v2(107.32,25.61) 106.12,24.4 106.12,22.79 104.94,21.61 100.5,21.61 98.75,23.36 98.02,23.36 96.88,22.22 83.38,22.22 80.15,18.98 74.99,18.98 73.52,17.52 72.53,17.52 71.38,16.37 65.29,16.37 63.85,17.81 63.85,19.68 63.32,20.21 59.96,20.21 58.12,22.05 56.14,22.05 54.49,23.7 v2(54.49,24.83)
  BOTTOM w0.102: v2(114.92,142.04) v1(114.92,142.56)
  BOTTOM w0.254: PR728.2 54.97,24.36 v2(54.49,24.83)
IADP_CHG: length 5.2
  TOP w0.102: PR717.1 53.88,28.22 v1(53.43,28.68)
  TOP w0.203: PR717.1 53.88,26.5 PC718.2 54.76,26.49 54.94,26.66 55.97,26.66 56.24,26.39 PU700.7
IDCHG_CHG: length 1.7
  TOP w0.203: PC720.2 54.61,25.6 54.98,25.23 PU700.8
IFPAB_RSET: length 16.2
  TOP w0.089: v1(242.91,121.69) 243.06,121.54 v2(243.06,121.06)
  IN2 w0.089: v2(233.94,113.8) 234.48,114.33 234.49,114.33 234.58,114.42 234.58,116.81 238.83,121.06 v2(243.06,121.06)
  BOTTOM w0.089: v2(233.94,113.8) 234.04,113.69 234.04,112.8 234.2,112.65 UG9.BD23 ; RG36.1 v2(243.06,121.06)
IFPCD_RSET: length 4.7
  TOP w0.102: RG37.1 232.43,115.98 v1(232.43,114.67) 232.43,112.81 v2(231.97,112.35)
  BOTTOM w0.1: UG9.BD20 v2(231.97,112.35)
IFPEF_RSET: length 5.9
  TOP w0.102: v2(229.87,112.35) 230.27,112.75 230.27,115.8 229.97,116.1 229.14,116.1 RG38.1
  BOTTOM w0.1: UG9.BD17 v2(229.87,112.35)
IGPU_ROM_CS#: length 21.5
  TOP w0.114: UG16.2 194.99,112.58 194.83,112.74 194.83,113.25 194.98,113.4 195.2,113.4 196.32,114.53 197.66,114.53 198.11,114.98 198.44,115.3 198.44,116.29 199.72,117.56 203.25,117.56 204.67,116.14 207.16,116.14 v1(207.43,115.88) v2(207.9,115.41)
  BOTTOM w0.089: 210.82,115.94 RG147.2
  BOTTOM w0.114: v2(207.9,115.41) 208.43,115.94 UG15.1 210.82,115.94
IGPU_ROM_SCLK: length 1.6
  BOTTOM w0.114: UG15.6 RG148.1
IGPU_ROM_SI: length 1.6
  BOTTOM w0.114: UG15.5 RG149.1
IGPU_ROM_SO: length 28.7
  TOP w0.114: UG16.5 195,111.08 194.66,110.73 194.66,109 195.46,108.2 197.55,108.2 197.74,108.39 198.4,108.39 198.85,107.93 199.72,107.93 199.96,108.17 199.96,108.99 199.77,109.19 199.77,110.12 201.02,111.37 201.02,113.92 201.96,114.86 204.93,114.86 v1(205.65,114.13) 206.28,113.51 208.26,113.51 209.61,114.87 211.72,114.87 v2(212.2,115.34)
  BOTTOM w0.089: v2(212.2,115.34) 212.62,114.92 RG146.1
IGPU_ROM_SO_R: length 3.1
  BOTTOM w0.089: RG146.2 211.83,114.74 v1(212.81,113.76)
  BOTTOM w0.114: RG146.2 211.31,114.74 211.25,114.67 UG15.2
ILIM_1.0VS_VGAP: length 4.1
  TOP w0.102: v2(239.4,42.66) v1(239.4,41.76)
  TOP w0.254: PR812.1 PR813.2 239.21,42.85 v2(239.4,42.66)
  BOTTOM w0.254: PU800.13 239.59,42.85 v2(239.4,42.66)
ILIM_1PH: length 4.1
  TOP w0.203: v2(125.6,138.27) 125.57,138.29 125.57,138.8 125.34,139.04 PU500.49
  BOTTOM w0.254: PC507.2 125.64,139.25 125.59,139.2 125.59,138.28 v2(125.6,138.27) 125.99,137.87 PR518.1
ILIM_2PH: length 5.9
  TOP w0.203: PU500.32 120.56,143.1 120.49,143.18 118.61,143.18 117.92,143.87 117.92,144.86 117.97,144.91 v2(117.95,144.91)
  BOTTOM w0.102: v2(117.95,144.91) v1(117.32,144.91)
  BOTTOM w0.254: v2(117.95,144.91) 117.97,144.91 118.32,144.55 PR542.1
ILIM_4PH: length 3.7
  TOP w0.102: PR541.2 v1(130.63,143.28)
  TOP w0.203: PR541.2 129.27,142.83 129.26,142.83 129.2,142.76 127.88,142.76 127.82,142.7 PU500.7
ILIM_+1.8VGS: length 2.7
  BOTTOM w0.254: PU802.13 227.42,42.28 227.29,42.15 PR815.2 PR814.1
ILIM_CHG: length 4.1
  TOP w0.203: PU700.21 58.64,21.19 58.83,21 58.83,20.78 59.23,20.39 PR709.1
  TOP w0.254: PQ705.3 60.62,19.91 PR711.1 PR709.1
ILIM_VCCIO: length 2.6
  BOTTOM w0.254: PU509.13 124.08,118.1 PR5034.2 PR5033.1
IMON_1PH: length 4.6
  TOP w0.203: PU500.46 124.14,138.94 124.04,138.84 v2(124.04,138.41) 124.04,138.13 124.47,137.7 125.48,137.7 PR512.2
  BOTTOM w0.254: PC506.2 123.91,138.53 v2(124.04,138.41)
IMVP_VR_ON: length 394
  TOP w0.114: UE5.121 308.46,21.21 308.56,21.31 CE38.1 309.7,21.9 310.95,21.9 311.27,22.22 311.27,22.83 311.95,23.5 311.95,23.9 312.87,24.82 314.21,24.82 v2(314.27,24.88) ; Q7.6 321.19,44.63 320.37,43.81 320.37,42.78 v2(321.19,41.95)
  IN3 w0.127: v2(122.61,132.82) 122.61,132.82 122.61,132.82 122.73,132.82 126.75,128.79 126.75,121.54 124.98,119.76 124.98,117.78 124.34,117.15 124.34,114.91 122.34,112.9 122.34,101.79 120.49,99.95 120.49,97.08 118.06,94.64 118.06,91.68 116.76,90.38 116.76,76 103.76,63 103.76,60.8 102.37,59.41 102.37,57.01 101.63,56.27 101.63,54.14 98.75,51.26 v2(98.75,49.27) ; v2(321.19,41.95) 321.6,41.54 321.6,40.03 320.81,39.24 320.81,37.3 316.38,32.87 316.38,32.06 314.52,30.21 314.52,28.53 315.1,27.96 315.1,25.71 v2(314.27,24.88)
  IN6 w0.081: v2(321.19,41.95) 320.25,41.95 317.49,44.72 317.49,46.3 316.87,46.92 315.6,46.92 314.27,45.58 309.57,45.58 307.46,43.47 306.67,43.47 306.45,43.25 291.27,43.25 289.9,41.88 274.65,41.88 269.47,47.06 257.66,47.06 256.96,47.76 250.33,47.76 248.95,49.14 243.85,49.14 243.4,49.58 238.25,49.58 237.76,49.1 232.43,49.1 231.57,49.96 227.99,49.96 226.88,51.06 224.47,51.06 224.21,50.81 216.76,50.81 216.16,51.42 213.81,51.42 210.88,54.34 210.88,56.21 208.73,58.36 206.74,58.36 206.2,58.9 203.7,58.9 203.61,58.81 201.36,58.81 201.28,58.89 199.3,60.87 196.89,60.87 196.55,60.53 196.26,60.41 195.94,60.2 195.7,60.04 195.23,59.57 194.86,59.01 194.81,58.91 194.74,58.83 194.73,58.81 192.63,56.72 189.86,56.72 189.62,56.96 188.04,56.96 187.89,57.11 187.25,57.11 187.1,56.96 186.67,56.96 184.35,54.64 184.35,43.79 180.96,40.4 175.61,40.4 174.28,39.07 173.07,39.07 172.73,38.73 169.24,38.73 168.28,37.77 122.75,37.77 119.89,40.63 112.88,40.63 111.66,41.85 107.25,41.85 105.36,43.74 105.36,44.31 100.91,48.76 99.26,48.76 v2(98.75,49.27)
  BOTTOM w0.114: PR524.2 125.06,136.27 124.7,135.92 124.7,134.82 124.56,134.68 124.56,134.04 124.18,133.66 123.45,133.66 122.61,132.82 122.61,132.82 v2(122.61,132.82)
INTRUDER#: length 2.4
  TOP w0.122: v2(213.75,19.84) 213.74,19.84 v1(213.32,19.43) 213.32,19.1 RH531.1
  BOTTOM w0.122: UH1.BB44 213.78,19.87 v2(213.75,19.84)
INV_PWM: length 117.6
  TOP w0.102: v2(170.2,159.73) 170.2,162.07 RV8.1 ; v2(188.31,100.49) 188.01,100.49 187.91,100.59 187.91,101.44 UG24.6 188.2,102.06 187.89,102.37 RG536.2 ; JEDP.36 169.12,180.34 168.16,179.37 168.16,176.34 169.48,175.02 169.48,173.21 v2(168.86,172.58)
  IN3 w0.102: v2(194.04,155.27) 193.56,155.27 192.5,154.21 188.75,154.21 188.59,154.37 182.22,154.37 182,154.6 177.12,154.6 176.65,155.08 173.88,155.08 173.63,155.33 172.78,155.33 170.2,157.9 v2(170.2,159.73)
  IN4 w0.102: v2(188.31,100.49) 189.18,101.36 189.18,103.05 188.41,103.81 188.41,106.54 189.18,107.31 189.18,109.97 190.32,111.12 190.32,114.16 193.68,117.53 193.68,120.77 194.51,121.59 194.51,123.9 195.69,125.08 196.15,125.54 196.15,126.24 196.63,126.72 196.63,127.52 197.26,128.15 197.26,148.24 197.11,148.39 197.11,148.85 194.15,151.81 194.15,155.16 v2(194.04,155.27) ; v2(168.86,172.58) 169.02,172.41 169.02,171.21 169.82,170.42 169.82,160.7 170.2,160.32 170.2,159.74 v2(170.2,159.73)
ISEN1: length 3.4
  BOTTOM w0.203: PR6026.2 271.65,135.23 v1(272.43,136.01) 273.61,137.19 PU6000.20
ISEN2: length 5.8
  BOTTOM w0.102: PR6027.2 273.07,134.42 273.07,133.73 v1(273.94,132.87)
  BOTTOM w0.203: PR6027.2 272.6,135.64 272.81,135.85 272.81,135.91 274.01,137.11 PU6000.19
ISEN3: length 2.4
  BOTTOM w0.203: PU6000.18 274.41,136.97 v1(273.77,136.34) 273.57,136.13 PR6028.2
ISEN4: length 3.2
  BOTTOM w0.203: PR6030.2 PR6070.2 275.34,136.13 v1(275.05,136.43) 274.81,136.67 PU6000.17
ISEN5: length 3
  BOTTOM w0.203: PU6000.16 275.21,137.07 275.81,136.46 v1(276.36,136.46) 276.48,136.35 276.48,135.69 PR6032.2
ISENSEP_L: length 3.2
  TOP w0.203: UA4.25 32.65,16.05 32.77,16.17 32.77,16.37
  TOP w0.508: RA77.1 RA58.2 33.34,16.94 33.12,16.72 33.12,16.71 32.89,16.49 32.89,16.49 32.77,16.37
ISENSEP_L_R: length 19.6
  TOP w0.127: v2(33.92,18.79) v1(33.92,19.59)
  IN1 w1.016: 37.47,5.39 34.97,5.39 33.98,6.37 33.98,7.1 32.97,8.12 31.57,8.12 30.55,9.13 30.55,15.23 32.86,17.54 33.4,17.54
  vias: v2(33.34,18.79) v2(37.85,4.38) v2(38.48,4.38)
ISENSEP_R: length 5.7
  TOP w0.127: v1(27.59,18.08) 27.96,17.71 RA80.1
  TOP w0.203: UA4.28 31.45,15.47 31.25,15.68 30.87,15.68
  TOP w0.508: 30.87,15.68 29.85,15.68 28.85,16.68 RA63.2 28.63,16.88 RA80.1
ISENSEP_R_R: length 16.3
  IN1 w1.016: 28.77,17.33 28.83,17.27 28.65,17.08 28.65,9.71 29.22,9.13 29.22,7.91 30.64,6.49 31.35,6.49 31.46,6.59 32.01,6.59 32.66,5.95 32.66,4.51 32.53,4.38
  BOTTOM w0.127: v1(31.15,3.1) 31.61,3.1 v2(31.73,3.23)
  vias: v2(28.49,18.22) v2(29.09,18.22) v2(32.33,3.23)
IVSENSE_L: length 3.2
  TOP w0.203: UA4.26 32.25,16.33 32.14,16.44
  TOP w0.508: 32.14,16.44 32.1,16.44 31.56,16.97 RA78.1 32.45,17.13 RA59.2
IVSENSE_R: length 3
  TOP w0.203: UA4.29 29.98,14.21 29.6,14.6
  TOP w0.508: 29.6,14.6 29.34,14.86 RA81.1 RA64.2
JKSI0: length 45.7
  TOP w0.102: v2(209.74,8.31) 211.11,9.68 216.58,9.68 217.21,10.31 220.79,10.31 221.02,10.54 223.21,10.54 223.41,10.75 223.41,12.87 223.19,13.1 v1(223.19,13.29) 223.19,14.91 224.25,15.97 224.25,17.82 224.18,17.88 224.18,19.57 224.42,19.81 225.18,19.81 225.18,19.8 226.67,19.8 227.86,21 228,21 228.52,21.52 229.9,21.52 230.15,21.26 230.32,21.26 230.86,20.72 v2(230.97,20.72)
  BOTTOM w0.102: JKB.30 208.97,7.78 209.13,7.94 209.37,7.94 v2(209.74,8.31)
  BOTTOM w0.107: v2(230.97,20.72) 231.02,20.72 231.71,21.41 231.71,28.36 231.39,28.68 231.39,31.59 RE471.1
JKSI1: length 48.5
  BOTTOM w0.102: RE474.1 227.11,34 226.79,33.68 226.79,32.31 226.29,31.8 226.29,31.16 226.56,30.89 226.56,29.31 v1(225.97,28.71) 225.84,28.58 225.84,26.71 225.17,26.05 225.04,25.91 225.04,22.9 226.74,21.2 226.74,20.95 227.38,20.31 228.13,20.31 228.21,20.22 228.21,20.22 228.52,19.92 228.52,18.98 230.2,17.29 230.21,17.29 230.59,16.92 230.59,13.68 230.42,13.52 228.05,13.52 227.47,14.09 226.91,14.09 226.39,14.61 222.45,14.61 221.89,14.04 220.57,14.04 220.01,13.48 217.52,13.48 217.31,13.26 215.89,13.26 214.75,12.12 214.75,11.72 214.64,11.62 214.47,11.44 213.26,11.44 212.8,10.99 211.47,10.99 211.19,10.71 209.99,10.71 209.47,10.19 JKB.29
JKSI2: length 40.7
  TOP w0.102: v2(230.39,20.6) 230.39,20.71 229.91,21.19 v1(229.62,21.19) 229.6,21.21 228.54,21.21 227.96,20.63 227.82,20.63 226.69,19.5 225.26,19.5 225.05,19.29 225.05,18.42 224.47,17.84 224.47,15.87 223.44,14.84 223.44,13.59 223.64,13.39 223.64,10.66 223.3,10.32 221.11,10.32 220.88,10.08 217.3,10.08 216.67,9.45 211.48,9.45 210.32,8.29 v2(210.32,8.29)
  BOTTOM w0.102: v2(210.32,8.29) 209.97,7.94 JKB.28
  BOTTOM w0.107: RE466.1 231.47,28.27 231.47,21.5 231.1,21.13 230.7,21.13 230.39,20.82 v2(230.39,20.6)
JKSI3: length 44.2
  BOTTOM w0.102: RE467.1 227.11,30.76 226.79,30.45 226.79,29.07 226.07,28.34 226.07,26.62 225.27,25.82 225.27,23 226.97,21.29 226.97,21.04 227.48,20.54 228.22,20.54 228.31,20.45 228.61,20.15 228.93,19.83 228.93,18.9 229.15,18.67 230.82,17.01 230.82,13.58 230.52,13.29 227.95,13.29 227.38,13.86 226.82,13.86 226.3,14.38 222.55,14.38 221.98,13.81 220.66,13.81 220.1,13.25 217.62,13.25 217.4,13.03 216.2,13.03 v3(215.45,12.28) 214.99,11.83 214.99,11.61 214.59,11.21 213.35,11.21 212.9,10.76 211.57,10.76 211.29,10.48 210.71,10.48 210.47,10.24 JKB.27
JKSI4: length 34.8
  TOP w0.102: v2(210.97,8.31) 211.03,8.31 v3(211.43,7.91) 211.54,7.8 212.29,7.8 212.48,7.99 212.48,8.44 213.04,8.99 216.86,8.99 217.49,9.63 221.07,9.63 221.3,9.86 223.49,9.86 224.1,10.47 224.1,14.8 224.93,15.63 224.93,16.24 228.86,20.17 229.33,20.17 229.76,20.6 229.77,20.6 v2(229.78,20.6)
  BOTTOM w0.102: v2(210.97,8.31) JKB.26
  BOTTOM w0.107: RE461.1 231.24,25.26 231.24,21.6 231,21.36 230.42,21.36 229.78,20.72 229.78,20.6 v2(229.78,20.6)
JKSI5: length 39.8
  BOTTOM w0.102: RE460.1 227.11,27.27 226.7,26.85 226.7,25.25 v3(225.8,24.35) 225.5,24.05 225.5,23.09 227.2,21.39 227.2,21.14 227.57,20.77 228.32,20.77 228.4,20.68 228.67,20.41 229.74,19.34 229.74,18.41 231.11,17.04 231.11,13.55 230.62,13.06 227.86,13.06 227.29,13.63 226.72,13.63 226.2,14.15 222.67,14.15 222.11,13.58 220.76,13.58 220.2,13.02 217.71,13.02 217.5,12.8 216.51,12.8 214.69,10.98 213.45,10.98 212.99,10.53 211.72,10.53 211.47,10.28 JKB.25
JKSI6: length 30.1
  TOP w0.102: v2(229.22,20.81) 228.96,20.55 228.47,20.55 v3(228.17,20.25) 227.76,20.25 226.26,18.75 225.97,18.75 224.7,17.48 224.7,15.72 223.87,14.89 223.87,10.56 223.4,10.09 221.21,10.09 220.98,9.85 217.4,9.85 216.76,9.22 212.89,9.22 v2(211.97,8.31)
  BOTTOM w0.102: RE455.1 230.68,22.28 229.62,22.28 229.16,21.81 229.16,20.87 v2(229.22,20.81) ; v2(211.97,8.31) JKB.24
JKSI7: length 36.4
  BOTTOM w0.102: JKB.23 212.47,10.18 212.57,10.28 213.06,10.28 213.54,10.76 214.78,10.76 216.6,12.58 217.59,12.58 217.81,12.79 220.29,12.79 220.85,13.35 222.2,13.35 222.77,13.92 226.11,13.92 226.63,13.4 227.19,13.4 227.76,12.83 230.71,12.83 231.34,13.46 231.34,17.22 230.12,18.44 v3(230.12,18.57) 230.12,19.29 228.77,20.64 228.5,20.91 228.41,21 227.67,21 227.43,21.23 227.43,21.48 225.73,23.19 225.73,23.59 226.42,24.29 RE454.1
JKSI8: length 49
  TOP w0.102: v2(212.92,8.31) 214.65,6.58 v1(224,6.58) 224.44,7.01 225.93,7.01 227.83,8.91 228.94,8.91 229.49,9.45 231.61,9.45 236.4,14.25 236.4,16.86 236.96,17.42 236.96,20.47 238.85,22.36 238.85,24.38 239.43,24.96 239.43,26.64 v2(238.83,27.23)
  BOTTOM w0.102: JKB.22 212.97,8.26 v2(212.92,8.31) ; v2(238.83,27.23) 238.83,28.36
  BOTTOM w0.107: 238.83,28.36 237.46,29.73 237.46,31.72 237.04,32.15 RE396.1
JKSI9: length 43.5
  BOTTOM w0.102: RE399.1 232.84,34 232.7,33.86 232.65,33.86 231.62,32.84 231.62,28.78 231.94,28.46 231.94,21.12 230.62,19.79 230.5,19.68 230.5,18.44 231.57,17.38 231.57,13.36 230.81,12.6 227.67,12.6 227.1,13.17 226.5,13.17 225.98,13.69 222.86,13.69 222.29,13.13 220.95,13.13 220.38,12.56 217.9,12.56 217.58,12.25 v1(217.26,12.25) 216.6,12.25 214.88,10.53 213.88,10.53 213.47,10.12 JKB.21
JKSI10: length 43.9
  TOP w0.102: v2(213.94,8.31) 215.34,6.91 v1(221.92,6.91) 222.35,7.34 225.94,7.34 227.73,9.13 228.85,9.13 231.31,11.6 231.31,13.49 233.28,15.46 233.28,15.65 233.98,16.35 235.55,16.35 236.73,17.52 236.73,20.62 238.62,22.51 238.62,24.47 239.2,25.06 239.2,26.04 v2(238.39,26.85)
  BOTTOM w0.102: 237.28,28.91 238.39,27.81 v2(238.39,26.85) ; v2(213.94,8.31) 213.94,8.25 213.97,8.22 JKB.20
  BOTTOM w0.107: 237.28,28.91 RE476.1
JKSI11: length 39.8
  BOTTOM w0.102: JKB.19 214.47,10.17 214.6,10.3 214.97,10.3 216.58,11.9 217.56,11.9 218,12.34 220.48,12.34 220.89,12.74 v3(221.71,12.74) 222.24,12.74 222.93,13.44 225.9,13.44 226.4,12.94 227,12.94 227.57,12.37 230.9,12.37 231.8,13.27 231.8,17.47 230.73,18.54 230.73,19.58 232.17,21.02 232.17,28.55 231.85,28.87 231.85,30.37 232.24,30.76 RE480.1
JKSI12: length 39.5
  TOP w0.102: v2(238.2,26.28) 238.32,26.15 238.32,22.98 236.93,21.58 236.93,21.2 236.5,20.77 236.5,17.64 235.53,16.67 235.34,16.67 233.92,16.67 233.05,15.8 233.05,15.55 230.79,13.29 v1(230.79,12.06) 230.79,11.41 228.75,9.36 227.64,9.36 225.94,7.67 215.61,7.67 v2(214.97,8.31)
  BOTTOM w0.102: v2(214.97,8.31) JKB.18 ; v2(238.2,26.28) 238.2,26.25 238.1,26.15 237.63,26.15 237.14,25.67 RE482.1
JKSI13: length 35.5
  BOTTOM w0.102: JKB.17 215.47,10.35 215.63,10.51 216.29,10.51 216.56,10.77 216.85,10.77 217.07,10.99 217.07,11.45 217.29,11.67 217.66,11.67 218.09,12.11 220.57,12.11 220.83,12.36 222.18,12.36 223.03,13.21 225.52,13.21 225.73,13 225.91,13 226.39,12.51 226.43,12.51 226.47,12.47 v3(226.84,12.47) 227.15,12.47 227.48,12.14 227.67,12.14 227.67,12.14 231,12.14 232.03,13.17 232.03,17.56 231,18.59 231,19.53 232.4,20.93 232.4,27.29 232.63,27.52 RE486.1
JKSI14: length 31.8
  TOP w0.102: v2(215.97,8.31) 216.38,7.9 225.85,7.9 227.54,9.59 228.51,9.59 v1(229.38,10.46) 230.16,11.24 230.16,12.98 232.74,15.57 232.74,15.87 233.77,16.89 235.44,16.89 236.23,17.69 236.23,21.07 v2(236.36,21.2)
  BOTTOM w0.102: RE488.1 236.36,22.05 v2(236.36,21.2) ; v2(215.97,8.31) JKB.16
JKSI15: length 31.6
  BOTTOM w0.102: RE492.1 232.79,24.29 232.62,24.12 232.62,20.83 231.23,19.44 231.23,18.68 232.25,17.66 232.25,13.08 231.23,12.05 230.94,11.76 v3(230.78,11.76) 230.08,11.76 229.93,11.92 227.76,11.92 227.38,11.92 227.21,12.09 226.48,12.09 226.26,12.32 226.08,12.32 225.42,12.98 223.12,12.98 222.27,12.13 220.93,12.13 220.67,11.88 218.18,11.88 217.88,11.57 217.88,11.02 217.4,10.54 216.68,10.54 216.47,10.33 JKB.15
JKSI16: length 37
  TOP w0.102: RE495.1 232.66,32.25 232.41,32 232.41,25.32 232.09,25 232.09,23.56 231.91,23.38 231.91,21.09 231.01,20.19 229.69,20.19 229.22,19.71 228.78,19.71 225.16,16.09 225.16,15.27 v1(224.43,14.54) 224.33,14.44 224.33,12.06 224.92,11.47 224.92,10.55 224.65,10.28 224.55,10.04 224.14,9.63 221.4,9.63 221.16,9.4 218.02,9.4 v2(216.93,8.31)
  BOTTOM w0.102: v2(216.93,8.31) 216.97,8.26 JKB.14
JKSI17: length 40.8
  TOP w0.102: RE498.1 236.77,34 237.11,33.66 237.11,33.37 237.11,32.42 237.11,32.42 237.11,32.37 237.12,32.36 237.92,31.56 237.92,30.99 237.73,30.8 237.73,28.06 236.84,27.17 236.84,25.64 237.08,25.41 237.08,24.88 236.95,24.75 236.95,24.74 235.59,23.38 235.59,23.38 235.35,23.14 235.35,23.14 235.04,22.83 235.04,20.76 234.23,19.96 234.03,19.96 233.21,19.13 233.21,18.69 231.6,17.08 231.6,16.04 228.46,12.9 228.46,12.8 v3(228.16,12.51) 227.59,11.94 v2(227.59,11.23)
  BOTTOM w0.102: v2(227.59,11.23) 227.59,11.38 227.11,11.87 226.39,11.87 226.17,12.09 225.99,12.09 225.33,12.75 223.27,12.75 222.43,11.91 221.02,11.91 220.76,11.65 218.28,11.65 218.11,11.48 218.11,10.93 217.47,10.29 JKB.13
JKSI18: length 32.2
  TOP w0.102: v2(217.97,8.31) 217.97,8.31 218.83,9.17 221.26,9.17 221.49,9.4 224.23,9.4 225.04,10.21 225.04,10.35 225.15,10.46 225.15,11.57 224.66,12.06 v1(224.66,12.32) 224.66,12.42 225.22,12.98 225.22,14.07 225.39,14.24 225.39,15.99 228.88,19.49 229.31,19.49 229.79,19.96 231.11,19.96 232.14,20.99 232.14,23.29 232.32,23.47 232.32,24.85 232.67,25.2 232.67,27.88 232.65,27.9 232.65,28.24 232.67,28.26 232.67,28.29 RE502.1
  BOTTOM w0.102: JKB.12 v2(217.97,8.31)
JKSI19: length 38.6
  TOP w0.102: v2(226.96,11.23) 226.96,11.87 226.26,12.56 v1(226.26,13.88) 226.07,14.07 226.07,15.71 229.16,18.8 229.6,18.8 229.74,18.94 231.06,18.94 232.83,20.71 232.83,22.32 233.41,22.9 233.41,23.14 234.82,24.56 236.43,24.56 236.85,24.97 236.85,25.31 236.61,25.55 236.61,27.26 237.5,28.15 237.5,30.53 237.27,30.76 RE503.1
  BOTTOM w0.102: JKB.11 218.47,10.45 218.82,10.8 219.92,10.8 219.93,10.81 220.54,10.81 220.72,10.99 220.72,11.28 221.12,11.68 222.56,11.68 223.4,12.52 225.24,12.52 225.9,11.86 226.07,11.86 226.3,11.64 226.86,11.64 226.96,11.53 v2(226.96,11.23)
JKSI20: length 28.1
  TOP w0.102: RE507.1 233.05,25.2 232.55,24.69 232.55,23.38 232.37,23.2 232.37,20.9 231.2,19.73 229.88,19.73 229.41,19.26 228.97,19.26 225.62,15.9 225.62,14.15 225.45,13.98 225.45,12.89 225.38,12.82 225.38,10.22 v1(225.37,10.21) 224.33,9.17 221.59,9.17 221.35,8.94 219.6,8.94 v2(218.97,8.31)
  BOTTOM w0.102: v2(218.97,8.31) JKB.10
JKSI21: length 25.4
  TOP w0.102: RE510.1 232.6,22.71 232.6,20.8 231.14,19.35 v3(230.54,19.35) 229.82,19.35 229.5,19.03 229.07,19.03 225.85,15.8 225.85,14.05 225.67,13.88 225.67,12.01 226.37,11.31 v2(226.37,11.23)
  BOTTOM w0.102: JKB.9 219.47,10.4 219.64,10.57 220.62,10.57 220.82,10.76 221.47,10.76 221.71,11 221.71,11.21 221.95,11.45 222.65,11.45 223.49,12.29 225.14,12.29 225.8,11.63 225.97,11.63 v2(226.37,11.23)
JKSO0: length 63.2
  TOP w0.102: 226.98,25.22 226.7,25.49 226.7,26.28 226.44,26.54 226.01,26.54 225.94,26.47 QE54.6 ; QE49.6 230.34,27.25 230.48,27.38 230.48,27.79 230.58,27.89 231.41,27.89 231.71,28.2 231.71,32.29 232.14,32.71 232.14,34.86 232.37,35.1 232.37,35.61 232.61,35.85 v1(232.61,36) 232.8,36.19 235.78,36.19 237.34,34.63 237.34,33.28 237.34,33.28 237.34,32.52 237.34,32.46 238.15,31.66 238.15,30.9 237.96,30.71 237.96,27.96 237.07,27.08 237.07,25.74 237.31,25.5 237.31,24.97 237.31,24.78 235.82,23.29 235.82,23.29 235.44,22.91 235.44,22.91 235.26,22.74 235.26,20.62 235.3,20.58 235.3,18.81 234.96,18.47 233.5,18.47 231.83,16.8 231.83,15.94 229,13.12 228.74,12.85 228.74,11.25 228.18,10.7 226.42,10.7 225.87,10.14 225.74,10.01 224.67,8.94 221.68,8.94 221.45,8.71 220.38,8.71 v2(219.97,8.31)
  TOP w0.107: 226.98,25.22 228.12,25.22 228.5,25.6 228.5,27.06 228.69,27.25 QE49.6
  BOTTOM w0.102: v2(219.97,8.31) JKB.8
JKSO1: length 31.6
  TOP w0.102: QE54.3 224.64,28.02 224.54,28.12 223.98,28.12 223.74,27.88 223.06,27.88 222.87,27.69 222.87,25.73 222.35,25.2 222.35,25.01 223.05,24.31 223.05,23.64 222.32,22.91 222.32,21.9 222.55,21.68 223.77,21.68 224.08,21.99 224.48,21.99 224.63,21.99 225.44,21.19 225.76,21.19 225.94,21.36 QE50.6 226.45,21.97 226.45,20.75 226.01,20.31 224.27,20.31 223.72,19.76 223.72,17.45 223.74,17.43 223.74,16.39 222.26,14.91 v3(222.26,11.59) 222.26,11.17 222.39,11.04 v2(222.39,11.04)
  BOTTOM w0.107: v2(222.39,11.04) 222.39,11.04 222.13,11.04 221.62,10.53 220.91,10.53 220.47,10.09 JKB.7
JKSO2: length 59.6
  TOP w0.102: v2(220.97,8.31) 221.37,8.31 221.78,8.72 224.77,8.72 225.97,9.92 226.3,10.25 v3(227.26,10.25) 228.06,10.25 228.96,11.16 228.96,12.76 229.1,12.89 232.06,15.85 232.06,16.33 233.31,17.58 235.15,17.58 235.53,17.96 235.53,20.68 235.49,20.72 235.49,22.64 235.54,22.69 235.54,22.69 236.04,23.19 236.04,23.19 237.53,24.68 237.53,24.87 237.53,25.06 237.53,25.06 237.53,25.59 237.3,25.83 237.3,26.98 238.18,27.87 238.18,30.61 238.38,30.8 238.38,31.8 237.57,32.61 237.57,33.18 237.57,34.72 235.88,36.41 231.38,36.41 231.24,36.27 231.24,35.7 231.68,35.25 231.68,32.9 231.24,32.46 231.24,31.38 231,31.14 231,31.14 230.98,31.13 230.58,31.13 230.47,31.03 230.47,30.56 230.4,30.49 QE51.6 228.71,30.49 228.61,30.38 228.61,28.82 228.29,28.5 226.89,28.5 226.48,28.91 QE55.6
  BOTTOM w0.102: v2(220.97,8.31) JKB.6
