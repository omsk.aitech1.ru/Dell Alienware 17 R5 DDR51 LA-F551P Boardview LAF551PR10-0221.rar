# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_MA6: length 67
  IN1 w0.089: v2(149.75,99.12) 149.35,99.12 148.77,98.54 148.77,86.96 148.17,86.37 148.17,85.65
  IN1 w0.13: v2(141.59,45.52) 141.79,45.52 142.14,45.87 142.14,49.01 141.68,49.47 141.68,52.71 141.84,52.87 141.99,52.87 142.14,53.02 142.14,53.4 141.99,53.55 141.84,53.55 141.68,53.71 141.68,54 141.84,54.16 142.03,54.16 142.14,54.27 142.14,54.6 142.01,54.73 141.81,54.73 141.68,54.85 141.68,55.22 141.81,55.35 142.01,55.35 142.17,55.51 142.17,61.18 142.32,61.33 142.51,61.33 142.66,61.48 142.66,61.8 142.5,61.95 142.32,61.95 142.17,62.11 142.17,62.42 142.32,62.57 142.5,62.57 142.66,62.73 142.66,64.85 142.5,65.01 142.32,65.01 142.17,65.16 142.17,65.47 142.32,65.62 142.5,65.62 142.66,65.78 142.66,66.09 142.5,66.24 142.32,66.24 142.17,66.4 142.17,66.71 142.32,66.86 142.5,66.86 142.66,67.02 142.66,74.44 142.53,74.57 142.38,74.57 142.25,74.7 142.25,74.96 142.38,75.09 142.53,75.09 142.66,75.22 142.66,75.47 142.53,75.6 142.38,75.6 142.25,75.73 142.25,75.99 142.38,76.12 142.53,76.12 142.66,76.25 142.66,76.52 147.56,81.43 147.56,83.99 148.17,84.6 148.17,85.65
  BOTTOM w0.076: UC1.AN7 149.29,99 149.37,98.92 149.55,98.92 v2(149.75,99.12)
  BOTTOM w0.185: v2(141.59,45.52) 142.94,46.86 142.94,47.62 143.19,47.87 JDIMM2.127
DDR_B_MA7: length 67.8
  IN1 w0.089: v2(149.75,101.57) 149.38,101.21 149.38,100.14 149,99.76 149,99.37 148.39,98.76 148.39,87.34 147.01,85.97 146.44,85.97 146.35,85.88 146.35,85.65
  IN1 w0.13: v2(141.59,44.17) 141.59,44.12 141.47,43.99 141.26,43.99 141.13,44.12 141.13,48.6 140.76,48.97 140.76,52.52 140.64,52.65 140.5,52.65 140.35,52.81 140.35,53.11 140.5,53.27 140.61,53.27 140.76,53.42 140.76,53.68 140.61,53.84 140.47,53.84 140.35,53.96 140.35,54.29 140.47,54.41 140.63,54.41 140.74,54.51 140.74,59.95 141.25,60.46 141.25,76.41 146.35,81.51 146.35,85.65
  BOTTOM w0.076: v2(149.75,101.57) UC1.AN10
  BOTTOM w0.185: v2(141.59,44.17) 141.86,44.17 142.26,43.77 142.26,42.14 141.94,41.83 JDIMM2.122
DDR_B_MA8: length 65.7
  IN1 w0.089: v2(149.73,99.69) 149.58,99.69 148.56,98.68 148.56,87.2 147.75,86.39 147.75,85.68 147.71,85.65
  IN1 w0.13: v2(141.61,46.88) 141.68,46.96 141.68,48.82 141.22,49.28 141.22,59.78 141.71,60.27 141.71,67.29 141.86,67.44 142.04,67.44 142.2,67.6 142.2,67.91 142.04,68.06 141.86,68.06 141.71,68.22 141.71,68.53 141.86,68.68 142.04,68.68 142.2,68.84 142.2,69.15 142.04,69.3 141.86,69.3 141.71,69.46 141.71,69.77 141.86,69.92 142.04,69.92 142.2,70.08 142.2,70.39 142.04,70.54 141.86,70.54 141.71,70.7 141.71,71.01 141.86,71.16 142.04,71.16 142.2,71.32 142.2,71.63 142.04,71.78 141.86,71.78 141.71,71.94 141.71,72.25 141.86,72.4 142.04,72.4 142.2,72.56 142.2,72.87 142.04,73.02 141.86,73.02 141.71,73.18 141.71,73.49 141.86,73.64 142.04,73.64 142.2,73.8 142.2,74.11 142.04,74.26 141.86,74.26 141.71,74.42 141.71,76.22 146.8,81.31 146.8,83.03 147.1,83.33 147.1,83.66 146.81,83.95 146.81,84.23 146.96,84.39 147.31,84.39 147.46,84.54 147.46,84.79 147.31,84.95 146.96,84.95 146.81,85.1 146.81,85.38 146.95,85.53 147.59,85.53 147.71,85.65
  BOTTOM w0.076: UC1.AN8 149.47,99.95 v2(149.73,99.69)
  BOTTOM w0.185: v2(141.61,46.88) 141.78,46.71 142.06,46.71 142.44,47.08 142.44,47.28 142.25,47.47 142.25,47.72 142.69,48.17 JDIMM2.125
DDR_B_MA9: length 66.1
  IN1 w0.089: 145.43,85.65 145.43,86.16 145.66,86.39 146.31,86.39 147.93,88.01 147.93,98.81 148.47,99.35 148.47,100.96 v2(147.91,101.52)
  IN1 w0.13: 145.43,85.65 145.43,81.88 140.33,76.78 140.33,60.84 139.4,59.91 139.4,49.04 140.21,48.22 140.21,45.88 v2(139.72,45.39)
  BOTTOM w0.076: v2(147.91,101.52) 147.53,101.9 UC1.AR11
  BOTTOM w0.185: JDIMM2.121 141.69,47.89 140.36,46.55 140.36,46.03 v2(139.72,45.39)
DDR_B_MA10: length 67.6
  IN1 w0.089: 154.78,85.65 154.78,87.41 153.88,88.31 153.88,95.46 153.49,95.86 153.49,99.54 v2(153.41,99.62)
  IN1 w0.13: 154.78,85.65 154.78,76.29 149.25,70.76 149.25,61.46 149.75,60.97 149.75,53.8 148.82,52.87 148.82,47.84 148.91,47.75 148.91,43.26 149.49,42.68 149.49,42.09 149.23,41.84 148.15,41.84 147.99,42 147.99,42.44 v2(148.47,42.93)
  BOTTOM w0.076: v2(153.41,99.62) UC1.AH7
  BOTTOM w0.185: v2(148.47,42.93) 148.86,42.93 149.95,41.84 149.95,40.8 JDIMM2.146
DDR_B_MA11: length 70.3
  IN1 w0.089: v2(149.75,102.22) 149.2,101.68 149.2,100.21 148.82,99.83 148.82,99.45 148.11,98.73 148.11,87.83 146.49,86.21 146.11,86.21 145.89,85.99 145.89,85.65
  IN1 w0.13: 145.89,85.65 145.89,81.7 140.79,76.6 140.79,60.65 140.28,60.14 140.28,55.29 139.89,54.9 139.89,49.2 140.67,48.41 140.67,42.29 140.83,42.13 142.15,42.13 142.28,42.26 142.28,42.79 142.14,42.93 141.63,42.93 v2(141.61,42.9)
  BOTTOM w0.076: v2(149.75,102.22) UC1.AN11
  BOTTOM w0.185: v2(141.61,42.9) 141.44,42.74 JDIMM2.120
DDR_B_MA12: length 64.4
  IN1 w0.089: 144.97,85.65 144.97,86.27 145.8,87.11 145.8,90.08 146.01,90.29 146.44,90.29 147.04,89.69 147.45,89.69 147.7,89.94 147.7,98.83 147.75,98.88 147.91,99.04 147.91,99.08 147.99,99.15 147.99,99.72 148.3,100.02 148.3,100.79 148.18,100.91 v2(147.92,100.91)
  IN1 w0.13: 144.97,85.65 144.97,82.07 139.45,76.55 139.45,62.72 139.6,62.56 139.71,62.56 139.87,62.41 139.87,62.1 139.71,61.94 139.6,61.94 139.45,61.79 139.45,60.61 138.94,60.1 138.94,48.85 139.72,48.07 v2(139.72,46.74)
  BOTTOM w0.076: UC1.AR10 147.59,101.25 v2(147.92,100.91)
  BOTTOM w0.185: v2(139.72,46.74) 139.82,46.74 141.19,48.11 JDIMM2.119
DDR_B_MA13: length 70.4
  IN1 w0.089: v2(155.24,100.92) 154.65,100.34 154.65,99.43 154.98,99.1 154.98,96.38 155.77,95.6 155.77,89.4 157.28,87.89 157.28,85.65
  IN1 w0.13: v2(153.61,42.47) 153.61,42.15 153.48,42.02 153,42.02 152.87,42.15 152.87,42.66 152.74,42.79 152.48,42.79 152.35,42.66 152.35,42.15 152.22,42.02 151.86,42.02 151.73,42.15 151.73,50.37 152.65,51.29 152.65,53.03 153.94,54.31 153.94,56.67 153.32,57.28 153.32,60.92 152.37,61.86 152.37,63.7 151.75,64.32 151.75,69.71 157.28,75.24 157.28,85.65
  BOTTOM w0.076: v2(155.24,100.92) UC1.AF9
  BOTTOM w0.185: v2(153.61,42.47) 153.38,42.47 152.95,42.04 152.95,40.8 JDIMM2.158
DDR_B_MA14_WE#: length 65
  IN1 w0.089: 156.16,85.65 156.16,87.74 155.26,88.64 155.26,95.18 154.02,96.43 154.02,99.11 154.21,99.3 154.21,100.62 153.95,100.88 153.95,101.68 v2(153.41,102.22)
  IN1 w0.13: v2(150.99,45.97) 150.55,46.41 150.55,47.73 150.6,47.78 150.6,50.84 151.22,51.45 151.22,53.19 151.8,53.77 151.8,60.85 151.25,61.4 151.25,63.24 150.63,63.86 150.63,70.17 156.16,75.7 156.16,85.65
  BOTTOM w0.076: v2(153.41,102.22) UC1.AH11
  BOTTOM w0.185: v2(150.99,45.97) 151.58,46.57 151.58,47.67 151.2,48.06 JDIMM2.151
DDR_B_MA15_CAS#: length 70.4
  IN1 w0.089: v2(155.24,100.28) 154.85,99.9 154.85,99.48 155.2,99.13 155.2,96.56 156.04,95.72 156.04,89.76 157.74,88.07 157.74,85.65
  IN1 w0.13: 157.74,85.65 157.74,75.05 152.21,69.52 152.21,64.51 152.86,63.87 152.86,62.97 153.31,62.52 153.31,62.3 153.05,62.05 153.05,61.83 153.27,61.61 153.49,61.61 153.75,61.87 153.97,61.87 154.39,61.44 154.39,59.93 154.24,59.77 153.94,59.77 153.78,59.62 153.78,59.31 153.94,59.15 154.24,59.15 154.39,59 154.39,58.69 154.24,58.54 153.94,58.54 153.78,58.38 153.78,58.07 153.94,57.92 154.24,57.92 154.39,57.76 154.39,54.12 153.13,52.85 153.13,51.12 152.29,50.28 152.29,43.61 152.64,43.25 153.18,43.25 v2(153.61,43.69)
  BOTTOM w0.076: v2(155.24,100.28) UC1.AF8
  BOTTOM w0.185: v2(153.61,43.69) 153.52,43.69 152.44,42.62 JDIMM2.156
DDR_B_MA16_RAS#: length 67.8
  IN1 w0.089: v2(153.41,101.57) 153.78,101.2 153.78,100.65 154.01,100.42 154.01,99.35 153.84,99.19 153.84,96 154.34,95.51 154.34,88.8 155.7,87.44 155.7,85.65
  IN1 w0.13: 155.7,85.65 155.7,75.89 150.17,70.36 150.17,61.84 151.34,60.67 151.34,55.12 151.2,54.98 150.89,54.98 150.76,54.85 150.76,54.54 150.89,54.41 151.19,54.41 151.34,54.26 151.34,53.96 151.22,53.83 150.95,53.83 150.76,53.64 150.76,51.64 149.74,50.62 149.74,48.21 149.98,47.96 149.98,45.37 150.9,44.45 v2(150.99,44.45)
  BOTTOM w0.076: v2(153.41,101.57) UC1.AH10
  BOTTOM w0.185: JDIMM2.152 151.44,41.88 151.64,42.08 151.64,43.79 v2(150.99,44.45)
DDR_B_ODT0: length 66.8
  IN1 w0.089: 158.3,85.65 158.3,88.08 156.35,90.03 156.35,95.75 155.46,96.64 155.46,99.43 v2(155.24,99.65)
  IN1 w0.13: v2(152.85,47.37) 152.87,47.39 152.87,50.07 153.69,50.88 153.69,52.62 154.96,53.89 154.96,61.67 153.92,62.71 153.92,63.63 153.79,63.75 153.55,63.75 153.42,63.88 153.42,64.14 153.55,64.27 153.79,64.27 153.92,64.4 153.92,64.65 153.7,64.87 153.01,64.87 152.85,65.02 152.85,65.33 153.01,65.49 153.76,65.49 153.92,65.64 153.92,65.95 153.76,66.11 153.01,66.11 152.85,66.26 152.85,66.57 153.01,66.73 153.75,66.73 153.92,66.9 153.92,67.19 153.76,67.35 153.01,67.35 152.85,67.5 152.85,67.81 153.01,67.97 153.76,67.97 153.92,68.12 153.92,68.43 153.76,68.59 153.01,68.59 152.85,68.74 152.85,69.05 153.01,69.21 153.74,69.21 153.92,69.38 153.92,70.43 158.3,74.81 158.3,85.65
  BOTTOM w0.076: v2(155.24,99.65) UC1.AF7
  BOTTOM w0.185: JDIMM2.155 152.2,48.03 v2(152.85,47.37)
DDR_B_ODT1: length 70.1
  IN1 w0.089: 159.22,85.65 159.22,88.43 156.94,90.71 156.94,96.42 156.47,96.89 156.47,99.17 v2(156.12,99.52)
  IN1 w0.13: v2(152.85,44.45) 153.79,45.39 153.79,48.05 154.7,48.95 154.7,49.55 155.12,49.97 155.12,52.76 155.88,53.51 155.88,62.05 154.84,63.09 154.84,63.3 154.97,63.43 155.77,63.43 155.9,63.56 155.9,63.82 155.77,63.95 154.97,63.95 154.84,64.08 154.84,64.33 154.97,64.46 155.77,64.46 155.9,64.59 155.9,64.85 155.77,64.98 154.97,64.98 154.84,65.11 154.84,65.87 154.99,66.02 155.59,66.02 155.75,66.18 155.75,66.44 155.96,66.65 155.96,66.95 155.75,67.17 155.75,67.47 155.96,67.69 155.96,67.99 155.75,68.21 155.75,68.51 155.96,68.73 155.96,69.03 155.75,69.25 155.75,70.96 159.22,74.43 159.22,85.65
  BOTTOM w0.076: v2(156.12,99.52) UC1.AE8
  BOTTOM w0.185: JDIMM2.161 153.69,48.04 153.87,47.87 153.87,45.47 v2(152.85,44.45)
DDR_B_PAR: length 63.8
  IN1 w0.089: 153.76,85.65 153.48,85.92 153.48,95.36 153.13,95.71 153.13,98.46 152.49,99.09 v2(152.49,99.62)
  IN1 w0.13: v2(148.47,45.97) 148.16,45.97 147.8,46.33 147.8,49.42 147.65,49.57 147.46,49.57 147.31,49.73 147.31,50.03 147.46,50.18 147.65,50.18 147.8,50.34 147.8,50.67 147.65,50.82 147.46,50.82 147.31,50.97 147.31,51.28 147.46,51.43 147.65,51.43 147.8,51.58 147.8,53.29 148.34,53.83 148.34,60.38 148.15,60.58 148.15,72.72 148.74,73.31 150.36,73.31 151.82,74.77 151.82,76.94 153.76,78.87 153.76,85.65
  BOTTOM w0.076: v2(152.49,99.62) UC1.AJ7
  BOTTOM w0.185: v2(148.47,45.97) 148.07,45.97 147.33,46.72 147.33,47.94 147.2,48.07 JDIMM2.143
DDR_DRAMRST#: length 19.3
  TOP w0.114: CD69.1 138.32,53.17 RD31.1 138.32,52.39 138.18,52.25 CD91.1 ; v2(137.41,51.68) 137.52,51.57 CD91.1 ; CD91.1 CD92.1
  IN4 w0.127: v2(137.41,51.68) 136.85,51.13 136.85,49.2 137.41,48.65 137.41,42.42 v2(137.55,42.28)
  BOTTOM w0.114: JDIMM1.108 138.44,52.07 138.06,51.68 v2(137.41,51.68) ; v2(137.55,42.28) 137.87,42.28 138.44,41.7 JDIMM2.108
DDR_RCOMP0: length 7
  BOTTOM w0.089: 171.81,91.02 171.97,91.18 RH148.2
  BOTTOM w0.127: v1(172.13,90.08) 171.71,90.5 171.71,90.92 171.81,91.02
  BOTTOM w0.254: UC1.G1 169.6,95.39 170.19,94.8 170.63,94.8
  BOTTOM w0.381: 170.63,94.8 171.97,93.46 RH148.2
DDR_RCOMP1: length 5.3
  BOTTOM w0.089: RH149.2 169.16,92.52 169.62,92.07 169.62,90.83 v1(169.48,90.69)
  BOTTOM w0.254: 169.29,94.11 168.54,94.86 UC1.H1
  BOTTOM w0.381: 169.29,94.11 169.29,92.69 RH149.2
DDR_RCOMP2: length 5.5
  BOTTOM w0.089: RH150.2 167.72,92.56 167.33,92.95 v1(167.33,93.27)
  BOTTOM w0.254: UC1.J2 167.96,95.76 167.96,94.79 168.73,94 168.73,93.44
  BOTTOM w0.381: RH150.2 168.27,92.98 168.73,93.44
DDR_VTT_PG_CTRL: length 27.5
  TOP w0.102: v2(131.31,103.98) 131.24,103.98 v3(129.9,102.64) 127.24,99.98 127.24,97.35 127.96,96.64 127.96,88.19 124.93,85.16 UC2.2
  BOTTOM w0.089: v2(131.31,103.98) 131.88,103.41 UC1.BT13
DEBUG_CTL1: length 2.2
  TOP w0.102: RT66.2 198.89,162.7
  TOP w0.107: v2(199.17,163.57) 199.02,163.57 198.76,163.31 198.76,162.82 198.89,162.7
  BOTTOM w0.076: 199.35,163.74 v2(199.17,163.57)
  BOTTOM w0.089: UT4.E4 199.47,163.87 199.35,163.74
DEBUG_CTL2: length 3.3
  TOP w0.102: v1(200.88,164.68) 200.88,164.29 199.82,163.22 v2(199.82,163.01)
  TOP w0.107: v2(199.82,163.01) 199.82,162.37 RT67.2
  BOTTOM w0.076: 199.95,163.14 199.83,163.01 v2(199.82,163.01)
  BOTTOM w0.089: UT4.D5 200.16,163.34 199.95,163.14
DEMB0: length 3.8
  BOTTOM w0.102: 137.91,155.88 137.91,155.07 138.17,154.8 138.69,154.8 RM75.2 138.83,154.05 RM79.2
  BOTTOM w0.107: 137.91,155.88 137.31,156.48 UM8.53
DEMB1: length 4.6
  BOTTOM w0.107: UM8.54 137.29,155.98 137.47,155.79 137.47,154.93 137.75,154.65 v1(137.75,153.93) 137.6,153.78 RM62.2 138.4,152.94 138.5,152.84
DEPOP#_EC: length 365.6
  TOP w0.102: v2(330.97,41.64) 330.97,41.64 330.97,41.65 330.97,41.65 330.54,42.08 UE6.2
  IN2 w0.089: 203.5,43.9 203.26,43.65 199.59,43.65 199.18,44.06 198.42,44.06 198.16,44.33 197.69,44.33 197.08,43.72 196.52,43.72 196.4,43.84 194.44,43.84 194.11,43.51 193.27,43.51
  IN2 w0.102: v2(323.45,27.13) 323.4,27.08 322.78,27.08 319.9,29.96 315.92,29.96 315.01,29.05 312.9,29.05 312.31,29.65 311.98,29.65 310.41,28.07 309.38,28.07 308.5,27.19 308.5,26.13 308.07,25.69 306.47,25.69 305.5,24.72 304.06,24.72 296.6,24.72 295.68,23.79 294.89,23.79 289.85,28.83 283.45,28.83 279.64,32.64 276.25,32.64 265.77,43.12 245.6,43.12 244.18,41.7 241.04,41.7 239.67,43.07 238.7,43.07 237.46,44.31 235.85,44.31 235.19,43.65 229.77,43.65 229.57,43.45 225.03,43.45 223.79,44.69 217.58,44.69 217.2,45.08 211.61,45.08 211.16,45.52 205.43,45.52 203.9,43.99 203.6,43.99 203.5,43.9 ; v2(38.24,22.34) 41.22,25.33 41.22,32.06 40.33,32.95 38.62,32.95 38.35,33.21 38.35,35.61 35.23,38.74 35.23,40.86 35.43,41.06 37.26,41.06 39.47,43.27 39.47,46.55 40.84,47.92 48.51,47.92 49.96,46.47 52.96,46.47 53.44,45.99 54.42,45.99 55.1,46.67 57.38,46.67 58.49,47.77 63.61,47.77 64.31,47.07 65.04,47.07 65.23,46.88 87.6,46.88 87.77,47.05 93.35,47.05 94.08,46.33 96.35,46.33 96.52,46.51 98.59,46.51 98.76,46.35 106.89,46.35 112.76,40.48 132.31,40.48 135.23,37.56 180.74,37.56 184.55,41.37 185.01,41.37 186.34,42.69 189.39,42.69 190.23,43.53 191.86,43.53 191.88,43.51 193.27,43.51
  IN3 w0.102: v2(323.45,27.13) 323.45,26.66 323.95,26.17 325.59,26.17 326.53,27.11 326.53,33.65 330.62,37.74 330.62,38.69 330.23,39.08 330.23,40.47 331.03,41.27 331.03,41.58 v2(330.97,41.64)
  BOTTOM w0.102: v2(38.24,22.34) 38.46,22.57 DA2.3
DET: length 230.5
  TOP w0.102: RV675.1 v1(166.54,184.39) 166.77,184.39 166.95,184.22 v2(166.95,183.58)
  IN3 w0.089: 192.16,24.83 192.16,32.25 196.41,36.5 196.73,36.5 198.01,37.78 198.01,41.77 196.73,43.04 196.73,44.19 196.41,44.51 196.41,45.7 ; 192.54,21.45 193.62,20.37 194.76,20.37 195.4,19.73 195.6,19.73 195.72,19.61 195.72,19.18 195.15,18.62 195.15,18.54 194.95,18.34 194.95,17.83 195.11,17.68 196.89,17.68 196.99,17.77 200.86,17.77 201.3,17.33 201.3,16.96
  IN3 w0.102: v2(197.12,46.88) 197.12,46.48 196.41,45.77 196.41,45.7 ; 192.16,24.83 192.54,24.45 192.54,21.45 ; 201.3,16.96 v2(201.3,16.82)
  IN4 w0.102: v2(197.12,46.88) 197.71,47.47 197.71,49.56 192.51,54.77 186.98,54.77 186.28,55.47 186.28,55.72 186.26,55.74 185.89,56.11 185.89,56.66 185.16,57.38 185.16,62.35 184.57,62.95 184.57,63.53 185.3,64.26 185.3,70.33 186.11,71.14 186.11,76.7 185.72,77.09 185.72,83.75 186.43,84.46 186.43,88.11 186.74,88.41 186.74,94.34 183.52,97.55 183.52,102.16 183.61,102.25 183.61,103.8 183.4,104.02 183.4,105.52 184.05,106.17 184.05,109.24 184.36,109.55 184.36,111.26 185.05,111.94 185.05,113.08 185.17,113.21 185.17,120.1 192.19,127.11 192.19,127.71 193,128.52 193,128.93 193,129.34 193.65,129.99 193.65,146.73 189.62,150.76 189.3,150.76 185.5,154.56 185.19,154.56 184.76,154.99 181.9,154.99 180.57,156.33 176.89,156.33 176.27,156.95 172.6,156.95 172.09,156.44 171.96,156.31 169.62,156.31 169.07,156.87 169.07,157.08 166.39,159.76 166.39,161.71 167.15,162.47 167.15,167.63 166.86,167.92 164.47,167.92 161.34,171.06 161.34,173.8 163.17,175.63 163.17,175.91 163.64,176.39 163.64,179.81 164.83,180.99 164.83,181.48 166.72,183.37 166.73,183.37 v2(166.95,183.58)
  BOTTOM w0.089: 201.43,16.96 201.43,17.83 201.33,17.94 201.33,18.81 UH1.T46
  BOTTOM w0.102: RH584.1 199.84,13.52 200.42,14.09 200.42,15.94 v2(201.3,16.82) 201.34,16.82 201.43,16.91 201.43,16.96
DEVSLP0: length 106.7
  IN6 w0.089: 191.87,25.39 192.21,25.73 192.21,26.03 192.77,26.6 194.4,26.6 195.29,25.71 196.48,25.71 196.73,25.96 199.47,25.96 199.64,25.78 200.27,25.78 203.02,23.03 203.02,22.85 203.65,22.22 205.43,22.22 205.77,21.88 205.77,21.56 205.98,21.35 206.3,21.35 206.7,20.95 206.7,18.16 207.6,17.26 v2(207.97,17.26)
  IN6 w0.102: v2(120.66,13.28) 123.5,16.12 126.1,16.12 129.15,19.17 157.93,19.17 158.55,19.79 160.33,19.79 162.64,22.1 178.91,22.1 180.79,23.98 184.77,23.98 185.86,25.07 185.86,26.77 187.38,28.29 188.9,28.29 189.18,28.01 189.18,26.93 189.61,26.5 189.82,26.5 191,25.32 191.8,25.32 191.87,25.39
  BOTTOM w0.089: v2(207.97,17.26) 208.46,17.75 UH1.AL48
  BOTTOM w0.102: JHDD.13 119.42,12.79 119.91,13.28 v2(120.66,13.28)
DEVSLP1: length 62.9
  IN4 w0.089: v2(207.46,17.96) 206.64,18.79 206,18.79 205.56,19.23 205.56,21.96 206.19,22.6 206.64,22.6 207.08,23.04 207.08,24.06 207.53,24.5 v2(207.65,24.5)
  IN6 w0.089: 208.89,16.96 208.14,17.71 207.72,17.71 v2(207.46,17.96)
  IN6 w0.102: 208.89,16.96 209.27,16.57 209.69,16.57 210.39,15.87 210.74,15.87 211.45,16.58 211.97,16.58 212.33,16.21 212.67,16.21 213.03,16.58 215,16.58 215.12,16.69 218.21,16.69 218.76,16.15 219.43,16.15 220.84,17.55 222.58,17.55 222.7,17.67 222.75,17.71 223.98,17.71 224.88,16.82 226.01,16.82 227.43,18.24 230.66,18.24 230.72,18.18 231.27,17.63 233.95,17.63 v2(234.31,18)
  BOTTOM w0.089: UH1.AH35 207.54,24.61 v2(207.65,24.5)
  BOTTOM w0.102: JSSD3.38 244.77,9.99 244.17,10.6 243.33,10.6 241.68,8.94 240.23,8.94 238.05,11.12 233.86,11.12 233.64,11.34 233.64,16.66 v1(234.31,17.33) v2(234.31,18)
DEVSLP3: length 88.8
  TOP w0.089: v2(211.36,20.07) v1(211.36,19.56)
  IN2 w0.089: 215.42,16.96 215.02,17.35 213.45,17.35 211.36,19.43 v2(211.36,20.07)
  IN2 w0.102: 215.42,16.96 215.68,16.69 218.67,16.69 218.96,16.4 219.32,16.4 219.79,16.88 220.95,16.88 221.83,17.76 223.52,17.76 224.85,16.43 231.79,16.43 232.2,16.84 236.11,16.84 237.2,17.94 246.8,17.94 246.82,17.96 248.1,17.96 248.48,18.34 248.48,20.76 248.23,21.01 248.23,21.17 247.95,21.45 247.95,21.57 247.95,25.53 248.1,25.68 248.44,26.03 255.75,26.03 258.6,23.17 270.07,23.17 270.16,23.26 270.3,23.4 271.71,23.4 273.96,21.15 275.68,21.15 275.81,21.02 275.81,21.01 276.3,20.53 277.02,20.53 278.27,19.28 v2(278.27,18.49)
  BOTTOM w0.089: UH1.AP48 210.02,18.3 210.37,18.65 210.37,18.71 210.38,18.72 210.38,18.96 210.3,19.04 210.3,19.47 210.65,19.82 211.11,19.82 v2(211.36,20.07)
  BOTTOM w0.102: v2(278.27,18.49) 278.06,18.28 278.06,17.08 278.33,16.81 JSSD2.38
DEVSLP4: length 153.9
  TOP w0.089: v2(210.73,19.16) v1(210.73,18.42)
  IN1 w0.089: 212.91,16.96 212.66,17.21 212.41,17.21 212.22,17.4 211.95,17.4 210.83,18.52 210.83,19.08 210.73,19.18 v2(210.73,19.16)
  IN1 w0.102: 212.91,16.96 213.43,16.44 214.19,16.44 214.58,16.82 216.47,16.82 216.58,16.7 218.67,16.7 218.98,16.4 219.43,16.4 219.73,16.7 221.53,16.7 221.63,16.61 v2(223.34,16.61)
  IN6 w0.102: v2(223.34,16.61) 224.37,16.61 224.54,16.44 230.1,16.44 231.06,17.4 240.47,17.4 242.68,15.19 244.59,15.19 244.96,14.82 248.83,14.82 250.12,16.1 250.12,16.55 251.94,18.37 261.72,18.37 262.52,19.17 266.2,19.17 266.43,18.94 266.93,18.94 267.13,18.73 274.01,18.73 274.63,18.11 274.75,18.11 275.65,17.2 295.19,17.2 295.2,17.21 300.11,17.21 300.72,16.6 303.12,16.6 304.01,15.71 304.69,15.71 305.29,16.31 307.08,16.31 308.12,15.26 314.81,15.26 315.63,14.44 317.01,14.44 v2(317.38,14.07)
  BOTTOM w0.107: JSSD1.38 334.76,40.66 335.99,39.42 335.99,30.48 329.94,24.44 328.28,24.44 319.98,16.13 319.98,15.45 318.59,14.07 v2(317.38,14.07)
  BOTTOM w0.122: UH1.AR47 210.66,18.98 210.73,19.05 v2(210.73,19.16)
DGPU_HOLD_RST#: length 135.2
  TOP w0.114: v2(191.35,63.24) 191.35,65.57 v1(191.38,65.6) 191.38,68.24 190.73,68.89 190.73,70.61 187.54,73.8 187.54,94.17 184.01,97.7 181.67,97.7 181.09,98.28 181.09,115.94 189.05,123.9 197.86,123.9 v2(199.12,125.16)
  IN1 w0.081: 196.45,40.94 198.13,39.26 198.13,37.9 199.35,36.68 199.35,36.07 201.73,33.69 204.27,33.69 204.94,33.01 206.37,33.01 207.64,31.74 208.03,31.74 208.8,30.98 210.57,30.98 210.77,30.79 v2(211.4,30.79) ; v2(191.35,63.24) 190.89,62.77 190.89,62.51 190.3,61.92 190.17,61.79 190.17,57.2 190.52,56.85 190.52,53.56 v2(189.91,52.95) 189.91,52.66 190.24,52.33 190.24,51.44 189.51,50.71 189.51,47.13 189.84,46.81 189.84,45.36 192.15,43.04 193.27,43.04
  IN1 w0.089: 196.45,40.94 194.35,43.04 193.27,43.04
  BOTTOM w0.089: UH1.BB20 212.89,30.92 211.53,30.92 v2(211.4,30.79)
  BOTTOM w0.114: UG31.9 190.38,53.42 v2(189.91,52.95) ; v2(199.12,125.16) RG13.1 RG3.2 199.74,124.34 200.11,123.97 UG10.1
DGPU_PEX_RST#: length 472.2
  TOP w0.114: v2(189.84,52.14) 189.44,52.54 189.44,55.1 192.63,58.29 193.35,60.05 195.02,61.72 195.69,61.72 196.63,62.66 198.66,62.66 199.07,62.25 199.68,62.25 199.84,62.4 199.84,64.04 198.44,65.44 195.04,65.44 192.35,68.13 192.35,68.81 191.63,69.54 191.63,70.96 188.4,74.18 188.4,94.49 183.62,99.28 183.62,100.26 182.36,101.51 182.36,101.93 182.16,102.12 182.16,115.22 184.92,117.97 185.15,117.97 190.24,123.07 196.96,123.07 v2(197.48,122.55) ; RG25.1 223.68,163.33 UX1.2 222.32,163.33 221.99,163 v2(221.99,162.96) ; RG568.1 307.34,60.53 v2(308.61,61.8) ; v2(207.07,154.26) 207.51,154.7 v1(208.38,154.7) 208.61,154.93 209.71,154.93 210,155.22 212.25,155.22 212.45,155.03 214.06,155.03 RG581.2 CG489.1 215.32,157.18 UG22.1 215.32,158.72 214.75,159.29 214.75,160.16 v2(214.73,160.19)
  IN1 w0.081: 216.75,120.45 v2(217.64,120.45) ; v2(197.48,122.55) 198.27,123.33 201.93,123.33 202.19,123.07 204.65,123.07 206,121.72 v2(206.19,121.72) 207.02,120.89 207.02,120.01 206.83,119.82 206.83,119.24 206.45,118.86 v2(206.13,118.86) 206.13,118.8 206.6,118.33 206.6,118 206.38,117.78 205.79,117.78 205.48,117.48 v2(205.48,117.45) 205.48,117.2 205.63,117.06 209.84,117.06 210.41,116.49 210.95,116.49 211.92,117.46 211.92,117.76 213.31,119.14 215.02,119.14 ; v2(328.61,47.44) 328.6,47.45 328.6,47.67 327.14,49.12 326.92,49.12 324.49,51.55 321.57,51.55 320.43,52.7 320.43,57.27 315.62,62.08 314.94,62.08 314.66,62.36 309.16,62.36 v2(308.61,61.8)
  IN1 w0.089: 215.02,119.14 215.3,119.14 216.61,120.45 216.75,120.45
  IN3 w0.127: v2(217.7,163.9) 217.7,164.67 219.08,166.06 220.26,166.06 222.3,164.02 222.3,163.37 221.99,163.07 v2(221.99,162.96) 222.36,162.59 222.36,161.74 222.09,161.47 221.4,161.47 220.76,160.84 217.85,160.84 217.42,161.27 215.25,161.27 214.73,160.75 v2(214.73,160.19)
  IN4 w0.089: 219.18,38.6 218.91,38.6 218.77,38.46 214.84,38.46 213.35,39.95 210.68,39.95 209.87,40.76 204.53,40.76 204.29,40.99 203.08,40.99 202.83,41.25 200.76,41.25 200.41,41.59 198.91,41.59 196.6,43.9 196.6,44.45 195.37,45.69 195.08,45.69
  IN4 w0.127: v2(328.61,47.44) 329.45,46.6 329.45,43.77 330.74,42.47 331.63,42.47 333.13,40.97 333.13,36.4 330.37,33.63 328.86,33.63 328.29,34.2 326.67,34.2 324.36,31.89 320.05,31.89 320.02,31.87 311.16,31.87 309.99,30.7 308.57,30.7 307.91,30.04 304.77,30.04 302.92,28.18 278.51,28.18 278.1,28.59 269.62,28.59 265.48,24.45 264.77,24.45 263.5,23.18 261.91,23.18 261.75,23.35 257.76,23.35 256.21,24.9 256.21,24.93 255.49,25.64 247.34,25.64 246.26,26.72 239.98,26.72 238.42,28.28 238.42,34.45 235.67,37.2 235.38,37.2 235.3,37.28 233.54,37.28 231.36,39.45 230.13,39.45 229.88,39.2 227.84,39.2 227.26,38.61 225.09,38.61 224.88,38.81 224.18,38.81 223.98,38.61 222.56,38.61 221.69,39.49 221.12,39.49 220.23,38.6 219.18,38.6 ; 195.08,45.69 195.01,45.76 191.4,45.76 189.84,47.32 v2(189.84,52.14)
  IN6 w0.081: v2(207.07,154.26) 207.47,153.86 207.47,152.33 204.91,149.77 202.32,149.77 v2(201.83,149.28) 201.83,145.24 204.93,142.13 204.93,136.29 208.29,132.93 214.33,132.93 223.7,123.56 224.06,123.56 v2(225.18,122.44)
  BOTTOM w0.089: RG4.1 234.2,122.09 233.85,122.44 v2(225.18,122.44) 225,122.26 223.44,122.26 222.12,120.94 219.09,120.94 218.6,120.45 v2(217.64,120.45)
  BOTTOM w0.114: QG7.5 QG7.2 205.49,122.04 205.81,121.72 v2(206.19,121.72) ; v2(206.13,118.86) 206,118.86 205.56,119.31 QG501.2 QG501.5 ; QG6.2 QG6.5 203.34,151.06 201.83,149.55 v2(201.83,149.28) ; UG31.10 189.98,53.76 189.42,53.19 189.42,52.56 v2(189.84,52.14) ; UX2.2 211.87,160.42 212.3,159.99 213.21,159.99 213.21,159.99 214.26,159.99 214.45,160.19 v2(214.73,160.19) 214.86,160.32 216.07,160.32 216.51,160.76 QV96.5 ; v2(217.7,163.9) 217.42,164.18 216.68,164.18 216.51,164 QV96.2 ; RG7.2 199.32,118.29 200.11,117.5 205.01,117.5 205.07,117.45 v2(205.48,117.45)
DGPU_PEX_RST#_R: length 6.2
  BOTTOM w0.089: UG9.BK26 236.47,117 236.12,117.35 236.12,117.79 235.91,118 235.91,120.89 v3(235.79,121.01) 234.68,121.01 RG4.2
DGPU_PRSNT#: length 18.4
  TOP w0.089: v2(218.45,33.71) 218.45,33.33 218.85,32.92 v1(219.06,32.92) 219.18,32.92
  TOP w0.102: 219.18,32.92 RH135.2
  IN6 w0.089: 219.18,33.82 218.56,33.82 v2(218.45,33.71) ; v2(218.51,23.74) 218.58,23.8 218.58,24.82 219.18,25.42
  IN6 w0.102: 219.18,33.82 219.32,33.82 220.61,32.53 220.61,28.31 219.97,27.68 219.97,26.41 219.79,26.23 219.79,26.03 219.55,25.79 219.55,25.74 219.31,25.5 219.26,25.5 219.18,25.42
  BOTTOM w0.089: UH1.BD38 215.1,23.4 216.08,23.4 216.24,23.57 216.72,23.57 216.89,23.74 v2(218.51,23.74)
DGPU_PWR_EN: length 358
  TOP w0.102: v2(189.24,37.39) 187.64,38.99 187.64,39.42 189.24,41.02 189.24,45.54 189.91,46.21 189.91,50.45 188.86,51.49 v1(188.86,53.01) 188.36,53.52 v2(188.23,53.52) ; v2(334.54,43.57) 333.78,44.33 UE6.9
  TOP w0.254: v2(210.24,32.07) 210.28,32.03 RH537.1 ; RG551.1 277.52,145.44 278.22,146.14 279.54,146.14 280.08,146.69 v2(280.08,146.78)
  IN3 w0.102: v2(280.08,146.78) 280.08,146.42 283.52,142.98 283.73,142.98 283.92,142.98 287.2,139.7 287.2,99.96 287.29,99.58 287.3,99.56 287.32,99.46 287.33,99.46 287.54,98.64 287.57,98.52 287.6,98.41 287.61,98.4 288.12,96.69 288.6,95.19 288.89,94.24 289.52,92.86 291.8,88.16 291.8,82.11 v2(292.2,81.72)
  IN4 w0.089: v2(210.24,32.07) 209.72,31.55 208.99,31.55 207.85,32.69 207.32,32.69 206.55,33.46 205.81,33.46 205.49,33.78 198.44,33.78 196.92,35.3 194.83,35.3 193.08,37.04 192.1,37.04
  IN4 w0.102: v2(286.08,27.55) 286.2,27.68 292.05,27.68 293.89,25.84 305.38,25.84 309.41,29.86 318.93,29.86 320.22,31.14 320.32,31.25 324.63,31.25 326.94,33.56 328.02,33.56 328.59,32.99 331.5,32.99 332.03,33.52 334.54,36.03 v2(334.54,43.57) ; 192.1,37.04 191.49,37.04 190.89,37.65 189.64,37.65 189.39,37.39 v2(189.24,37.39)
  IN6 w0.089: v2(210.24,32.07) 210.61,32.44 211.65,32.44 212.13,32.91 212.13,34.06 213.36,35.29 213.67,35.29 214.07,35.69 214.32,35.69 216.08,37.46 216.71,37.46 217.53,38.28 218.8,38.28 218.89,38.19 218.89,36.93 219.18,36.64
  IN6 w0.102: v2(286.08,27.55) 285.5,28.12 284.78,28.12 283.92,27.26 278.03,27.26 277.23,28.06 264.61,28.06 263.91,28.76 260.17,28.76 259.15,29.77 249.26,29.77 246.58,27.09 246.58,26.53 244.78,24.73 242.47,24.73 239.56,21.83 239.54,21.83 239.48,21.77 237.05,21.77 235.59,23.23 235.59,23.72 235.33,23.97 233.98,23.97 233.5,23.49 230.51,23.49 228.48,25.52 228.48,34.15 226.51,36.12 224.48,36.12 223.62,35.26 222.02,35.26 222.01,35.27 221.89,35.27 221.48,35.67 220.15,35.67 219.18,36.64
  BOTTOM w0.102: v2(292.2,81.72) 292.2,76.33 299.62,68.91 299.62,64.47 302,62.09 306.84,62.09 307.12,62.37 314.06,62.37 314.4,62.03 318.02,62.03 318.52,62.54 320.43,62.54 321.2,61.77 321.2,53.68 322.55,52.33 335.66,52.33 337.13,50.85 337.13,46.15 v2(334.54,43.57) ; v2(188.23,53.52) 187.34,53.52 186.66,54.19 RG570.2 RG573.1
  BOTTOM w0.254: v2(210.24,32.07) 210.05,32.07 UH1.AN18
DGPU_PWROK: length 146.8
  TOP w0.089: 219.18,34.28 218.7,34.28 218.58,34.41 v2(218.07,34.41)
  TOP w0.114: RH516.2 220.02,34.81 v1(219.49,34.28) 219.18,34.28 ; UE6.19 328.59,45.83 v2(328.4,46.02)
  IN1 w0.081: 219.18,34.12 219.78,33.52 219.78,29.66 219.64,29.52 219.06,29.52 218.58,29.03 218.58,27.8 218.53,27.75 ; 218.99,25.14 219.73,25.14 221.25,23.61 221.44,23.61 222.67,22.39 223.41,22.39 223.71,22.09 224.56,22.09 225.37,21.27 226.1,21.27 227,20.37 229.18,20.37 229.35,20.2 231.74,20.2 231.76,20.21 234.35,20.21 235.72,21.58 236.17,21.58 236.19,21.6 237.06,21.6 237.42,21.95 237.56,21.95 238.91,23.3 238.91,24.2 244.85,30.14 246.56,30.14 248.33,31.92 251.64,31.92 252.29,32.56 264.43,32.56 264.93,32.07 272.53,32.07 272.87,31.73 274.5,31.73 275.22,32.44 288.84,32.44 291.88,35.47 293.61,35.47 294.07,35.93 320.24,35.93 322.25,37.95 322.44,37.95 323.11,38.61 323.11,39.37 323.86,40.12 323.86,45.08 324.58,45.8 324.86,45.8 325.89,46.83 327.54,46.83 328.19,46.17 328.25,46.17 v2(328.4,46.02)
  IN1 w0.089: 219.18,34.12 218.89,34.41 v2(218.07,34.41) ; 218.99,25.14 218.38,25.14 218.35,25.16 218.23,25.16 217.95,25.45 217.95,26.03 218.4,26.49 218.4,26.81 218.4,27.51 218.53,27.63 218.53,27.75
  BOTTOM w0.089: v2(218.07,34.41) 217.57,33.91 216.48,33.91 215.73,34.66 215.58,34.66 UH1.BE14
DGPU_ROM_CS#: length 33.8
  TOP w0.089: 215.02,117.5 RG579.1
  TOP w0.114: 215.02,117.5 213.94,116.42 213.34,116.42 212.92,116.01 212.92,115.43 v2(212.84,115.34) 212.37,115.81 v1(210.03,115.81) 209.23,115.81 208.28,114.86 208.28,114.6 207.97,114.29 206.55,114.29 205.18,115.66 204.47,115.66 203.05,117.08 199.92,117.08 198.92,116.08 198.92,115.1 197.86,114.04 196.52,114.04 196.06,113.58 196.06,112.73 196.21,112.58 UG16.11
  BOTTOM w0.089: v2(212.84,115.34) 213.11,115.07 213.11,113.47 212.92,113.27 212.92,112.13 211.77,110.98 RG74.2 210.82,109.91
  BOTTOM w0.114: UG13.1 210.82,109.91
DGPU_ROM_SCLK: length 1.6
  BOTTOM w0.114: UG13.6 RG75.1
DGPU_ROM_SI: length 4
  BOTTOM w0.114: v1(199.22,107.03) 199.95,107.03 200.24,106.73 200.68,106.73 RG77.1 UG13.5
DGPU_ROM_SO: length 26.2
  TOP w0.114: UG16.8 197.53,111.08 v2(198.03,110.58) ; RG580.1 199.09,108.79 v2(199.51,108.37)
  BOTTOM w0.114: v2(198.03,110.58) 198.79,109.82 198.79,109.1 v2(199.51,108.37) 199.51,108.13 198.88,107.5 198.88,106.81 200.12,105.57 203.94,105.57 204.72,106.36 206.52,106.36 207.28,105.6 212.55,105.6 213.94,106.99 v1(213.94,107.22) 213.94,107.79 213.09,108.64 RG76.1
DGPU_ROM_SO_R: length 3.9
  BOTTOM w0.089: v1(213.64,108.73) 213.25,109.11 212.29,109.11 211.82,108.64 RG76.2 210.82,108.64
  BOTTOM w0.114: UG13.2 210.82,108.64
DH_1.2V: length 3.8
  TOP w0.102: v2(89.93,44.74) v1(89.19,44.74)
  IN4 w1.016: 88.27,42.09 88.27,44.19 88.97,44.89
  vias: v2(89.29,41) v2(89.29,40.38) v2(90.31,45.19)
DH_CHG: length 13.2
  TOP w0.102: v2(74.81,21.96) v1(75.68,21.96)
  IN1 w1.016: 73.01,21.79 71.53,21.79 70.81,21.07 64.22,21.07 62.12,23.17 62.12,23.49
  vias: v2(61.54,24.37) v2(62.18,24.37) v2(74.18,21.96)
DIFFOUT_2PH: length 9.2
  TOP w0.203: PR539.2 117.97,135.72 119.34,137.09 119.34,137.86 119.6,138.12 119.6,141.38 119.87,141.65 120.23,141.65 120.34,141.76 120.54,141.76 120.68,141.9 PU500.35
  TOP w0.254: PR537.1 117.94,135.44 PR539.2
DIFFOUT_4PH: length 2.6
  TOP w0.203: PU500.4 127.73,141.5 127.99,141.24 128.37,141.24 128.5,141.38 PR536.2 PC516.2
DIMM_CHA_SA0: length 4
  TOP w0.102: v1(177.78,51.88) 177.44,51.88 177.25,52.07 v2(177.25,52.22)
  TOP w0.107: v2(177.25,52.22) 177.36,52.33 RD28.1 RD1.2
  BOTTOM w0.127: JDIMM1.256 177.44,52.41 v2(177.25,52.22)
DIMM_CHA_SA1: length 5.1
  TOP w0.102: v1(180.08,56.11) 179.36,56.11 179.13,55.88 RD2.2
  TOP w0.107: RD2.2 178.6,56.05 RD29.1 v2(177.87,55.3)
  BOTTOM w0.127: JDIMM1.260 178.44,54.73 v2(177.87,55.3)
DIMM_CHA_SA2: length 8.1
  TOP w0.102: v1(157.82,48.57) RD3.2
  TOP w0.107: RD3.2 RD30.1 155.15,48.57 154.69,49.03 v2(154.69,50.95)
  BOTTOM w0.127: JDIMM1.166 154.94,52.51 155.1,52.36 155.1,51.35 v2(154.69,50.95)
DIMM_CHB_SA0: length 3.9
  TOP w0.107: RD4.2 177.17,39.98 v2(177.17,39.5) 177.17,39.42 176.35,38.6 RD38.1
  BOTTOM w0.107: v2(177.17,39.5) 177.45,39.78 177.45,40.79 JDIMM2.256
DIMM_CHB_SA1: length 6.4
  TOP w0.102: RD5.2 177.55,40.52 178.01,40.97 178.01,42.51 v1(178.24,42.74)
  TOP w0.107: RD39.1 177.24,38.6 177.81,39.17 v2(177.81,39.49) 177.81,39.87 177.55,40.12 RD5.2
  BOTTOM w0.107: 178.44,40.06 177.88,39.49 v2(177.81,39.49)
  BOTTOM w0.127: JDIMM2.260 178.44,40.06
DIMM_CHB_SA2: length 5.6
  TOP w0.102: v1(154.83,42.76) 155.49,42.76 155.53,42.73 v2(155.54,42.73)
  TOP w0.107: v2(155.54,42.73) 156.23,42.05 RD40.1 RD6.2
  BOTTOM w0.107: v2(155.54,42.73) 154.94,42.13 JDIMM2.166
DISP_CEC: length 3.2
  BOTTOM w0.107: JDP.6 233.57,171.41 233.45,171.28 v1(233.45,170.49) 233.45,169.62 RV18.2
DISP_CLK_AUXP_CONN: length 17.8
  IN1 w0.089: v2(232.61,163.62) 232.45,163.78 232.21,163.78 231.94,164.05 231.94,165.1 232.7,165.85 232.7,167.27 235.93,170.5 236.53,170.5 v2(236.62,170.6)
  BOTTOM w0.089: v2(232.61,163.62) 231.92,162.92 UV3.4 ; RV15.2 236.11,169.07 236.32,169.28 236.32,169.4 236.04,169.68 236.04,170.13 236.24,170.32 236.35,170.32 v2(236.62,170.6) 236.81,170.41 236.94,170.41 237.04,170.51 237.04,171 236.88,171.16 236.88,171.24 236.57,171.54 JDP.16
DISP_DAT_AUXN_CONN: length 17.7
  IN1 w0.089: v2(232.62,164.54) 232.62,164.14 232.5,164.02 232.25,164.02 232.14,164.13 232.14,165.01 232.89,165.77 232.89,167.19 236.01,170.3 236.33,170.3 v2(236.62,170.01)
  BOTTOM w0.089: UV3.7 230.81,164.87 230.92,164.99 232.29,164.99 232.62,164.66 v2(232.62,164.54) ; RV16.2 236.91,169.07 236.22,169.76 236.22,170.06 236.31,170.15 236.49,170.15 v2(236.62,170.01) 236.84,170.23 237.01,170.23 237.22,170.44 237.22,171.07 237.05,171.24 237.05,171.48 237.18,171.6 JDP.18
DISPOFF#: length 30.4
  TOP w0.102: v2(168.82,160.32) 168.89,160.39 168.89,161.04 DV1.1 168.74,161.47 168.18,162.03 RV1.1 ; JEDP.35 v2(168.62,183) 168.63,183 168.63,183.72 v1(167.92,184.43)
  IN4 w0.102: v2(168.82,160.32) 168.59,160.54 168.59,163.68 169.36,164.46 169.36,170.23 167.03,172.57 167.03,179.63 166.49,180.17 166.49,181.41 167.14,182.06 167.68,182.06 v2(168.62,183)
DL_1.2V: length 7.5
  IN4 w1.016: 95.51,37.52 91.39,41.65 91.39,42.46
  BOTTOM w0.102: v2(91.35,43.54) 91.14,43.54 v1(90.67,43.07)
  vias: v2(91.34,44.15) v2(95.58,36.31) v2(95.58,35.68)
DL_CHG: length 1.9
  IN4 w1.016: 61.81,22.96 63.36,22.96 63.59,22.74
  vias: v2(60.42,22.75) v2(60.85,22.34) v2(64.46,22.85) v2(65.1,22.85)
DMI_CRX_PTX_N0: length 90.9
  IN1 w0.089: v2(191.49,26.54) 191.62,26.41 192.16,26.41 192.35,26.6 192.35,30.7 190.92,32.13 189.63,32.13 189.14,32.62 188.34,32.62 186.98,33.98 186.98,35.04 186.11,35.91 185.6,35.91 183.78,37.73 183.78,40.82 182.83,41.78 182.83,51.43 182.25,52 182.25,60.66 181.77,61.14 181.77,62.87 181.08,63.56 180.85,63.56 180.56,63.85 180.56,65.59 178.98,67.18 178.98,80.38 178.6,80.77 178.6,88.36 177.26,89.7 177.26,93.15 176.15,94.25 175.18,94.25 173.26,96.16 173.26,96.36 172.73,96.89 172.73,99.18 172.49,99.42 171.19,99.42 170.95,99.66 170.95,99.86 v2(170.71,100.1)
  BOTTOM w0.076: v2(170.71,100.1) UC1.E8
  BOTTOM w0.107: UH1.C33 194.73,25.3 194.25,25.78 194.25,25.78 194.11,25.91 194.11,26.02 193.64,26.49 192.18,26.49 192.1,26.41 191.62,26.41 v2(191.49,26.54)
DMI_CRX_PTX_N1: length 89.8
  IN1 w0.089: v2(191.22,27.93) 191.28,27.87 191.69,27.87 191.78,27.96 191.78,30.37 190.66,31.49 189.37,31.49 188.88,31.98 188.61,31.98 188.08,31.98 186.34,33.72 186.34,34.77 185.85,35.27 185.34,35.27 183.14,37.46 183.14,40 181.61,41.53 181.61,49.89 180.88,50.61 180.88,54.4 181.61,55.13 181.61,60.35 179.89,62.07 179.89,65.37 179.78,65.48 178.34,66.91 178.34,72.69 177.92,73.11 177.92,88.1 176.62,89.4 176.62,93.1 175.87,93.85 175,93.85 173.36,95.49 172.6,95.49 172.22,95.88 172.22,98.25 171.58,98.89 170.61,98.89 170.18,99.31 v2(170.06,99.31)
  BOTTOM w0.076: v2(170.06,99.31) 169.71,98.97 UC1.F6
  BOTTOM w0.107: v2(191.22,27.93) 191.41,27.74 191.61,27.74 192.36,26.99 193.79,26.99 194.2,26.58 194.2,26.58 194.33,26.44 194.49,26.44 194.7,26.23 194.7,26.13 194.82,26.01 UH1.C32
DMI_CRX_PTX_N2: length 87.9
  IN1 w0.089: v2(170.71,98.52) 170.91,98.32 170.91,98.09 171.28,97.73 171.28,97.41 171.14,97.27 171.14,96.51 171.48,96.17 171.48,95.18 171.67,95 173.34,95 174.83,93.51 175.45,93.51 175.99,92.98 175.99,89.14 177.29,87.84 177.29,72.54 177.71,72.12 177.71,66.65 179.25,65.11 179.25,61.81 180.98,60.08 180.98,55.39 180.25,54.66 180.25,50.35 180.98,49.62 180.98,40.13 182.51,38.6 182.51,37.73 182.51,37.2 184.82,34.89 184.82,34.19 187.66,31.35 188.62,31.35 189.11,30.86 189.63,30.86 190.4,30.86 191.14,30.11 191.14,28.78 191.05,28.69 190.68,28.69 v2(190.64,28.73)
  BOTTOM w0.076: UC1.E5 170.71,98.45 v2(170.71,98.52)
  BOTTOM w0.107: v2(190.64,28.73) 190.68,28.69 191.43,28.69 191.58,28.54 191.85,28.54 193.01,27.39 193.95,27.39 194.03,27.31 194.09,27.31 194.43,27.02 194.47,27.03 194.53,26.98 194.66,26.85 194.67,26.85 UH1.C31
DMI_CRX_PTX_N3: length 89.6
  IN1 w0.089: v2(190.64,29.91) 190.64,29.89 190.43,29.68 189.33,29.68 188.13,30.88 187.46,30.88 180.01,38.33 180.01,43.93 180.51,44.43 180.51,49.43 179.78,50.16 179.78,54.85 180.51,55.58 180.51,59.89 178.78,61.61 178.78,64.91 177.24,66.46 177.24,71.93 176.82,72.35 176.82,87.64 175.52,88.94 175.52,92.78 174.96,93.33 174.82,93.33 174.75,93.33 173.93,94.15 173.93,94.15 173.27,94.82 171.35,94.82 170.61,95.56 170.61,97.24 170.14,97.71 170.14,98.5 169.5,99.13 169.5,100.28 169.08,100.7 168.89,100.7 v2(168.7,100.89)
  BOTTOM w0.076: v2(168.7,100.89) 168.66,100.9 168.3,100.64 UC1.J9
  BOTTOM w0.107: v2(190.64,29.91) 191.36,29.91 192.82,28.44 193.3,28.44 193.53,28.21 193.92,28.21 194.18,27.95 194.31,27.95 194.76,27.51 UH1.C29
DMI_CRX_PTX_P0: length 90.9
  IN1 w0.089: v2(191.45,25.95) 191.45,25.95 191.45,25.97 191.47,25.97 191.64,26.14 191.66,26.14 191.76,26.24 192.23,26.24 192.52,26.53 192.52,30.77 190.99,32.29 189.7,32.29 189.21,32.78 188.41,32.78 187.14,34.05 187.14,35.11 186.18,36.07 185.67,36.07 183.94,37.8 183.94,40.89 182.99,41.84 182.99,51.49 182.41,52.07 182.41,60.73 181.94,61.2 181.94,62.93 181.14,63.73 180.92,63.73 180.73,63.92 180.73,65.66 179.14,67.25 179.14,80.45 178.76,80.84 178.76,88.43 177.42,89.77 177.42,93.21 176.22,94.42 175.25,94.42 173.43,96.23 173.43,96.42 172.89,96.96 172.89,99.25 172.56,99.58 171.26,99.58 171.11,99.73 171.11,99.85 v2(171.36,100.1)
  BOTTOM w0.076: UC1.D8 171.36,100.03 v2(171.36,100.1)
  BOTTOM w0.107: UH1.B33 194.25,25.49 193.91,25.83 193.91,25.93 193.56,26.28 192.26,26.28 192.18,26.2 191.74,26.2 191.66,26.13 191.62,26.13 v2(191.45,25.95)
DMI_CRX_PTX_P1: length 89.7
  IN1 w0.089: v2(170.71,99.31) 170.71,99.14 170.8,99.05 171.65,99.05 172.39,98.31 172.39,95.94 172.67,95.66 173.43,95.66 175.07,94.02 175.94,94.02 176.79,93.17 176.79,89.47 178.09,88.17 178.09,73.18 178.51,72.76 178.51,66.98 179.94,65.55 180.05,65.44 180.05,62.14 181.78,60.42 181.78,55.06 181.05,54.33 181.05,50.68 181.78,49.95 181.78,41.6 183.31,40.06 183.31,37.53 185.41,35.44 185.91,35.44 186.51,34.84 186.51,33.79 188.15,32.15 188.54,32.15 188.95,32.15 189.44,31.66 190.73,31.66 191.94,30.44 191.94,27.89 191.76,27.7 191.57,27.7 v2(191.22,27.35)
  BOTTOM w0.076: v2(170.71,99.31) 170.81,99.21 170.81,99.09 170.58,98.86 170.44,98.86 UC1.E6
  BOTTOM w0.107: UH1.B32 194.4,26.01 194.5,26.1 194.5,26.14 194.4,26.24 194.25,26.24 193.99,26.49 193.99,26.5 193.7,26.79 192.27,26.79 191.52,27.54 191.41,27.54 v2(191.22,27.35)
DMI_CRX_PTX_P2: length 87.9
  IN1 w0.089: v2(171.36,98.52) 171.19,98.52 171.08,98.42 171.08,98.16 171.44,97.79 171.44,97.34 171.31,97.2 171.31,96.58 171.65,96.24 171.65,95.25 171.74,95.16 173.41,95.16 174.89,93.68 175.52,93.68 176.15,93.04 176.15,89.21 177.45,87.9 177.45,72.61 177.87,72.19 177.87,66.72 179.42,65.18 179.42,61.87 181.14,60.15 181.14,55.32 180.41,54.59 180.41,50.42 181.14,49.69 181.14,40.2 182.67,38.67 182.67,37.66 182.67,37.27 184.98,34.96 184.98,34.26 187.73,31.51 188.69,31.51 189.18,31.02 189.57,31.02 190.46,31.02 191.31,30.18 191.31,28.71 191.12,28.53 191.02,28.53 v2(190.64,28.15)
  BOTTOM w0.076: UC1.D5 171.36,98.45 v2(171.36,98.52)
  BOTTOM w0.107: UH1.B31 194.46,26.67 194.46,26.73 194.36,26.81 194.36,26.81 194.3,26.87 194.02,27.11 193.95,27.11 193.87,27.19 192.92,27.19 191.77,28.34 191.5,28.34 191.35,28.49 190.98,28.49 v2(190.64,28.15)
DMI_CRX_PTX_P3: length 89.6
  IN1 w0.089: v2(168.76,100.1) 168.76,100.45 168.85,100.54 169.01,100.54 169.34,100.21 169.34,99.06 169.97,98.43 169.97,97.64 170.44,97.17 170.44,95.49 171.28,94.65 173.2,94.65 173.77,94.08 173.77,94.08 174.68,93.17 174.9,93.17 175.35,92.71 175.35,88.87 176.65,87.57 176.65,72.28 177.07,71.86 177.07,66.39 178.62,64.84 178.62,61.54 180.34,59.82 180.34,55.65 179.61,54.92 179.61,50.09 180.34,49.36 180.34,44.5 179.84,44 179.84,38.26 187.39,30.71 188.07,30.71 189.26,29.52 190.43,29.52 190.64,29.31 v2(190.64,29.32)
  BOTTOM w0.076: UC1.J8 168.72,100.11 v2(168.76,100.1)
  BOTTOM w0.107: UH1.B29 194.32,27.59 194.32,27.66 194.23,27.75 194.09,27.75 193.84,28 193.45,28 193.21,28.24 192.74,28.24 191.28,29.7 191.02,29.7 190.81,29.5 190.81,29.5 190.81,29.47 190.64,29.31 v2(190.64,29.32)
DMI_CTX_PRX_N0: length 99.5
  IN1 w0.089: v2(176.41,98.67) 176.63,98.45 176.63,98.22 176.81,98.03 177.88,98.03 179.28,96.64 183.34,96.64 186.06,93.92 186.06,90.28 183.84,88.07 183.84,77.4 182.13,75.69 182.13,72.78 182.55,72.36 182.55,70.65 182.13,70.24 182.13,68.46 182.7,67.9 183.01,67.9 183.48,67.43 183.48,66.81 183.48,64.83 183.93,64.38 184.41,63.89 184.41,62.09 184.79,61.71 184.79,56.32 185.37,55.74 185.37,42.83 186.53,41.67 186.53,40.52 186.89,40.16 186.89,38.76 190.3,35.35 191.26,35.35 191.92,36.01 192.29,36.01 193.1,36.01 193.94,35.17 193.94,33.46 198.55,28.85 198.55,25.39 198.4,25.24 198.2,25.24 198.09,25.35 198.05,25.35 198,25.41 v2(198.02,25.57)
  BOTTOM w0.076: UC1.A8 172.78,99.7 172.65,99.83 172.65,99.93 172.73,100.01 173.28,100.01 173.45,100.19 174.07,100.19 174.34,99.92 174.8,99.92 174.83,99.9 174.83,99.9
  BOTTOM w0.107: 174.83,99.9 175.18,99.9 175.78,99.3 176.64,99.3 176.79,99.16 176.79,98.99 176.47,98.67 v2(176.41,98.67) ; v2(198.02,25.57) 198.38,25.21 198.38,24.78 UH1.K34
DMI_CTX_PRX_N1: length 92.6
  IN1 w0.089: v2(197.18,25.14) 197.01,24.97 196.91,24.97 196.76,25.12 196.73,25.12 196.14,25.71 195.12,25.71 194.51,26.32 194.51,26.86 193.58,27.79 193.58,28.09 193.56,28.11 193.56,30.58 192.26,31.88 192.26,32 190.84,33.42 188.68,33.42 187.79,34.3 187.79,35.38 184.58,38.59 184.58,41.16 183.63,42.11 183.63,51.76 183.05,52.34 183.05,60.99 182.57,61.47 182.57,63.2 181.74,64.03 181.74,65.72 179.78,67.68 179.78,70.91 180.17,71.3 180.17,73.49 179.78,73.88 179.78,81.27 179.4,81.65 179.4,89.12 178.06,90.46 178.06,93.41 176.35,95.11 175.46,95.11 174.13,96.45 174.13,99.05 174.32,99.24 174.78,99.24 174.98,99.05 174.98,98.97 174.73,98.73 v2(174.72,98.73)
  BOTTOM w0.076: 174.16,99.25 174.11,99.25 174.09,99.22 172.86,99.22 172.84,99.2 172.21,99.2 172.01,99 172.01,98.9 172.14,98.77 172.25,98.77 172.33,98.85 UC1.B6
  BOTTOM w0.107: UH1.G33 196.93,25.36 197.16,25.14 v2(197.18,25.14) ; 174.16,99.25 174.57,99.25 174.57,99.25 174.73,99.25 174.91,99.07 174.91,98.92 v2(174.72,98.73)
DMI_CTX_PRX_N2: length 97.2
  IN1 w0.089: v2(176.38,96.76) 176.57,96.81 176.63,96.92 176.54,97.27 176.54,97.37 176.87,97.69 177.56,97.69 179.08,96.17 183.14,96.17 185.59,93.72 185.59,90.48 182.55,87.44 182.55,76.82 181.05,75.32 181.05,74.44 181.44,74.06 181.44,72.81 182.08,72.17 182.08,71.22 181.05,70.2 181.05,68.21 183.01,66.25 183.01,64.56 183.56,64 183.84,63.72 183.84,61.99 184.32,61.52 184.32,52.97 184.9,52.39 184.9,42.63 186.06,41.47 186.06,40.33 186.42,39.97 186.42,38.56 190.1,34.88 191.47,34.88 192.13,35.54 192.56,35.54 193.02,35.07 193.02,33.71 197.02,29.71 197.02,28.18 197.99,27.21 197.99,26.91 197.9,26.75 197.9,26.75 v2(198,26.41)
  BOTTOM w0.076: UC1.A5 173.24,98.41 173.43,98.41 173.46,98.39 173.48,98.39
  BOTTOM w0.107: UH1.K32 198.29,26.04 198.06,26.04 197.95,26.15 197.95,26.36 v2(198,26.41) ; 173.48,98.39 174.03,98.39 174.34,98.07 175.9,98.07 176.8,97.18 176.8,96.86 176.6,96.66 176.48,96.66 v2(176.38,96.76)
DMI_CTX_PRX_N3: length 94.1
  IN1 w0.089: v2(175.22,96.76) 175.01,96.55 175.01,96.38 175.8,95.6 179.27,95.6 179.34,95.53 182.88,95.53 184.95,93.46 184.95,90.74 181.8,87.58 181.18,87.58 180.41,86.82 180.41,74.18 180.8,73.79 180.8,70.9 180.41,70.52 180.41,67.94 182.37,65.98 182.37,64.29 183.21,63.46 183.21,61.73 183.68,61.26 183.68,52.71 184.26,52.13 184.26,42.37 185.42,41.21 185.42,40.07 185.78,39.7 185.78,38.3 187.02,37.07 187.02,37.05 188.23,35.84 188.25,35.84 190.03,34.05 191.13,34.05 192.34,32.84 192.84,32.84 194.76,30.92 194.76,28.16 195.91,27.02 196.16,27.02 196.36,26.86 196.44,26.57 196.71,26.41 v2(196.91,26.46)
  BOTTOM w0.076: 173.55,97.82 173.54,97.83 173.52,97.83 173.48,97.86 173.33,97.86 173.31,97.85 172.47,97.85 172.34,97.72 171.98,97.72 171.9,97.64 171.9,97.53 UC1.B4
  BOTTOM w0.107: v2(175.22,96.76) 175.16,96.76 174.91,97.01 174.91,97.21 174.71,97.42 173.95,97.42 173.55,97.82 ; v2(196.91,26.46) UH1.G30
DMI_CTX_PRX_P0: length 99.5
  IN1 w0.089: v2(197.94,24.98) 198.06,25.07 198.46,25.07 198.71,25.32 198.71,28.91 194.1,33.52 194.1,35.24 193.17,36.17 192.22,36.17 192.22,36.17 191.85,36.17 191.19,35.51 190.37,35.51 187.05,38.82 187.05,40.23 186.69,40.59 186.69,41.74 185.53,42.9 185.53,55.81 184.95,56.39 184.95,61.78 184.58,62.16 184.58,63.96 183.99,64.54 183.64,64.89 183.64,66.88 183.64,67.5 183.08,68.06 182.76,68.06 182.3,68.53 182.3,70.17 182.71,70.59 182.71,72.43 182.3,72.85 182.3,75.62 184.01,77.33 184.01,88 186.22,90.21 186.22,93.99 183.41,96.8 179.35,96.8 177.95,98.2 176.88,98.2 176.79,98.29 176.79,98.47 v2(176.99,98.67)
  BOTTOM w0.076: UC1.B8 172.4,99.7 172.47,99.78 172.47,100.03 172.65,100.21 173.2,100.21 173.37,100.38 174.15,100.38 174.42,100.12 174.81,100.12 174.82,100.1
  BOTTOM w0.107: UH1.J35 197.62,24.66 v2(197.94,24.98) ; 174.82,100.1 175.27,100.1 175.86,99.51 176.72,99.51 176.99,99.24 v2(176.99,98.67)
DMI_CTX_PRX_P1: length 92.7
  IN1 w0.089: v2(175.34,99.05) 175.21,99.05 175.21,99.05 174.85,99.41 174.25,99.41 173.96,99.12 173.96,96.38 175.39,94.95 176.28,94.95 177.89,93.34 177.89,90.4 179.23,89.06 179.23,81.58 179.61,81.2 179.61,73.81 180,73.42 180,71.37 179.61,70.98 179.61,67.61 181.57,65.65 181.57,63.96 182.41,63.13 182.41,61.4 182.88,60.92 182.88,52.27 183.46,51.69 183.46,42.04 184.41,41.09 184.41,38.52 187.63,35.31 187.63,34.23 188.61,33.25 190.77,33.25 192.1,31.93 192.1,31.81 193.39,30.51 193.39,28.04 193.41,28.02 193.41,27.72 194.34,26.79 194.34,26.25 195.06,25.54 196.07,25.54 196.6,25.01 v2(196.6,24.76)
  BOTTOM w0.076: UC1.C6 172.14,99.37 172.76,99.37 172.79,99.4 174.02,99.4 174.04,99.42 174.07,99.42 174.08,99.43 174.14,99.43 174.15,99.45 174.16,99.45
  BOTTOM w0.107: 174.16,99.45 174.49,99.45 174.49,99.45 174.81,99.45 175.14,99.12 175.14,99.11 175.21,99.05 175.21,99.05 v2(175.34,99.05) ; UH1.F34 196.27,25.09 v2(196.6,24.76)
DMI_CTX_PRX_P2: length 97.2
  IN1 w0.089: v2(177.17,96.97) 176.94,96.91 176.78,97 176.71,97.29 176.71,97.3 176.94,97.53 177.49,97.53 179.02,96 183.08,96 185.42,93.66 185.42,90.54 182.39,87.51 182.39,76.89 180.88,75.38 180.88,74.38 181.27,73.99 181.27,72.74 181.91,72.1 181.91,71.29 180.88,70.27 180.88,68.14 182.84,66.18 182.84,64.49 183.4,63.94 183.4,63.93 183.68,63.66 183.68,61.93 184.15,61.45 184.15,52.9 184.73,52.32 184.73,42.57 185.89,41.4 185.89,40.26 186.25,39.9 186.25,38.49 190.03,34.71 191.54,34.71 192.2,35.37 192.49,35.37 192.86,35 192.86,33.65 196.86,29.65 196.86,28.11 197.83,27.14 197.83,26.95 197.76,26.83 197.76,26.82 v2(197.42,26.72)
  BOTTOM w0.076: 173.48,98.63 173.46,98.63 173.43,98.6 172.98,98.6 172.85,98.47 172.51,98.13 UC1.B5
  BOTTOM w0.107: UH1.J32 197.42,26.14 v2(197.42,26.72) ; 173.48,98.63 174.07,98.63 174.42,98.28 175.98,98.28 177,97.26 177,97.13 v2(177.17,96.97)
DMI_CTX_PRX_P3: length 94
  IN1 w0.089: v2(174.64,96.76) 174.85,96.55 174.85,96.32 175.73,95.43 179.2,95.43 179.27,95.37 182.81,95.37 184.79,93.39 184.79,90.81 181.73,87.75 181.11,87.75 180.25,86.89 180.25,74.11 180.64,73.73 180.64,70.97 180.25,70.58 180.25,67.87 182.21,65.91 182.21,64.22 183.04,63.39 183.04,61.66 183.52,61.19 183.52,52.64 184.1,52.06 184.1,42.3 185.26,41.14 185.26,40 185.62,39.63 185.62,38.23 186.85,37 186.85,36.99 188.17,35.67 188.18,35.67 189.96,33.89 191.06,33.89 192.27,32.67 192.77,32.67 194.6,30.85 194.6,28.1 195.84,26.85 196.1,26.85 196.22,26.76 196.27,26.57 196.29,26.47 v2(196.17,26.27)
  BOTTOM w0.076: 173.41,97.67 173.4,97.68 173.39,97.68 173.39,97.67 172.54,97.67 172.32,97.46 172.32,97.29 172.14,97.11 171.89,97.11 UC1.D4
  BOTTOM w0.107: v2(174.64,96.76) 174.71,96.83 174.71,97.13 174.62,97.22 173.86,97.22 173.41,97.67 ; v2(196.17,26.27) UH1.F30
DMIC_CLK1_R: length 3.5
  BOTTOM w0.099: LA6.2 34.36,38.26 34.36,37.46 v1(34.08,37.18) 33.62,36.71 UA1.53
DMIC_DATA1_R: length 3.6
  BOTTOM w0.099: RA19.2 35.31,37.17 35.41,37.07 35.66,37.07 35.76,36.98 35.76,36.73 35.66,36.63 34.22,36.63 34.02,36.43 UA1.54
DP_CBL_DET: length 155.4
  TOP w0.102: v2(232.8,170.54) 233.4,169.94 235.67,169.94 236.37,169.24 237.35,169.24 238.22,168.37 238.22,165.68 v1(237.61,165.07) 237.44,164.9 234.83,164.9 234.33,164.39 234.33,161.47 v2(233.44,160.58)
  IN4 w0.102: v2(220.72,122.11) 220.72,122.03 223.36,119.4 225.48,119.4 226.1,120.02 226.1,121.83 229.77,125.49 236.11,125.49 239.25,128.63 261.99,128.63 264.75,131.38 268.68,131.38 269.78,132.48 269.78,144.87 264.04,150.61 257.7,150.61 257.15,151.17 253.4,151.17 252.42,150.19 244.78,150.19 243.21,151.77 241.24,151.77 240.03,152.98 239.07,152.98 238.48,153.58 238.48,158.21 236.1,160.58 v2(233.44,160.58)
  BOTTOM w0.089: 211.19,123.77 211.48,123.49 211.48,123.03 212.6,121.91 213.04,121.91 214.21,120.74 215.95,120.74 216.4,121.19 218.56,121.19 219.48,122.11 v2(220.72,122.11)
  BOTTOM w0.102: RV17.1 228.55,159.92 228.55,160.86 228.66,160.97 UV3.1 230.27,160.97 230.67,160.58 v2(233.44,160.58) ; QG500.2 209.62,123.97 209.89,124.24 210.72,124.24 211.19,123.77
  BOTTOM w0.107: JDP.4 232.97,171.21 232.8,171.04 v2(232.8,170.54)
DP_CBL_DET#: length 41.7
  TOP w0.089: v2(221.47,112.35) v1(220.9,112.35)
  IN2 w0.089: 226.04,122.36 226.04,121.42 225.12,120.5 225.12,120.04 225.3,119.87 225.3,118.79 226.06,118.03 226.06,112.44 226,112.38 226,110.52 224.56,109.08 223.2,109.08 221.47,110.81 v2(221.47,112.35)
  IN2 w0.102: 226.04,122.36 226.04,123.97 223.97,126.04 216.57,126.04 215.6,127.01 210.1,127.01 v2(209.91,126.83)
  BOTTOM w0.089: UG9.BD5 v2(221.47,112.35)
  BOTTOM w0.102: v2(209.91,126.83) 209.08,126.83 208.7,127.21 RG540.1
DP_HPD_PCH: length 195.2
  TOP w0.102: v1(222.59,160.33) 222.59,160.42 222.28,160.72 v2(222.28,160.73) 222.28,160.79 222.91,161.41 RX4.1 222.91,162.21 222.87,162.25 UX1.1
  IN1 w0.089: v2(212.82,30.34) 212.82,30.89 212.16,31.55 209.05,31.55 208.66,31.94 208.66,32.32 207.97,33.01 207.46,33.01 206.89,33.58 205.94,33.58 205.18,34.34 204.22,34.34 203.55,35.02 203.55,35.34 203.08,35.8 203.08,36.69 202.82,36.96 202.17,36.96 201.67,37.45 201.67,37.51 201.24,37.94 201.24,38.47 196.73,42.98 196.73,43.3 196.22,43.81 195.53,43.81 194.36,44.97
  IN1 w0.102: 194.36,44.97 193.85,45.48 192.1,45.48 191.24,46.33 191.24,48.8 192.03,49.58 192.16,49.72 192.16,53.44 192.16,53.82 191.74,54.23 191.74,58.38 191.21,58.91 191.21,61.39 192.66,62.84 v2(192.66,63.26)
  IN2 w0.102: v2(222.28,160.73) 222.06,160.73 221.51,160.19 217.34,160.19 217.13,160.4 216.85,160.4 216.58,160.14 216.58,159.13 216.42,158.97 214.8,158.97 213.71,160.06 211.9,160.06 208.87,157.04 208.87,156.69 207.51,155.32 206.82,155.32 205.99,154.5 205.99,151.61 196.47,142.08 196.47,139.86 196.47,139.67 191.36,134.56 191.36,129.03 183.63,121.3 183.63,106.92 181.59,104.89 181.59,97.89 185.71,93.77 185.71,88.35 185.71,88.16 182.09,84.54 182.09,82.97 179.85,80.74 179.85,74.5 180.73,73.62 180.73,73.43 180.73,70.73 181.11,70.35 182.95,70.35 184.29,69.02 185.43,69.02 189.43,65.01 190.9,65.01 v2(192.66,63.26)
  BOTTOM w0.089: v2(212.82,30.34) 212.78,30.34 UH1.AW24
  BOTTOM w0.102: QX2.3 226.87,167 225.14,165.27 225.14,164.61 225.1,164.57 225.1,163.97 224.54,163.41 224.54,161.27 224.19,160.91 223.72,160.91 223.54,160.73 v2(222.28,160.73)
