# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_P9_R: length 4.9
  TOP w0.102: JTOBII.4 156.96,168.1 156.85,168.2 156.51,168.2 156.39,168.33 156.39,168.78 156.55,168.94 156.69,168.94 v2(156.86,168.77)
  BOTTOM w0.102: LE3.3 156.84,167.35 RE648.2
  BOTTOM w0.107: v2(156.86,168.77) 156.86,168.89 156.91,168.95 157.03,168.95 157.09,169.01 157.23,169.01 157.3,168.93 157.3,168.52 157.17,168.39 157.17,168.03 156.87,167.74 LE3.3
USB20_P10: length 102.5
  TOP w0.107: v2(143.58,2.98) 143.77,3.18 143.77,3.72 144.69,4.63 144.69,4.76 144.6,4.85 144.43,4.85 DK1.3 144.29,5.2 144.51,5.43 144.76,5.43 144.87,5.54 144.87,6.05 145.23,6.42 145.54,6.42 145.57,6.44 146.14,6.44 146.17,6.42 146.59,6.42 147.28,5.73 147.28,2.74 147.86,2.16 152.39,2.16 152.84,2.61 152.84,4.31 v2(152.65,4.5)
  IN6 w0.089: v2(195.47,44.48) 195.64,44.28 195.63,44.13 194.75,43.25 194.75,36.55 196.86,34.44 196.86,34.18 196.59,33.92 196.59,33.04 194.63,31.08 191.76,31.08 191.18,31.66 190.9,31.66 190.44,32.12 183.09,32.12 180.9,29.92 172.66,29.92 171.61,28.87 162.32,28.87 161.78,28.32 161.78,27.74 v2(161.36,27.32)
  BOTTOM w0.107: UH1.H2 197.28,40.79 197.39,40.9 197.39,41.51 196.74,42.16 196.74,42.27 196.74,42.27 196.54,42.47 196.54,43.19 196.25,43.48 195.89,43.48 195.62,43.75 195.62,44.34 195.47,44.48 v2(195.47,44.48) ; JPK.11 v2(143.58,2.98) ; v2(152.65,4.5) 152.84,4.69 152.84,10.68 161.73,19.57 161.73,26.95 v2(161.36,27.32)
USB20_P11: length 182.8
  TOP w0.107: v2(189.09,146.88) 189.28,146.69 192.89,146.69 194.84,144.74 201.14,144.74 205.66,149.27 205.66,152.47 205.96,152.77 206.34,152.77 v2(206.55,152.98) ; v2(207.59,163.62) 207.41,163.8 207.41,169.03 205.36,171.09 202.87,171.09 202.41,170.63 202.41,170.43 202.2,170.22 201.93,170.22 RT115.1
  IN4 w0.127: v2(199.59,37.14) 199.59,36.98 199.46,36.85 199.26,36.85 198.67,37.45 198,37.45 197,36.44 195.06,36.44 193.63,37.86 191.74,37.86 191.21,38.4 190.45,38.4 189.94,38.91 189.94,41.01 184.84,46.11 184.84,46.89 184.57,47.16 184.57,50.37 183.07,51.87 181.43,51.87 180.99,52.31 180.99,56.35 181.2,56.57 181.2,58.92 180.59,59.53 180.59,65.14 181,65.55 181,70.56 181.52,71.08 181.67,71.08 182.23,71.64 182.23,73.49 179.82,75.9 179.82,82.13 177.59,84.35 177.59,94.14 179.9,96.46 179.9,108.58 180.73,109.4 180.73,111.25 180.92,111.44 180.92,116.86 182.39,118.34 182.39,121.85 190.09,129.54 190.09,137.79 189.43,138.45 189.43,144.91 189.81,145.29 189.81,146.46 189.56,146.71 189.25,146.71 v2(189.09,146.88)
  IN6 w0.089: v2(207.59,163.62) 207.54,163.62 207.37,163.45 207.37,163.3 207.11,163.03 206.7,163.03 206.42,162.75 206.42,160.89 207.07,160.24 207.07,155.2 205.93,154.05 205.93,152.99 206.14,152.77 206.34,152.77 v2(206.55,152.98)
  BOTTOM w0.107: v2(199.59,37.14) 199.92,37.14 UH1.P9
USB20_P11_R: length 6.1
  TOP w0.107: RT115.2 201.31,169.54 201.31,169.08 201.31,169.08 201.31,168.93 201.31,168.92 201.31,168.88 200.54,168.11 200.32,168.11 200.21,168.22 200.21,168.62 v2(200.35,168.71) 200.22,168.71 200.11,168.82 200.11,168.86 199.98,168.99 RT113.2
  BOTTOM w0.076: 200.35,168.46 200.35,168.39 199.97,168.01 199.97,167.9 200.18,167.69 200.18,167.14 200.09,167.05 200.09,166.94
  BOTTOM w0.089: UT4.L5 200.09,166.94
  BOTTOM w0.107: 200.35,168.46 v2(200.35,168.71)
USB20_P14: length 121.9
  IN6 w0.089: v2(300.78,33.18) 300.94,33.02 300.94,32.78 300.85,32.69 299.86,32.69 299.58,32.97 293.78,32.97 292.64,31.83 288.74,31.83 288.41,31.5 284.75,31.5 284.24,32.01 277.75,32.01 277.45,31.7 264.94,31.7 262.83,33.81 253.59,33.81 251.89,35.51 249.43,35.51 246.47,38.47 240.32,38.47 239.11,39.68 234.76,39.68 233.68,40.76 232.04,40.76 231.66,41.14 230.17,41.14 230.11,41.09 224.98,41.09 223.03,43.04 223.03,43.13 222.4,43.13 213.83,43.13 212.99,43.97 210.29,43.97 210.01,44.24 205.3,44.24 204.64,43.59 202.28,43.59 201.27,44.61 201.27,45.35 200.94,45.67 200.52,45.67 199.97,45.67 199.47,45.18 198.38,45.18 197.3,44.1 197.3,43.59 195.97,42.26 195.97,39.49 195.8,39.33 195.8,38.96 195.9,38.87 195.96,38.79 195.97,38.79 195.96,38.66 v2(195.81,38.53)
  BOTTOM w0.107: v2(195.81,38.53) 195.85,38.49 UH1.F6 ; JWLAN.3 300.82,34.71 300.92,34.61 300.92,33.32 v2(300.78,33.18)
USB31_PWR_EN: length 363.1
  TOP w0.102: v2(22.58,51.29) 22.35,51.53 22,51.53 21.87,51.65 21.86,51.65 21.78,51.74 UU2.3 ; UE10.19 314.68,60.81 v2(314.65,60.79)
  IN2 w0.102: v2(182.25,45.39) 183.94,45.39 187.27,48.72 191.12,48.72 193.12,50.73 199.75,50.73 203.03,54.01 206.78,54.01 209.81,50.97 209.81,49.76 210.7,48.87 214.78,48.87 216.19,47.46 224.61,47.46 225.03,47.04 242.87,47.04 244.41,45.51 245.16,44.76 266.52,44.76 270.26,41.01 272.36,41.01 v2(272.49,41.14)
  IN3 w0.102: v2(36.9,53.58) 37.28,53.97 41.72,53.97 43.24,52.44 45.69,52.44 46.1,52.04 50.52,52.04 50.71,52.04 51.35,51.4 54.99,51.4 55.37,51.77 55.5,51.91 65.13,51.91 68.12,48.93 69.71,48.93 83.9,34.74 84.32,34.32 84.32,33.77 85.19,31.86 88.38,24.87 90.94,22.79 105.54,22.79 105.76,23.01 105.76,23.64 106.56,24.45 118.5,24.45 120.01,25.95 174.31,25.95 178.95,30.6 178.95,32.33 180.97,34.35 180.97,43.86 182.25,45.14 v2(182.25,45.39)
  IN4 w0.102: v2(36.9,53.58) 35.9,54.59 33.21,54.59 30.58,51.96 30.58,50.83 30.18,50.44 28.57,50.44 27.85,49.71 27.85,47.06 27.47,46.68 25.51,46.68 25.24,46.94 24.67,46.94 24.53,46.8 23.25,46.8 22.44,47.62 22.44,51.15 v2(22.58,51.29) ; v2(272.49,41.14) 277.65,41.14 278.6,42.09 291.47,42.09 292.55,41.01 294.9,41.01 295.09,41.01 296.07,40.03 297.32,40.03 297.47,40.18 297.47,41.29 297.6,41.43 299.22,43.04 306.21,43.04 306.97,43.81 307.32,43.81 314.37,50.86 314.37,57.5 314.99,58.12 314.99,60.44 v2(314.65,60.79)
USB_FLIP: length 18.5
  TOP w0.102: v2(26.27,51.07) 26.27,50.6 RU19.1
  IN4 w0.102: v2(26.27,51.07) 26.2,51.07 25.6,50.47 23.91,50.47 23.38,51.01 23.38,55.65 23.96,56.24 23.96,57.53 23.49,58.01 19.46,58.01 v2(19.36,57.9)
  BOTTOM w0.102: QU2.2 19.49,56.32 19.11,56.7 19.11,57.66 v2(19.36,57.9) ; v2(26.27,51.07) 26.27,51.04 26.3,51.04 26.41,50.94 UU7.18
USB_MODE: length 1.5
  TOP w0.102: RU20.1 27,50.93 v2(26.86,51.07)
  BOTTOM w0.102: UU7.19 26.91,51.02 v2(26.86,51.07)
USB_OC0#: length 233.1
  TOP w0.089: 208.29,16.96 208.42,17.08 208.42,18.52 208.15,18.79 208.15,18.79 207.46,19.47 v1(207.46,19.94) 207.46,22.22 208.03,22.79 208.03,23.43 v2(207.63,23.83)
  TOP w0.114: UU1.13 20.56,45.86 20.14,46.28 v2(20.14,46.55) ; RPH6.4 208.48,15.54 208.1,15.92 208.1,16.76 208.29,16.96
  IN6 w0.081: 191.87,30.07 191.73,30.21 191.73,30.21 191.58,30.37 190.92,31.03 190.64,31.03 190.47,31.19 189.44,31.19 189.27,31.03 185.09,31.03 184.74,30.68 183.9,29.84 182.11,29.84 180.89,28.63 172.98,28.63 170.87,26.52 129.97,26.52 127.68,28.81 108.33,28.81 101.86,35.27 101.86,41.6 98.24,45.23 97.2,45.23 96.69,45.74 94.15,45.74 92.57,47.32 64.05,47.32 63.7,47.68 57.59,47.68 56.91,46.99 55.01,46.99 54.31,46.29 50.42,46.29 48.56,48.15 38.31,48.15 37.83,47.67 33.75,47.67 32.77,46.7 32.77,45.32 32.11,44.66 31.94,44.66 31.64,44.37 31.64,44.26 31.57,44.19 31.57,43.03 29.35,40.8 28.21,40.8 25.31,37.91 24.02,37.91 24.01,37.92 23,37.92 20.66,40.26 20.66,43.67 20.14,44.19 v2(20.14,46.55)
  IN6 w0.089: 191.87,30.07 192.45,29.49 192.45,27.77 192.86,27.36 195.08,27.36 196.12,28.39 196.12,28.4 196.33,28.61 196.33,28.61 196.54,28.81 198.54,28.81 200.45,26.9 200.45,26.6 202.04,25.01 203.02,25.01 203.81,24.22 205.3,24.22 206.07,23.45 207.24,23.45 v2(207.63,23.83)
  BOTTOM w0.122: UH1.AH36 v2(207.63,23.83)
USB_OC1#: length 150.7
  TOP w0.089: v2(214.18,34.22) 214.18,34.04 213.22,33.07 212.86,33.07 212.11,32.32 212.11,30.9 211.29,30.08 209.04,30.08 v1(208.55,29.59) 208.16,29.2 208.16,26.15 207.99,25.98 207.99,24.68 208.02,24.65 208.02,23.89 208.29,23.61 208.29,22.53 207.84,22.09 v2(207.84,21.96) 208.26,21.54 208.26,20.87 207.78,20.39 207.78,19.92 208.19,19.51 208.45,19.51 208.8,19.16 208.8,18.77 208.61,18.57 208.61,16.96
  TOP w0.102: CU17.1 319.39,26.1 319.2,25.91 v2(319.2,25.53) 319.26,25.46 UU3.3 ; 208.61,16.96 208.61,16.9 208.35,16.65 208.35,16.24 208.98,15.62 RPH6.3
  IN2 w0.089: 219.18,35.42 218.96,35.42 218.58,35.04 217.24,35.04 216.42,34.22 v2(214.18,34.22)
  IN2 w0.102: v2(319.2,25.53) 316.54,28.18 314.11,28.18 312.81,26.88 312.81,25.52 311.95,24.66 311.95,23.51 311.71,23.27 311.39,23.27 309.57,21.44 308.12,21.44 306.69,20.02 305.6,20.02 305.57,19.99 305.44,19.85 303.44,19.85 303.33,19.74 303.1,19.74 302.87,19.97 302.54,19.97 302.3,19.74 302.3,19.3 301.82,18.82 296.6,18.82 296.54,18.76 284.98,18.76 278.53,25.21 276.53,25.21 275.53,26.22 274.61,26.22 272.25,28.58 266.2,28.58 265.34,29.44 257.37,29.44 256.97,29.84 248.87,29.84 248.2,30.5 242.84,30.5 241.14,32.19 241.14,34.68 239.67,36.15 238.79,36.15 237.6,37.34 229.89,37.34 229.43,36.88 228.08,36.88 225.26,34.06 223.71,34.06 222.73,35.04 220.23,35.04 219.85,35.42 219.18,35.42
  BOTTOM w0.122: UH1.AL40 208.1,22.22 v2(207.84,21.96)
USB_OC2#: length 6.5
  TOP w0.089: v2(208.33,20.13) v1(209.3,19.16) 209.3,18.66 209.05,18.41 209.05,17.45 209.55,16.96
  TOP w0.114: 209.55,16.96 210.12,16.39 210.12,15.55 RPH6.1
  BOTTOM w0.122: UH1.AJ44 207.79,20.13 v2(208.33,20.13)
USB_OC3#: length 8.2
  TOP w0.089: v2(209.04,21.57) v1(208.64,21.17) 208.44,20.97 208.44,20.79 207.96,20.31 207.96,19.99 208.26,19.69 208.52,19.69 208.98,19.23 208.98,18.7 208.94,18.65 208.94,18.61 208.86,18.53 208.86,17.26 209.17,16.96
  TOP w0.102: 209.17,16.96 209.75,16.38 209.75,15.88 209.48,15.62 RPH6.2
  BOTTOM w0.089: UH1.AL41 208.65,21.57 v2(209.04,21.57)
USB_PWR_EN: length 22.7
  TOP w0.102: UU3.4 317.84,25.46 318.46,26.09 CU16.1 318.63,26.84 RE645.2 317.65,27.63 317.19,27.17 v1(315.73,27.17) 314.58,27.17 314.33,26.92 v2(314.32,26.92)
  TOP w0.107: v2(305.92,19.61) UE5.117
  IN1 w0.102: v2(314.32,26.92) 314.32,26.8 313.83,26.3 313.83,22.96 312.52,21.66 312.52,20.46 312.21,20.16 306.47,20.16 v2(305.92,19.61)
USB_SEL0: length 2
  TOP w0.102: RU30.1 13.74,54.18 14.15,54.18 14.2,54.13 14.26,54.13 14.3,54.09 14.61,54.09 14.66,54.14 UU2.28
USB_SEL1: length 2
  TOP w0.102: UU2.27 14.32,54.54 v2(14.3,54.56)
  BOTTOM w0.102: v1(14.44,54.05) 14.3,54.19 v2(14.3,54.56) 14.32,54.58 RU29.2
USB_XTAL24_IN: length 2.5
  TOP w0.102: UU2.25 13.77,55.34 RU34.2 13.71,55.97 v1(14.06,56.32)
USB_XTAL24_IN_R: length 6.2
  TOP w0.102: RU34.1 13,55.53 RU28.1 11.79,55.53 CU51.1 11.52,54.28 11.52,53.01 v1(11.4,52.9) 11.35,52.85 YU1.1
USB_XTAL24_OUT: length 1.5
  TOP w0.102: UU2.26 14.5,54.94 14.47,54.96 13.92,54.96 13.78,54.82 RU35.2
USB_XTAL24_OUT_R: length 7.2
  TOP w0.102: YU1.3 12.2,49.97 12.2,52.17 11.82,52.56 11.82,53.52 12.09,53.79 12.34,53.79 CU52.1 12.38,53.8 RU28.2 12.58,54.82 RU35.1
USBC_PWR_EN: length 353.7
  TOP w0.102: v2(28.21,45.33) 28.28,45.41 CU35.1 28.28,46.41 RE649.2 31.06,46.98 31.57,47.49 31.57,48.61 31.94,48.97 31.94,49.37 v2(31.95,49.37) ; UE10.5 318.26,56.95 v2(318.51,56.7)
  IN2 w0.102: v2(322.08,34.79) 320.83,34.79 316.83,30.79 311.6,30.79 309.82,29.01 309.01,29.01 306.83,26.83 306,26.83 305.03,25.86 304.53,25.86 295.57,25.86 289.84,31.59 284.82,31.59 281.82,34.58 281.82,34.86 281.13,35.55 275.4,35.55 266.42,44.53 245.07,44.53 244.64,44.96 242.78,46.82 224.94,46.82 224.52,47.23 216.1,47.23 214.69,48.64 210.6,48.64 209.58,49.66 209.58,50.83 206.63,53.78 203.24,53.78 199.96,50.5 193.22,50.5 191.21,48.5 187.37,48.5 183.86,44.99 181.77,44.99 180.65,46.1 178.46,46.1 176.42,48.14 174.49,48.14 174.02,48.6 172.59,48.6 172.49,48.71 154.81,48.71 154.21,49.31 144.99,49.31 144.39,48.71 124.29,48.71 123.79,49.2 99.93,49.2 99.44,48.71 97.53,48.71 96.89,49.35 95.53,49.35 94.91,49.97 92.24,49.97 91.43,49.15 83.57,49.15 83.31,48.89 67.34,48.89 65.99,50.24 64.04,50.24 63.41,49.62 58.35,49.62 57.92,50.05 46.76,50.05 46.05,50.77 37.31,50.77 36.97,51.11 34.11,51.11 32.34,49.34 31.98,49.34 v2(31.95,49.37)
  BOTTOM w0.102: v2(318.51,56.7) 318.91,56.3 v1(318.91,54.47) 318.91,53.93 319.21,53.62 319.21,52.78 320.32,51.67 320.32,51.13 315.92,46.73 315.92,45.84 317.57,44.19 318.79,44.19 320.62,42.36 321.36,42.36 321.71,42.01 321.71,39.85 321.06,39.19 321.06,38.42 322.08,37.4 v2(322.08,34.79) ; UU7.6 v2(28.21,45.33)
USBCHG_DET#: length 31.9
  TOP w0.102: v2(29.92,43.66) v3(29.2,43.66)
  TOP w0.254: DU6.2 32.46,45.39 32.1,45.04 31.56,45.04 31.19,45.41 CU28.1 30.26,45.41 RU4.2
  TOP w0.508: CU27.2 23.5,37.71 23.69,37.52 v2(23.73,37.52) ; v2(29.92,43.66) 29.92,44.88 30.25,45.22 RU4.2
  IN1 w0.508: JUSB1.10 13.78,35.48 14.58,36.27 15.25,36.27 16.15,37.18 23.39,37.18 v2(23.73,37.52) 24.28,38.07 25.07,38.07 27.12,40.12 28.9,40.12 29.74,39.28 31.2,39.28 31.57,39.65 31.57,41.96 30.68,42.85 30.17,42.85 29.92,43.11 v2(29.92,43.66)
USBCHG_DET_D: length 56.8
  TOP w0.102: v1(59.78,45.36) 59.6,45.53 v2(59.6,46.12)
  TOP w0.254: UU5.4 19.17,37.37 RU6.1 18.74,37.96 18.55,37.77 v2(18.55,37.79) ; v2(59.6,46.12) 59.33,46.39 PD100.3
  IN3 w0.254: v2(18.55,37.79) 17.92,38.42 17.92,39.17 18.68,39.93 18.68,41.46 21.09,43.87 21.85,43.87 22.36,43.36 25.41,43.36 28.66,46.61 28.66,49.04 28.95,49.33 30.49,49.33 31.22,50.06 31.22,50.17 31.57,50.52 32.55,50.52 33.16,49.91 33.78,49.91 35.83,47.87 48.71,47.87 50.24,46.35 54.56,46.35 55.19,46.98 57.22,46.98 58.09,46.12 v2(59.6,46.12)
USBCHG_DET_EC#: length 321.5
  TOP w0.102: DU6.1 31.38,46.97 v1(30.93,46.53) v2(30.93,46.02) ; CU29.1 RU6.2 20.01,37.96 19.55,38.42 18.67,38.42 v2(18.61,38.47)
  TOP w0.107: v2(295.41,24.43) 295.17,24.19 295.17,21.32 296.78,19.72 296.78,17.3 296.55,17.07 296.55,14.74 296.96,14.34 296.96,11.08 297.14,10.9 UE5.75
  IN2 w0.089: 201.81,45.6 201.72,45.51 201.24,45.51
  IN2 w0.102: 201.81,45.6 202.19,45.98 210,45.98 210.26,46.24 211.09,46.24 211.8,45.53 217.39,45.53 217.77,45.15 223.98,45.15 225.21,43.92 229.39,43.92 229.64,44.16 233.85,44.16 235.04,45.36 237.06,45.36 238.89,43.53 239.86,43.53 241.23,42.15 243.99,42.15 245.45,43.62 265.92,43.62 276.42,33.11 279.81,33.11 283.64,29.29 290.23,29.29 295.09,24.43 v2(295.41,24.43) ; v2(18.61,38.47) 18.8,38.47 19,38.28 19.95,38.28 22.04,40.38 22.55,40.38 27,44.82 28.39,44.82 29.47,45.9 30.82,45.9 v2(30.93,46.02) 30.93,46.28 31.38,46.73 31.38,47 32.02,47.65 37.44,47.65 37.73,47.94 37.99,48.2 48.56,48.2 50.06,46.7 53.06,46.7 53.54,46.22 54.33,46.22 55.01,46.9 57.29,46.9 58.39,48 64.03,48 64.16,48.13 64.63,48.13 65.42,47.34 87.32,47.34 87.51,47.53 96.29,47.53 96.85,46.97 98.78,46.97 98.95,46.8 107.08,46.8 112.95,40.94 133.27,40.94 134.07,40.13 182.67,40.13 184.36,41.82 184.82,41.82 185.88,42.88 186.15,43.15 189.2,43.15 190.74,44.69 195.15,44.69 195.32,44.85 196.19,44.85 196.6,44.44 197.05,44.44 197.6,44.99 199.51,44.99 200.03,45.51 201.24,45.51
VCIN0_PH1: length 303.2
  TOP w0.203: UE5.109 306.23,16.41 305.89,16.75 v2(305.89,16.88)
  TOP w0.254: PH1.1 153.72,112.22 v2(153.94,112) ; PR25.1 PR24.1 312.17,52.75 312.17,52.18 311.44,51.45 311.44,50.82 v1(309.31,48.69) 308.11,47.49 v2(307.79,47.49)
  IN2 w0.254: v2(307.3,24.47) 307.3,23.83 307.05,23.57 303.58,23.57 302.57,23.57 301.23,22.24 301.19,22.24 301.07,22.12 298.86,22.12 298.15,21.41 297.36,21.41 297.29,21.48 296.57,22.2 291.14,22.2 291.13,22.2 290.15,22.2 289.58,22.77 289.58,24.1 288.55,25.12 287.74,25.12 287.07,25.8 286.64,25.8 286.07,26.37 285.88,26.37 285.59,26.65 285.59,26.84 284.87,27.56 282.83,27.56 280.85,29.54 278.74,29.54 277.91,30.37 276.36,30.37 275.09,31.64 272.83,31.64 272.47,32.01 268.94,32.01 268.28,32.66 261.47,32.66 261.05,33.08 251.76,33.08 251.36,33.48 251.25,33.48 248.95,35.78 248.95,37.02 247.12,38.85 240.52,38.85 239.01,40.36 236.35,40.36 235.34,41.37 230.08,41.37 229.14,40.43 225.18,40.43 222.88,42.73 214.77,42.73 213.38,41.34 209.79,41.34 209.75,41.37 206.74,41.37 206.57,41.2 204.86,41.2 204.57,41.49 200.03,41.49 199.94,41.39 197.18,41.39 196.92,41.13 195.12,41.13 193.08,39.09 192.33,39.09 191.44,38.2 189.86,38.2 189.76,38.29 185.92,38.29 185.59,37.96 183.75,37.96 180.11,34.32 164.96,34.32 163.27,36.01 v2(163.27,36.06)
  IN3 w0.254: v2(153.94,112) 153.75,112 153.27,111.53 153.27,110.06 153.86,109.48 153.86,108.41 152.92,107.48 152.92,104.02 152.05,103.15 152.05,99.22 152.84,98.42 152.84,89.03 155.71,86.16 166,86.16 168.66,83.49 168.66,60.92 167.84,60.09 167.84,55.2 164.85,52.22 164.85,48.47 164.09,47.71 164.09,40.73 163.27,39.9 v2(163.27,36.06) ; v2(307.79,47.49) 307.79,47.87 307.03,48.63 305.6,48.63 304.62,47.65 304.62,41.14 303.92,40.44 303.92,35.61 305.25,34.28 305.25,32.06 305.09,31.89 305.09,30.89 305.76,30.22 306.71,30.22 307.3,29.63 307.3,27.57 307.3,27.56 307.3,25.63 307.3,25.63 v2(307.3,24.47)
  BOTTOM w0.254: v2(307.3,24.47) 307.3,18.3 v2(305.89,16.88)
VCIN1_AC_IN: length 390.9
  TOP w0.102: QE3.5 325.83,44.4 325.73,44.3 324.41,44.3 323.44,43.33 323.09,43.33 323.09,43.33 322.43,43.33 v2(322.14,43.62)
  TOP w0.107: CE40.2 308.64,15.59 308.43,15.8 v2(308.4,15.8) 308.4,16.5 308.09,16.81 UE5.110
  TOP w0.203: PR714.2 56.59,27.37 v2(56.59,27.3) 57.04,26.84 PU700.5
  TOP w0.254: v2(239.53,28.44) 239.98,27.99 239.98,24.74 239.39,24.15 239.39,21.95 239.06,21.62 239.06,21.13 237.27,19.33 237.27,17.3 236.71,16.74 236.71,14.12 233.05,10.47 v2(233.05,9.58) ; v2(201.62,11.19) 201.62,11.93 200.72,12.83 200.72,14.35 198.53,16.54 196.07,16.54 195.89,16.36 193.84,16.36 193.25,15.78 192.17,15.78 191.83,16.12 183.84,16.12 v1(183.1,16.86) 182.63,17.33 v2(182.63,18.53)
  IN1 w0.102: v2(239.53,28.44) 239.18,28.79 239.18,32.39 239.73,32.95 241.77,32.95 243.15,34.33 243.15,35.16 243.73,35.74 245.67,35.74 249.89,39.96 249.89,42.13 251.51,43.74 265.32,43.74 272.99,36.07 277.28,36.07 278.02,35.33 287.86,35.33 291.67,39.14 302.25,39.14 303.16,40.06 309.57,40.06 310.71,41.2 317.13,41.2 318.78,39.54 321.6,39.54 322.14,40.09 v2(322.14,43.62)
  IN2 w0.254: v2(102.82,33.26) 102.05,32.5 100.36,32.5 100.23,32.38 98.69,32.38 98.05,31.74 98.05,26.85 97.23,26.03 97.23,24.31 96.85,23.93 v2(93.73,23.93)
  IN3 w0.102: v2(308.4,15.8) 310.14,15.8 310.52,16.18 310.7,16.18 312.11,17.59 312.11,17.61 312.21,17.71 312.21,17.72 312.52,18.02 312.52,18.78 313.6,19.87 314.65,19.87 315.74,20.96 315.74,25.96 315.57,26.14 315.57,27.21 315.95,27.59 315.95,27.77 314.99,28.73 314.99,30.01 316.85,31.87 316.85,32.67 321.28,37.1 321.28,39.05 322.07,39.84 322.07,43.54 v2(322.14,43.62)
  IN4 w0.254: v2(56.59,27.3) 57.95,28.65 69.31,28.65 75.57,34.92 79.57,34.92 85.54,28.95 85.54,23.68 85.8,23.42 93.23,23.42 v2(93.73,23.93) ; v2(182.63,18.53) 136.64,18.53 136.37,18.27 109.75,18.27 105.88,22.14 105.88,26.13 103.99,28.01 103.99,31.39 102.82,32.57 v2(102.82,33.26)
  BOTTOM w0.254: v2(201.62,11.19) 201.62,10.33 DH1.1 201.92,9.42 202.86,9.42 203.02,9.26 203.47,9.26 204.24,8.49 205,8.49 205.74,7.75 205.74,6.73 206.6,5.87 225.65,5.87 226.89,7.12 226.89,7.61 228.77,9.49 229.48,9.49 229.75,9.76 232.88,9.76 v2(233.05,9.58) ; v2(56.59,27.3) 56.71,27.3 57.24,26.77 PR715.1
VCIN1_ADP_PROCHOT: length 19.7
  TOP w0.102: PR23.1 291.64,7.2 v1(291.26,7.59)
  TOP w0.203: UE5.102 306.3,13.61 305.7,14.22 v2(305.7,14.28)
  TOP w0.254: PR23.1 PC13.2 PR26.2 294.18,7.2 294.75,7.78 294.75,8.39 v2(295.09,8.73)
  IN3 w0.254: v2(305.7,14.28) 305.7,14.21 301.06,9.58 295.94,9.58 v2(295.09,8.73)
VCIN_ BATT_TEMP: length 279.6
  TOP w0.203: CE35.2 289.76,12.01 UE5.63
  TOP w0.254: v2(54.35,19.23) 54.66,19.54 PR727.1 ; v2(285.25,12.88) 285.25,11.13 285.5,10.87 289.29,10.87 289.63,11.21 CE35.2 ; v2(86.62,19.61) v1(86.62,16.35) 86.62,10.46 85.78,9.62 PC14.1 81.87,10.16 PR16.1 81.87,11.15 81.31,11.72 PR22.2 79.72,11.65 PD3.2
  IN4 w0.254: v2(86.62,19.61) 80.84,13.83 56.97,13.83 54.35,16.45 v2(54.35,19.23)
  IN6 w0.254: v2(86.62,19.61) 91.83,14.41 103.44,14.41 107.32,10.53 111.33,10.53 111.83,10.02 122.82,10.02 123.9,11.1 128.15,11.1 134.12,17.07 169.64,17.07 172.63,14.09 182.2,14.09 186.12,10.17 186.32,9.97 187.24,9.97 188.42,8.79 189.15,8.79 189.41,8.79 189.94,8.26 192.83,8.26 194,7.08 203.44,7.08 203.7,6.82 230.05,6.82 230.43,7.2 253.1,7.2 254.4,8.5 256.17,8.5 260.27,12.6 271.84,12.6 272.18,12.94 280.29,12.94 280.35,12.88 v2(285.25,12.88)
VCLK_5V: length 2.4
  BOTTOM w0.203: PR107.1 50.37,48.05 v1(51.14,48.05) 51.62,48.05 51.8,47.88 PU100.19
VCOUT0_MAIN_PWR_ON#: length 288.2
  TOP w0.107: v2(308.4,14.41) UE5.104
  TOP w0.254: v2(59.17,50.27) 59.17,50.09 58.77,49.69 PR114.1
  IN2 w0.102: v2(306.82,29.12) 306.42,29.52 304.87,29.52 303.46,28.11 295.74,28.11 294.31,29.54 293.2,29.54 290.48,32.26 286.12,32.26 282.61,35.78 278.72,35.78 278.04,36.46 278.04,38.11 275.44,40.7 274.17,40.7 268.99,45.88 245.58,45.88 243.33,48.14 227.64,48.14 227,48.78 224.17,48.78 222.93,50.03 212.3,50.03 207.23,55.1 202.58,55.1 199.32,51.84 196.2,51.84 194.5,53.55 191.08,53.55 190.08,52.54 189.18,52.54 186.8,50.16 184.04,50.16 183.19,49.31 181.09,49.31 180.09,48.31 178.96,48.31 178.26,49 174.84,49 174.38,49.47 172.95,49.47 172.85,49.57 155.17,49.57 153.71,51.03 145.49,51.03 144.03,49.57 128.68,49.57 127.39,50.85 124.34,50.85 123.68,51.52 109.28,51.52 108.08,50.32 97.61,50.32 97.1,50.83 91.89,50.83 91.07,50.01 86.31,50.01 85.61,50.71 84.71,50.71 83.14,49.15 67.4,49.15 66.08,50.47 63.94,50.47 63.32,49.85 61.33,49.85 60.91,50.27 v2(59.17,50.27)
  BOTTOM w0.102: v1(306.52,29.54) 306.52,29.42 v2(306.82,29.12)
  BOTTOM w0.107: v2(308.4,14.41) 307.71,15.1 307.71,26.15 307.35,26.52 307.35,28.59 v2(306.82,29.12)
VCOUT1_PROCHOT#: length 3
  TOP w0.107: RE85.2 309.11,13.25 RE84.2 308.5,13.81 308.3,14.01 UE5.103
VD33STB: length 3.1
  TOP w0.102: v1(36.05,30.83) 36.46,31.23 v2(36.86,31.23)
  TOP w0.107: v2(36.86,31.23) 36.86,31.02 37.29,30.59 RA25.2
  BOTTOM w0.107: v2(36.86,31.23) 36.51,31.23 36.44,31.31 UA1.10
VGA_EN: length 5.3
  BOTTOM w0.102: v1(123.5,160.28) 124.96,160.28 125.23,160.01 RM87.1 125.23,159.71 124.9,159.38 RM14.2
  BOTTOM w0.107: RM14.2 125.13,158.84 125.77,159.48 UM8.26
VGA_SMB_CK2: length 73.5
  IN1 w0.081: v2(203.3,150.4) 203.46,150.4 203.45,150.41 204.76,150.41 205.23,150.87 205.23,151.12 205.04,151.31 203.07,151.31 202.53,150.77 202.53,145.99 200.37,143.84 200.37,137.61 202.64,135.35 202.64,132.45 199.65,129.47 199.19,129.47 198.02,128.3 198.02,126.66 198.55,126.13 198.55,125.02 198.93,124.64 202.46,124.64 202.73,124.38 204.8,124.38 204.96,124.54 206.48,124.54 207.32,123.71 209.78,123.71 209.98,123.5 209.98,123.39 210.07,123.31 210.25,123.31 210.36,123.2 v2(210.36,123.04)
  IN6 w0.081: v2(210.36,123.04) 210.17,122.85 210.17,122.47 210.3,122.33 210.75,122.33 210.78,122.3 211.44,122.3 212.31,121.43 212.31,120.28 212.73,119.86 216.61,119.86 216.8,120.05 221.96,120.05 222.77,119.24 222.77,116.57 223.15,116.19 223.31,116.19 v2(223.57,116.45)
  BOTTOM w0.1: UG9.BJ8 v2(223.57,116.45)
  BOTTOM w0.114: RG17.1 208.05,124.01 208.19,124.01 208.3,123.9 208.3,123.04 208.97,122.37 209.91,122.37 210.16,122.62 210.16,122.84 v2(210.36,123.04) ; v2(203.3,150.4) 203.46,150.4 203.45,150.41 QG6.4
VGA_SMB_DA2: length 74
  IN1 w0.081: v2(209.77,123.04) 209.77,123.42 209.69,123.5 207.23,123.5 206.4,124.33 205.05,124.33 204.89,124.17 202.64,124.17 202.38,124.43 198.84,124.43 198.34,124.94 198.34,126.04 197.81,126.57 197.81,128.38 199.1,129.68 199.57,129.68 202.43,132.54 202.43,135.26 200.17,137.53 200.17,143.93 202.32,146.08 202.32,150.86 202.98,151.52 205.12,151.52 205.23,151.41 206.18,151.41 207.07,152.3 v2(207.07,152.69)
  IN6 w0.081: v2(223.57,115.75) 223.3,116.02 223.08,116.02 222.6,116.5 222.6,119.17 221.89,119.88 216.87,119.88 216.64,119.65 212.64,119.65 212.1,120.19 212.1,121.35 211.36,122.09 210.69,122.09 210.66,122.13 210.22,122.13 209.96,122.38 209.96,122.85 v2(209.77,123.04)
  BOTTOM w0.1: v2(223.57,115.75) UG9.BH8
  BOTTOM w0.114: v2(209.77,123.04) 209.92,122.89 209.92,122.72 209.81,122.61 209.07,122.61 208.54,123.14 208.54,124 208.29,124.25 208.05,124.25 RG18.1 ; v2(207.07,152.69) 207.07,151.87 206.9,151.71 QG6.1
VGND: length 6.2
  TOP w0.508: v2(23.31,56.82) 23.31,57.27 CU55.2 23,57.59 CU56.2
  IN1 w0.508: v2(23.31,56.82) 23.31,56.32 22.93,55.93 22.93,53.65 22.68,53.39 22.23,53.39 v2(22.04,53.2)
  vias: v1(22.97,50.33)
VL: length 3
  BOTTOM w0.102: v1(52.71,43.96) 53.56,43.96 PC111.1
  BOTTOM w0.203: PC111.1 53.73,44.63 53.73,44.64 53.93,44.84 53.93,45.23 53.86,45.3 PU100.13
VR_PWRGD: length 357
  TOP w0.107: UE5.101 306.12,13.21 v2(305.06,14.28)
  TOP w0.203: PU500.45 123.74,139.01 123.71,138.97 123.71,138.72 123.58,138.6 123.58,138.12 123.71,137.99 123.71,137.99 124.09,137.61 v2(124.09,137.34) 124.24,137.19 PR516.2
  IN1 w0.102: v2(125.59,21.28) 123.57,23.3 119.45,23.3 118.75,23.99 109.93,23.99 108.15,25.77 108.15,32.31 v2(107.01,33.46)
  IN2 w0.102: v2(125.59,21.28) 126.03,20.83 126.69,20.83 127.97,22.11 143.48,22.11 144.35,21.25 168.91,21.25 169.36,21.69 181.68,21.69 181.83,21.54 187.16,21.54 187.59,21.11 189.5,21.11 191.2,19.41 191.22,19.41 192.58,18.05 192.58,18.05 192.71,17.92 192.71,17.73 192.86,17.58 192.86,17.58 193.8,16.65 193.8,15.94 194.63,15.11 196.17,15.11 197.21,16.16 197.59,16.16 197.78,16.16 197.78,16.16 199.56,16.16 200.41,17.01 200.9,17.01 201.11,17.22 201.65,17.22 201.66,17.21 201.96,17.21 201.98,17.22 207.43,17.22 208.92,15.73 213.86,15.73 214.3,16.17 218.39,16.17 218.65,15.92 219.47,15.92 219.47,15.92 219.74,15.92 220.03,16.2 221.41,16.2 221.93,15.69 231.69,15.69 232.39,16.39 236.61,16.39 237.7,17.48 246.36,17.48 246.92,16.92 247.26,16.92 247.56,17.22 248.01,17.22 248.94,18.15 248.94,20.76 248.94,20.76 248.94,20.95 248.94,21.14 248.41,21.67 248.41,21.76 248.41,21.76 248.41,25.34 248.56,25.49 255.64,25.49 258.42,22.71 270.26,22.71 270.49,22.94 271.5,22.94 273.76,20.69 275.49,20.69 276.11,20.07 276.83,20.07 277.63,19.26 277.63,18.15 277.95,17.83 278.88,17.83 278.94,17.83 280.02,16.75 282.49,16.75 292.67,16.75 292.89,16.53 293.66,15.76 294.48,15.76 294.82,15.42 294.82,15.42 295.09,15.15 297.25,15.15 297.4,15.31 299.17,15.31 299.31,15.45 299.5,15.45 303.89,15.45 v2(305.06,14.28)
  IN3 w0.089: 129.44,107.01 129.44,107.77 129.49,107.82 129.49,115.41 129.44,115.45
  IN3 w0.102: 129.44,107.01 122.07,99.64 122.07,96.76 119.39,94.09 119.39,75.86 108.39,64.86 108.39,62.33 105.06,59 105.06,42.38 107.44,39.99 107.44,33.89 v2(107.01,33.46) ; 129.44,115.45 128.8,116.09 128.02,116.09 127.29,116.83 127.29,128.92 122.72,133.49 121.56,133.49 120.68,134.37 120.68,135.07 122.68,137.06 123.81,137.06 v2(124.09,137.34)
VR_SVID_ALERT#: length 18.8
  TOP w0.114: v2(123.35,134.93) 123.35,135.56 PR517.1
  IN6 w0.081: v2(123.35,134.93) 123.4,134.88 123.4,133.23 128.39,128.24 v2(128.39,121.82)
  BOTTOM w0.114: v2(123.35,134.93) 123.35,135.43 PR506.2 ; v2(128.39,121.82) 128.14,121.57 RH152.2 126.73,122.48 RH153.1
VR_SVID_CLK: length 29.8
  TOP w0.114: PR515.2 124.05,135.48 v2(124.05,134.98)
  IN6 w0.081: v2(124.05,134.98) 124.2,134.82 124.2,134.28 123.86,133.94 123.86,133.45 128.86,128.46 128.86,124.51 129.16,124.21 129.16,124.09 128.92,123.86 128.92,123.74 129.04,123.63 129.15,123.63 129.39,123.86 129.5,123.86 129.62,123.75 129.62,123.63 129.38,123.4 129.38,123.28 129.5,123.17 129.61,123.17 129.85,123.4 129.96,123.4 130.08,123.29 130.08,123.17 129.84,122.94 129.84,122.82 129.96,122.71 130.07,122.71 130.31,122.94 130.42,122.94 130.54,122.83 130.54,122.71 130.3,122.48 130.3,122.36 130.42,122.25 130.53,122.25 130.77,122.48 130.88,122.48 131.06,122.31 131.06,122.19 130.81,121.95 130.81,121.83 130.92,121.72 131.04,121.72 131.29,121.96 131.4,121.96 131.63,121.74 131.63,121.62 131.53,121.53 131.53,121.41 131.65,121.3 131.76,121.3 131.86,121.39 131.97,121.39 133.92,119.44 136.28,119.44 136.53,119.19 136.53,118.87 v2(136.92,118.48)
  BOTTOM w0.076: UC1.BH32 137.29,118.11 v2(136.92,118.48)
  BOTTOM w0.114: v2(124.05,134.98) 124.05,135.6 PR507.2
VR_SVID_DATA: length 30.8
  TOP w0.114: v2(122.67,134.95) 122.67,135.38 PR519.2
  IN6 w0.081: v2(122.67,134.95) 122.59,134.88 122.59,134.22 122.94,133.87 122.94,133.04 127.93,128.05 127.93,121.37 v2(128.29,121.01) 128.29,120.65 129.97,118.98 131.59,118.98 135.01,115.56 v2(137.43,115.56)
  BOTTOM w0.076: UC1.BH29 137.44,115.56 v2(137.43,115.56)
  BOTTOM w0.114: v2(128.29,121.01) 127.9,120.61 RH151.2 ; PR505.1 122.67,135.25 v2(122.67,134.95)
VROM_SEL: length 128.1
  TOP w0.089: RH588.2 214.75,29.95 214.7,29.9 213.21,29.9 212.99,29.67 212.99,29.31 212.78,29.11 212.35,29.11 v2(212,29.47)
  TOP w0.102: UG16.10 197.68,112.08 197.87,111.88 197.87,111.22 198.08,111.01 198.23,111.01 v2(198.64,110.61) 198.64,110.54 198.27,110.18 197.71,110.18 197.31,110.58 UG16.7 ; v2(192.85,65.19) 192.85,65.94 v1(192.99,66.08) ; v2(192.92,110.65) 193.18,110.65 193.85,109.97 RH589.2
  IN1 w0.089: v2(212,29.47) 212.15,29.62 212.15,30.86 211.66,31.34 208.93,31.34 208.46,31.81 208.46,32.26 207.89,32.83 207.32,32.83 206.79,33.35 205.9,33.35 205.23,34.03 202.14,34.03 201.93,34.25 201.93,36.95 201.49,37.38 201.49,37.43 201.06,37.87 201.06,38.4 200.87,38.59 199.88,38.59 196.55,41.91 196.55,43.22 196.15,43.63 195.37,43.63 194.19,44.8
  IN1 w0.102: v2(192.92,110.65) 193.43,110.14 198.17,110.14 v2(198.64,110.61) ; v2(192.85,65.19) 192.67,65.01 192.67,64.07 192.05,63.45 192.05,62.56 190.98,61.49 190.98,58.82 191.51,58.29 191.51,54.14 191.93,53.72 191.93,49.81 191.01,48.9 191.01,46.24 192,45.25 193.74,45.25 194.19,44.8
  IN2 w0.102: v2(192.92,110.65) 192.92,110.38 193.43,109.87 193.43,107.48 195.14,105.77 195.14,104.83 194.71,104.4 191.33,104.4 190.45,105.29 189.03,105.29 186.58,102.84 186.58,99.59 187.88,98.29 187.88,72.47 191.64,68.71 191.64,66.98 192.85,65.77 v2(192.85,65.19)
  BOTTOM w0.089: UH1.AW26 212,29.24 v2(212,29.47)
VSB_N_001: length 7
  TOP w0.127: 72.89,13.08 v1(72.89,14.15)
  TOP w0.508: PC10.2 72.34,11.69 PR12.2 72.89,13.08 72.83,13.15 PR13.2 71.7,13.52 71.45,13.77 70.94,13.77 70.44,13.27 PQ3.3
VSB_N_002: length 3.8
  TOP w0.127: v1(69.91,7.75) PQ4.2
  TOP w0.508: PR17.1 68.86,10.01 PC12.1 69.4,9.99 69.91,9.48 PQ4.2
VSB_N_003: length 1.8
  TOP w0.508: PR13.1 71.34,12.23 70.56,11.46 PQ4.1
VSENSEN_L: length 3.5
  TOP w0.203: 31.7,15.93 31.85,15.77 UA4.27
  TOP w0.508: 31.7,15.93 31.7,15.94 31.14,16.5 30.93,16.5 30.67,16.76 RA79.1 29.8,17.13 RA61.2
VSENSEN_R: length 2.8
  TOP w0.203: 29.47,13.9 29.56,13.81 UA4.30
  TOP w0.508: 29.47,13.9 29.41,13.9 29.4,13.9 RA82.1 RA65.2
VSN_1PH: length 3.6
  TOP w0.203: PU500.51 126.14,139.22 126.16,139.22 126.88,138.5 v2(126.88,138.15) PC500.2
  BOTTOM w0.102: v2(126.88,138.15) 126.88,138.28 v1(126.59,138.57)
  BOTTOM w0.203: PC500.2 v2(126.88,138.15)
VSN_2PH: length 5.3
  TOP w0.203: v2(120.44,138.9) 120.57,139.03 120.57,139.55 120.09,140.03 120.09,140.58 120.61,141.1 PU500.37
  BOTTOM w0.102: v2(120.44,138.9) v1(120.04,139.3)
  BOTTOM w0.254: v2(120.44,138.9) 120.53,138.81 PR530.1 PC514.1
VSN_4PH: length 3
  TOP w0.203: PU500.2 127.59,140.7 127.71,140.58 127.76,140.58 v2(128.14,140.2) 128.72,139.63 PC512.2
  BOTTOM w0.254: PC512.2 128.72,139.63 v2(128.14,140.2)
VSP_1PH: length 3.4
  TOP w0.203: PU500.52 126.54,139.36 127.47,138.43 v2(127.47,138.18) 127.75,137.9 PC508.2
  BOTTOM w0.254: v2(127.47,138.18) 127.75,137.9 PC508.2
VSP_2PH: length 6.6
  TOP w0.203: PR529.1 120.69,138.29 120.9,138.49 120.9,139.69 120.42,140.17 120.42,140.44 120.68,140.7 PU500.38
  TOP w0.254: PC513.1 119.69,137.62 120.36,138.29 PR529.1
VSP_4PH: length 4.5
  TOP w0.203: PU500.1 127.45,140.3 127.67,140.08 127.67,139.42 127.88,139.22 v1(127.88,138.59) 127.88,138.4 PR523.2
  TOP w0.254: PC511.2 PR523.2
VTTREF_1.2V: length 1.7
  BOTTOM w0.203: PU201.4 93.09,48.75 PC210.1
WAKE#: length 9.2
  TOP w0.089: 219.18,17.37 v2(218.98,17.37)
  TOP w0.114: RH453.1 220.71,17.95 RH4.2 219.64,17.07 219.35,17.37 219.18,17.37
  IN3 w0.089: v2(218.98,17.37) 218.98,17.45 218.4,18.02 216.99,18.02 216.04,17.07 214.15,17.07 v2(214.04,16.96)
  BOTTOM w0.089: v2(214.04,16.96) 214.04,17.73 214.38,18.07 UH1.BB47
WAKE_PCH#: length 5.3
  TOP w0.089: 219.18,20.53 219.05,20.53 v1(218.77,20.25)
  TOP w0.102: 219.18,20.53 v2(219.31,20.53) 219.31,20.2 RH545.1
  BOTTOM w0.122: UH1.BG44 216.54,20 217.06,19.48 217.21,19.34 217.9,19.34 218.28,19.72 218.77,20.2 218.77,20.22 219.01,20.22 v2(219.31,20.53)
WL_OFF#: length 170.1
  TOP w0.089: RH520.2 213.88,31.68 213.08,30.88 212.6,30.88 211.22,29.51 v2(210.13,29.51)
  TOP w0.102: RN15.2 311.86,40.63 312.24,40.25 v2(313.19,40.25)
  IN2 w0.089: v2(210.13,29.51) 210.46,29.84 211.21,29.84 212.64,31.26 214.16,31.26 215.72,32.82 216.29,32.82 216.42,32.69 216.92,32.69 217.19,32.96 217.19,33.15 217.55,33.51 217.7,33.51 217.7,33.51 218.14,33.51 218.55,33.09 219.18,33.09
  IN2 w0.102: v2(318.52,25.52) 318.52,25.58 316.2,27.91 314.16,27.91 313.04,26.79 313.04,25.4 312.17,24.54 312.17,23.41 311.8,23.04 311.49,23.04 309.66,21.21 308.21,21.21 306.16,19.16 302.48,19.16 302.24,18.92 302.24,18.55 301.7,18 300.19,18 300.19,18 299.85,18 299.85,18 297.1,18 296.46,17.36 294.36,17.36 293.54,18.18 282.92,18.18 279.43,21.67 276.77,21.67 276.15,22.29 274.22,24.22 273.48,24.22 272.61,25.09 272.61,25.84 271.42,27.03 266.49,27.03 265.82,26.36 265.25,26.36 264.93,26.67 260.6,26.67 259.98,27.3 257.67,27.3 257.18,27.79 256.82,27.79 256.47,28.14 252.41,28.14 251.78,27.51 247.99,27.51 246.03,25.56 246.03,25.23 246.03,21.1 244.79,19.85 244.79,19.41 244.5,19.13 236.67,19.13 235.86,19.93 232.86,19.93 231.72,21.07 231.72,21.52 231,22.24 230.09,22.24 230,22.15 228.73,22.15 228.72,22.16 228,22.88 228,23.73 227.18,24.56 227.18,26.18 225.88,27.48 225.88,28.07 224.8,29.15 224.8,30.69 223.87,31.61 223.53,31.61 222.05,33.09 219.18,33.09
  BOTTOM w0.107: v2(313.19,40.25) 313.63,39.81 315.69,39.81 316.38,39.12 316.38,38.04 316.88,37.54 318.09,37.54 318.63,38.08 320.36,38.08 320.75,37.69 320.75,31.87 321.37,31.25 v1(321.37,30.52) 319.61,28.76 319.61,26.6 v2(318.52,25.52)
  BOTTOM w0.122: UH1.AP24 v2(210.13,29.51)
WL_OFF#_R: length 6.7
  TOP w0.102: RN15.1 312.33,41.56 CN9.1 313.44,41.08 313.51,41.14 RN5.2 313.88,40.77 v2(314.14,40.5) 314.51,40.14 v1(315.25,40.14)
  BOTTOM w0.102: JWLAN.48 314.07,40.57 v2(314.14,40.5)
WOOFER_SEL: length 66.8
  TOP w0.102: v2(319.25,57.72) 319.56,58.03 UE10.7
  TOP w0.107: JIO.21 v2(326.78,21.66)
  IN3 w0.102: v2(319.25,57.72) 318.96,57.43 315.92,57.43 315.43,56.94 315.43,56.26 316.26,55.43 316.26,53.08 320.3,49.04 334.28,49.04 335.69,47.63 335.69,22.66 334.03,21.01 327.43,21.01 v2(326.78,21.66)
XCLK_BIASREF: length 9
  IN1 w0.381: v2(202.83,45.2) 202.79,45.17 202.79,45.11 202.54,44.86 202.38,44.7 202.38,43.87 201.41,42.89 201.36,42.89 201.02,42.56 201.02,42.51 200.99,42.47 v2(200.99,42.28)
  BOTTOM w0.152: UH1.T3 201.35,40.59
  BOTTOM w0.305: 201.35,40.59 201.35,40.76 201.36,40.77 201.36,40.79 201.58,41.01
  BOTTOM w0.381: 201.58,41.01 201.58,41.49 200.99,42.09 v2(200.99,42.28) ; RH71.2 RH590.2 202.38,44.7 202.83,45.14 v2(202.83,45.2) 202.9,45.28 v1(202.9,45.82)
XDP_HOOK0: length 11.7
  TOP w0.107: JPCMC.27 118.28,160.8 117.9,161.18 v2(117.9,161.7) 117.9,162.19 118.68,162.97 122.2,162.97 122.87,162.3 124.93,162.3 126.65,160.58 RC355.1
XDP_ITP_PMODE: length 251.4
  TOP w0.089: v2(215.02,43.62) 214.64,43.23 213.56,43.23 212.95,43.85 209.85,43.85 209.23,43.23 209.23,43.22 208.86,42.85 v2(208.86,42.79)
  TOP w0.107: JPCMC.26 117.49,161.06 117.49,162.12 118.58,163.21 122.3,163.21 122.89,162.61 124.95,162.61 126.18,161.38 v2(126.43,161.38) 126.53,161.38 126.84,161.69 127.3,161.69 128.41,160.58 RC353.2
  IN1 w0.089: 215.02,43.88 v2(215.02,43.62)
  IN1 w0.102: v2(197.75,64.95) 199.04,64.95 199.31,64.69 203.35,64.69 208.23,59.81 208.23,55.47 213.38,50.32 213.38,48.62 214.42,47.58 214.42,46.25 215.21,45.47 215.21,44.07 215.02,43.88
  IN2 w0.102: v2(126.43,161.38) 126.43,160.54 124.51,158.62 124.51,153.76 125.84,152.43 139.67,152.43 140.4,151.69 147.19,151.69 148.51,153.01 148.51,153.18 149.05,153.72 150.26,153.72 152.73,156.19 168.48,156.19 169.26,155.41 169.84,155.41 173.31,151.94 183.46,151.94 186.79,148.61 186.79,145.27 188.05,144.01 188.05,130.09 180.41,122.45 180.41,108.05 178.31,105.95 178.31,95.75 176.62,94.06 176.62,83.06 175.46,81.9 175.46,71.69 183.33,63.82 183.33,59.07 185.06,57.35 187.21,57.35 187.44,57.57 192.66,57.57 193.35,58.26 193.35,59.4 195.17,61.22 195.17,62.83 195.89,63.55 196.91,63.55 197.75,64.39 v2(197.75,64.95)
  BOTTOM w0.089: v2(208.86,42.79) 208.86,42.73 208.35,42.22 208.35,40.86 208.24,40.74 208.24,40.31 UH1.AL3
XDP_PRDY#: length 295.3
  TOP w0.089: v2(215.78,43.62) 215.78,43.15 215.69,43.06 213.48,43.06 212.87,43.67 210.18,43.67 v2(209.88,43.36)
  TOP w0.114: JPCMC.34 121.09,161.57 v2(121.37,161.85)
  IN1 w0.081: v2(209.53,55.56) 209.53,54.47 213.6,50.41 213.6,48.79 215.45,46.93 215.45,45.53 215.78,45.2 215.78,43.88
  IN1 w0.089: 215.78,43.88 v2(215.78,43.62)
  IN3 w0.127: v2(133.33,114.8) 133.68,114.45 134.63,114.45 136.33,112.74 136.33,108.34 136.07,108.08 135.36,108.08 132.9,105.62 132.73,105.45 132.73,105.45 131.92,104.64 131.92,102.14 129.73,99.95 129.73,98.84 129.6,98.71 129.6,98.22 128.23,96.85 128.23,77.18 115.78,64.73 114.36,64.73 109.08,59.44 109.08,44.09 114,39.17 114.82,39.17 115.51,38.47 v2(115.6,38.47)
  IN6 w0.081: v2(133.33,114.8) 133.33,115.29 132.07,116.54 130.04,116.54 128.42,118.16 127.58,118.16 126.92,117.5 125.97,117.5 125.66,117.81 125.66,119.97 126.35,120.67 126.35,122.88 124.34,124.9 124.34,126.51 118.62,132.23 118.62,139.64 118.99,140.01 118.99,144.1 119.29,144.41 119.29,146.35 119.07,146.58 119.07,147.13 118.96,147.24 118.96,149.74 124.84,155.62 124.84,155.98 125.03,156.17 125.03,160.22 123.08,162.17 121.69,162.17 v2(121.37,161.85) ; v2(115.6,38.47) 116.02,38.89 119.79,38.89 121.69,37 131.44,37 131.45,36.99 168.75,36.99 168.9,37.15 179.45,37.15 186.77,44.46 186.77,52.89 186.77,53.27 188.29,54.79 188.76,54.79 189.25,55.28 195.03,55.28 196.39,53.92 199.4,53.92 202.08,56.6 202.35,56.87 207.18,56.87 208.49,55.56 v2(209.53,55.56)
  BOTTOM w0.076: v2(133.33,114.8) 133.66,114.47 UC1.BP27
  BOTTOM w0.089: UH1.AM5 209.41,39.26 209.47,39.2 210.15,39.2 210.38,39.43 210.38,40.08 210.33,40.13 210.33,42.91 v2(209.88,43.36)
XDP_PREQ#: length 298.4
  TOP w0.089: v2(216.35,43.55) 216.35,42.98 215.37,41.99 214.15,41.99 213.37,41.21 209.56,41.21 208.25,39.91 v2(208.25,39.64)
  TOP w0.114: v2(120.79,161.85) 120.72,161.78 120.72,161.24 JPCMC.33
  IN1 w0.081: v2(209.15,56.01) 209.8,56.01 209.93,55.88 209.93,54.37 213.81,50.49 213.81,48.87 215.86,46.82 215.86,45.42 216.65,44.63 216.65,43.88
  IN1 w0.089: 216.65,43.88 216.65,43.85 v2(216.35,43.55)
  IN3 w0.091: v2(131.34,116.17) 131.82,115.7 132.09,115.7 132.95,114.84 132.95,106.8 130.87,104.72
  IN3 w0.127: 130.87,104.72 130.87,103.63 130.4,103.15 130.4,102.22 129.36,101.18 129.36,98.34 127.98,96.96 127.98,77.29 115.67,64.98 114.25,64.98 108.8,59.52 108.8,44.01 114.23,38.58 v2(114.82,38.58)
  IN6 w0.081: v2(120.79,161.85) 121.18,161.45 121.53,161.45 122.05,161.96 123,161.96 124.82,160.14 124.82,156.26 124.63,156.07 124.63,155.7 118.75,149.83 118.75,148.51 118.37,148.13 118.28,148.04 118.28,146.71 119.08,145.9 119.08,144.49 118.78,144.19 118.78,140.1 118.41,139.72 118.41,130.42 126.15,122.68 126.15,120.76 125.45,120.06 125.45,117.63 125.95,117.12 127.54,117.12 128.1,116.56 129.56,116.56 129.8,116.32 131.11,116.32 131.26,116.17 v2(131.34,116.17) ; v2(114.82,38.58) 115.34,39.1 119.93,39.1 121.82,37.21 131.53,37.21 131.53,37.2 168.62,37.2 168.77,37.36 179.37,37.36 186.56,44.55 186.56,52.8 186.56,53.36 188.2,55 188.67,55 189.17,55.49 195.12,55.49 196.48,54.13 199.32,54.13 201.87,56.69 201.87,56.69 202.26,57.08 207.27,57.08 208.34,56.01 v2(209.15,56.01)
  BOTTOM w0.076: RH156.2 130.09,116.45 130.98,116.45 131.26,116.17 v2(131.34,116.17) 131.71,116.54 132.07,116.54 132.25,116.36 135.28,116.36 UC1.BL30
  BOTTOM w0.122: UH1.AL2 208.74,40.31 208.74,39.94 208.44,39.64 v2(208.25,39.64)
XDP_SPI_IO2: length 14.9
  TOP w0.107: RC354.1 127.82,163.19 125.79,163.19 v1(125.68,163.3) 122.86,163.3 122.14,164.02 118.58,164.02 116.98,162.42 116.98,160.32 JPCMC.24
XDP_SPI_SI: length 272.2
  TOP w0.102: RC9.2 126.55,162.14 v2(126.36,161.96)
  TOP w0.107: JPCMC.25 117.66,160.28 117.23,160.71 117.23,162.3 118.55,163.61 122.22,163.61 122.98,162.85 126.38,162.85 RC9.2
  IN4 w0.089: 209.32,25.23 209.31,25.23 208.58,25.97 203.77,25.97 203.23,25.42 203.23,25.07 202.8,24.64 200.79,24.64 200.4,25.03 199.78,25.03 199.53,25.29 199.53,25.73 198.95,26.3 198.95,28.38 195.69,31.64 195.5,31.64 194.3,32.84 192.23,32.84 192.19,32.88 192.1,32.88
  IN4 w0.102: v2(225.29,29.91) 225.29,32.07 224.82,32.54 223.95,32.54 222.51,31.09 221.3,31.09 220.54,30.34 220.54,28.44 219.85,27.74 218.58,27.74 218.3,27.47 218.3,26.57 216.87,25.14 216.6,25.14 215.87,24.4 213.58,24.4 212.75,23.56 211.52,23.56 211.41,23.67 210.88,23.67 209.32,25.23 ; 192.1,32.88 192,32.88 190.7,34.18 188.67,34.18 188.47,33.98 188.44,33.95 187.74,33.95 187.28,34.41 187.28,37.01 186.32,37.98 186.32,41.82 183.49,44.64 183.49,45.54 183.49,45.55 183.49,46.33 180.74,49.08 180.74,50.34 179.54,51.55 179.54,52.38 178.55,53.37 178.55,55.71 177.86,56.4 177.86,60.41 178.96,61.52 178.96,70.9 180.24,72.17 180.24,73.31 180.08,73.46 180.07,73.46 179.87,73.66 177.61,73.66 175.61,75.67 175.61,94.31 178.52,97.22 178.52,107.56 177.86,108.22 177.86,113.94 178.51,114.58 178.51,117.87 180.44,119.8 180.44,121.21 180.43,121.22 180.43,121.74 180.43,121.74 180.43,122.1 180.44,122.1 180.44,123.07 187.65,130.28 187.65,144.52 186.98,145.19 186.98,147.73 184.59,150.12 172.79,150.12 172.16,150.75 167.01,150.75 160.28,157.48 152.01,157.48 148,153.47 145.83,153.47 144.86,152.5 143.31,152.5 142.05,153.76 131.8,153.76 130.75,154.81 128.15,154.81 127.2,155.76 127.2,160.15 127.42,160.37 127.42,161.46 126.92,161.96 v2(126.36,161.96)
  BOTTOM w0.107: v2(225.29,29.91) 225.29,28.44 225.21,28.35 v1(225.21,27.5) 225.21,27.33 224.24,26.36 RH1.1
XDP_TCK: length 232.3
  TOP w0.089: v2(207.37,41.85) 207.14,42.08 206.01,42.08 205.8,42.29 205.8,42.55 205.53,42.82 205.53,43.77 205.42,43.88 202.63,43.88 202.38,44.13 202.38,45.03
  TOP w0.102: v3(195.53,62.11) 195.53,62.61 v2(195.58,62.67) ; 202.38,45.03 202.38,45.49 v2(202.34,45.54)
  TOP w0.107: JPCMC.31 119.79,161.94 120.35,162.5 121.92,162.5 122.59,161.82 123.99,161.82 v2(124.28,161.53) 124.34,161.47 124.34,161.05 125.95,159.44 126.45,159.44 126.62,159.27 RC348.1
  IN2 w0.102: v2(195.58,62.67) 195.58,61.31 193.58,59.31 193.58,58.17 192.76,57.35 187.53,57.35 187.3,57.12 184.96,57.12 184.81,57.27 183.1,58.97 183.1,63.72 175.23,71.6 175.23,81.99 176.39,83.16 176.39,94.15 178.12,95.88 178.12,106.08 180.19,108.15 180.19,122.54 187.82,130.18 187.82,143.92 186.57,145.18 186.57,148.51 183.36,151.71 174.32,151.71 174.32,151.71 173.22,151.71 169.75,155.18 169.17,155.18 168.39,155.96 153.6,155.96 149.11,151.46 140.31,151.46 139.58,152.2 125.74,152.2 124.28,153.66 v2(124.28,161.53)
  IN3 w0.102: v2(202.34,45.54) 202.27,45.6 202.27,46.86 200.69,48.44 200.69,59.15 199.27,60.57 197.67,60.57 v2(195.58,62.67)
  BOTTOM w0.122: UH1.AJ3 207.38,40.08 207.38,40.95 207.37,40.95 v2(207.37,41.85)
XDP_TDI: length 263
  TOP w0.089: v2(206.16,42.44) 206.16,42.44 205.7,42.89 205.7,43.86 205.69,43.88
  TOP w0.102: JPCMC.29 119,161.41 118.75,161.66 v2(118.75,161.85) ; v2(136.16,117.78) 134.78,116.4 133.82,116.4 132.15,114.74 131.14,114.74 130.82,115.05 v3(129.28,115.05) 126.88,115.05 v2(126.6,115.33) ; 205.69,43.88 205.69,45.1 205.52,45.26 204.58,45.26 203.61,45.45 202.69,45.83 202.33,46.07 v2(201.61,46.3)
  IN2 w0.102: v2(201.61,46.3) 201.68,46.37 201.68,46.92 200.74,47.87 198.76,47.87 197.37,46.48 196.95,46.48 196.54,46.89 196.07,46.89 194.55,45.37 190.45,45.37 188.92,43.84 185.86,43.84 185.19,43.17 184.58,42.55 184.11,42.55 182.66,41.1 180.14,41.1 179.78,41.46 134,41.46 133.83,41.62 117.6,41.62 v2(116.85,42.37)
  IN3 w0.089: v2(136.16,117.78) 136.16,117.65 138.06,115.75 138.06,114.23 138.57,113.72 138.57,112.96 138.06,112.45 138.06,109.65 138.57,109.15 138.57,108.77 138.06,108.26 138.06,107.17 137.6,106.71 137.19,106.71 136.27,105.78 134.65,105.78 134.14,105.27 134.14,104.54 133.75,104.16 133.75,102.75 132.98,101.98 132.98,100.63 133.56,100.06 133.56,94.84 130.99,92.27 130.99,85.65
  IN3 w0.102: v2(116.85,42.37) 115.26,42.37 114.5,43.13 114.5,48.51 112.96,50.05 112.96,53.24 114.94,55.21 114.94,60.85 115.33,61.25 117.5,61.25 118.6,62.35 118.6,64.26 130.99,76.65 130.99,85.65
  IN6 w0.102: v2(118.75,161.85) 118.86,161.74 119.44,161.74 120.43,160.76 123.2,160.76 124.16,159.79 124.16,156.53 123.97,156.34 123.97,155.98 118.1,150.1 118.1,148.78 117.62,148.31 117.62,146.44 118.43,145.63 118.43,144.76 118.12,144.46 118.12,140.37 117.75,140 117.75,129.96 124.79,122.92 124.79,116.93 126.39,115.33 v2(126.6,115.33)
  BOTTOM w0.076: v2(136.16,117.78) 135.83,118.11 UC1.BL32
  BOTTOM w0.089: v2(206.16,42.44) 206.41,42.44 206.5,42.35 206.5,41.06 206.84,40.72 UH1.AH2
  BOTTOM w0.102: RH495.2 126.81,115.13 v2(126.6,115.33)
XDP_TDO: length 253.8
  TOP w0.089: 206.7,43.88 v2(206.7,43.42)
  TOP w0.102: 206.7,43.88 v3(206.7,44.31) 206.7,44.87 206.08,45.49 204.6,45.49 203.68,45.67 202.8,46.03 202.01,46.55 201.95,46.61 201.95,46.61 201.83,46.73 v2(201.22,46.73) ; JPCMC.35 121.41,160.76 121.87,161.22 v2(122.18,161.22)
  IN2 w0.089: 196.14,45.7 195.66,45.21 195.03,45.21 194.96,45.15 194.54,45.15
  IN2 w0.102: 196.14,45.7 196.57,46.13 197.21,46.13 197.58,45.76 199.58,45.76 200.04,46.22 200.71,46.22 v2(201.22,46.73) ; 194.54,45.15 190.55,45.15 189.01,43.61 185.96,43.61 185.42,43.07 185.42,43.07 184.63,42.28 184.17,42.28 182.76,40.87 180.04,40.87 179.69,41.23 133.9,41.23 133.74,41.39 114.44,41.39 113.33,42.5 113.33,47.08 112.57,47.83 107.98,47.83 v2(107.84,47.69)
  IN3 w0.089: v2(131.14,115.31) 131.26,115.18 131.26,115.05 131.56,114.75 132.1,114.75 132.38,114.47 132.38,107.06 130.28,104.96 130.28,104.02 129.44,103.18
  IN3 w0.102: v2(107.84,47.69) 108.05,47.9 108.05,59.83 121.87,73.65 121.87,73.84 127,78.98 127,98.92 128.42,100.33 128.42,102.15 129.44,103.18
  IN6 w0.102: v2(122.18,161.22) 123.07,161.22 124.26,160.02 124.39,159.89 124.39,156.44 124.2,156.25 124.2,155.88 118.32,150 118.32,148.69 118.19,148.55 118.19,148.55 117.85,148.21 117.85,146.53 118.66,145.72 118.66,144.67 118.35,144.36 118.35,140.27 117.98,139.9 117.98,130.16 125.02,123.12 125.02,117.45 125.78,116.7 127.36,116.7 127.93,116.13 129.39,116.13 129.63,115.9 130.26,115.9 130.59,115.56 130.88,115.56 v2(131.14,115.31)
  BOTTOM w0.076: UC1.BT28 132.03,115.55 131.38,115.55 v2(131.14,115.31) 130.72,115.72 RH496.2
  BOTTOM w0.089: 206.97,41.44 207.17,41.25 207.17,40.45 206.97,40.25 UH1.AH3
  BOTTOM w0.122: 206.97,41.44 206.97,42.04 207.08,42.14 207.08,43.05 v2(206.7,43.42)
XDP_TMS: length 290.3
  TOP w0.089: 207.1,43.88 207.1,43.19 v2(207.48,42.8)
  TOP w0.114: 207.1,43.88 207.1,44.81 206.18,45.73 204.62,45.73 203.74,45.9 202.91,46.24 202.16,46.74 201.93,46.96 201.68,46.96 200.22,48.42 200.22,52.87 202.55,55.2 202.55,58.9 v2(203.27,59.62) ; v2(119.35,162.15) JPCMC.30 ; v2(109.19,42.66) v3(109.81,42.66)
  IN3 w0.089: v2(131.71,115.12) 131.99,115.12 132.56,114.55 132.56,106.99 130.46,104.89 130.46,103.85 129.44,102.84
  IN3 w0.127: 129.44,102.84 128.66,102.05 128.66,100.23 127.47,99.04 127.47,77.5 115.46,65.49 114.04,65.49 108.29,59.73 108.29,43.56 v2(109.19,42.66)
  IN6 w0.081: v2(119.35,162.15) 120.25,161.24 121.62,161.24 122.13,161.75 122.91,161.75 124.61,160.05 124.61,156.35 124.42,156.15 124.42,155.79 118.54,149.91 118.54,148.6 118.28,148.34 118.07,148.12 118.07,146.62 118.88,145.81 118.88,144.58 118.57,144.27 118.57,140.18 118.2,139.81 118.2,130.27 125.94,122.54 125.94,120.85 125.24,120.15 125.24,117.54 125.87,116.92 127.46,116.92 128.02,116.35 129.48,116.35 129.75,116.08 130.33,116.08 130.67,115.74 131.33,115.74 131.71,115.36 v2(131.71,115.12) ; v2(203.27,59.62) 203.27,59.68 203.18,59.78 201.27,59.78 199.56,61.5 197.15,61.5 196.89,61.5 196.63,61.5 196.23,61.1 196.18,61.1 196.11,61.03 195.96,60.97 195.83,60.88 195.59,60.72 195.51,60.67 195.35,60.56 195.3,60.53 194.74,59.97 194.63,59.79 194.55,59.67 194.52,59.62 194.4,59.45 194.4,59.45 194.24,59.21 192.38,57.35 190.12,57.35 189.88,57.59 188.3,57.59 188.15,57.74 186.99,57.74 186.84,57.59 186.41,57.59 183.72,54.9 183.72,47.95 182.63,46.85 181.55,46.85 181.2,46.51 181.2,43.33 179.68,41.81 174.2,41.81 173.65,41.26 113.14,41.26 111.73,42.66 v2(109.19,42.66)
  BOTTOM w0.076: v2(131.71,115.12) 131.94,114.88 132.17,114.88 132.61,114.88 132.71,114.98 132.71,115.35 132.91,115.56 133.32,115.56 UC1.BP28
  BOTTOM w0.089: RH494.2 130.49,114.71 130.67,114.89 131.48,114.89 v2(131.71,115.12) ; UH1.AJ4 207.68,39.83 207.68,40.24 207.57,40.35 207.57,40.89 207.82,41.14 207.82,42.46 v2(207.48,42.8)
XMP1: length 156.7
  TOP w0.102: v2(104.05,52.34) 102.73,52.34 PR212.1 ; v2(121.81,21.28) v1(121.81,20.76)
  IN2 w0.089: v2(215.65,24.95) 215.27,25.33 215.27,26.22 214.86,26.63 213.57,26.63 213.18,27.02 212.43,27.02 211.69,26.28 210.57,26.28 210.45,26.15 208.92,26.15 208.5,25.73 207.29,25.73 206.99,25.44 205.93,25.44 204.69,24.2 201.42,24.2 200.48,25.14 198.97,25.14 198.08,26.03 197.11,26.03 196.48,25.39 193.24,25.39 192.93,25.7 192.93,26.03 192.92,26.04 192.92,26.15 192.16,26.91 192.16,29.29 191.87,29.57
  IN2 w0.102: v2(121.81,21.28) 123.22,22.69 123.22,23.37 130.28,30.42 184.74,30.42 185.11,30.79 190.66,30.79 191.87,29.57
  IN4 w0.102: v2(104.05,52.34) 104.05,48.83 103.26,48.04 103.26,48 103.25,47.98 103.25,32.57 104.59,31.22 104.59,27.84 106.18,26.25 106.18,22.27 107.62,20.83 121.37,20.83 v2(121.81,21.28)
  BOTTOM w0.089: UH1.BE34 215.55,24.84 v2(215.65,24.95)
XMP1-1: length 5.7
  TOP w0.102: v1(102.12,54.7) 102.28,54.54 PR212.2
  TOP w0.254: PR212.2 PC217.1 103.11,53.76 PR216.1 103.17,54.65 103.17,55.2 103.89,55.92 104.9,55.92 PQ202.2
XMP1-2: length 6.7
  TOP w0.102: PR213.2 v1(105.75,50.88)
  TOP w0.254: PQ202.6 106.87,56.51 106.12,56.51 105.57,55.96 105.57,52.86 105.75,52.68 PR213.2
XMP2: length 157.3
  TOP w0.102: PR214.1 106.32,53.33 v2(106.89,53.33) 107.15,53.08 v1(107.15,52.8)
  IN2 w0.089: 193.27,24.18 193.56,24.18 194.45,23.3 195.53,23.3 195.72,23.49 196.09,23.49 196.58,23.97 196.59,23.97 196.99,24.37 197.87,24.37 198.45,24.95 200.42,24.95 201.34,24.02 202.04,24.02 202.59,23.47 204.21,23.47 204.76,24.02 206,25.26 207.09,25.26 207.4,24.95 208.03,24.95 209.06,25.97 210.52,25.97 210.65,26.1 211.76,26.1 212.5,26.84 213.11,26.84 213.43,26.52 v2(213.43,26.03) ; 191.87,29.25 191.97,29.15 191.97,24.83
  IN2 w0.102: v2(121.13,21.28) 121.15,21.28 121.58,20.85 122.02,20.85 123.58,22.41 123.58,23.36 130.41,30.19 184.9,30.19 185.26,30.56 190.56,30.56 191.87,29.25 ; 193.27,24.18 192.6,24.18 191.97,24.82 191.97,24.83
  IN4 w0.102: v2(106.89,53.33) 106.89,52.99 107.3,52.58 107.3,51.76 103.49,47.95 103.49,32.91 104.82,31.57 104.82,28.91 106.41,27.32 106.41,22.36 107.49,21.28 v2(121.13,21.28)
  BOTTOM w0.089: UH1.BA33 213.43,25.79 v2(213.43,26.03)
