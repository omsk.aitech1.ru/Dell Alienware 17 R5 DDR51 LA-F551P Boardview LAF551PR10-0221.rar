# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EN_0.6VSP: length 5.3
  BOTTOM w0.102: PR211.1 95.88,49.63 v1(96.43,50.18)
  BOTTOM w0.203: 95.13,46.4 94.93,46.2 PU201.7
  BOTTOM w0.254: PR211.1 PR209.1 PC214.1 95.82,47.23 95.13,46.55 95.13,46.4
EN_1.2V: length 2.8
  BOTTOM w0.203: PC213.1 95.6,46.35 95.05,45.8 PU201.8
  BOTTOM w0.254: PC213.1 PR208.2
EN_+1VALWP: length 4.1
  TOP w0.254: PU300.3 242.44,20.81 241.83,20.2 v1(241.83,19.79) PR300.2 PC300.1
EN_INVPWR: length 308.4
  TOP w0.107: v2(294.01,21.61) 294.01,20.94 294.61,20.35 294.61,18.85 293.96,18.2 293.96,12.5 294.27,12.2 294.27,10.91 294.34,10.84 UE5.68
  IN4 w0.102: v2(159.5,163.73) 159.56,163.67 160.24,163.67 160.72,163.2 161.54,163.2 162.02,163.67 163.02,163.67 165.25,161.45 165.25,157.17 165.88,156.54 167.78,156.54 169.15,155.17 171.4,155.17 172.07,154.5 175.96,154.5 175.97,154.49 176.54,154.49 177.11,153.91 177.11,153.35 178.07,152.39 186.05,152.39 188.83,149.61 189.15,149.61 191.45,147.32 191.45,143.19 191.27,143.01 191.27,138.92 191.73,138.47 191.73,128.86 191.04,128.18 191.04,127.58 184.03,120.57 184.03,117.66 182.63,116.26 182.63,113.63 183.22,113.04 183.22,110.03 182.73,109.53 182.73,108.41 181.61,107.29 181.61,97.85 181.89,97.56 181.89,97.56 185.59,93.86 185.59,89.55 184.95,88.9 184.95,84.59 184.34,83.98 184.34,76.66 184.86,76.14 184.86,71.5 183.57,70.22 183.57,69.31 183.87,69.02 183.87,64.45 183.27,63.85 183.27,62.63 183.48,62.42 183.87,62.03 184.02,61.87 184.02,56.91 184.44,56.49 184.44,55.94 185.13,55.25 185.13,54.77 186.47,53.43 186.47,52.96 187.11,52.33 187.11,46.16 190.18,43.08 193.91,43.08 195.03,41.96 197.16,41.96 198.46,40.66 200.02,40.66 200.37,40.31 202.44,40.31 202.74,40.01 203.96,40.01 204.48,39.49 204.48,38.71 205.23,37.96 207.78,37.96 207.85,37.89 208.15,37.89 208.86,38.6 209.3,38.6 209.31,38.6 209.66,38.6 209.88,38.38 209.88,37.83 212.24,35.48 213.31,35.48 213.63,35.79 214.21,35.79 214.48,36.06 218.91,36.06 219.74,35.23 219.74,34.64 220.39,34 221.57,34 222.77,35.21 223.18,35.21 224.53,36.55 226.47,36.55 226.59,36.68 230.85,36.68 231.03,36.5 231.3,36.23 231.3,35.77 231.31,35.75 231.31,35.75 231.55,35.51 231.56,35.51 231.91,35.16 231.91,33.71 232.21,33.41 232.88,32.74 232.88,32.7 233.99,31.6 233.99,26.7 234.83,25.86 235.19,25.86 235.66,25.39 235.66,25.03 236.21,24.48 239.78,24.48 240.08,24.77 245.47,24.77 246.54,23.7 246.91,23.7 247.11,23.7 247.24,23.57 251.08,19.73 253.8,19.73 255.47,21.4 257.74,21.4 257.91,21.24 264.31,21.24 265.16,22.09 265.64,22.09 266.06,22.51 266.07,22.51 266.35,22.79 268.78,22.79 270.07,24.08 270.13,24.08 280.44,24.08 281.83,22.7 285.21,22.7 286.29,23.78 291.11,23.78 292.19,22.7 292.92,22.7 v2(294.01,21.61)
  IN6 w0.102: v2(159.5,163.73) 159.09,163.73 157.87,162.51 154.49,162.51 153.88,161.9 153.27,161.9 153.26,161.9 152.07,161.9 151.95,161.78 v2(150.53,161.78)
  BOTTOM w0.102: v2(150.53,161.78) 150.16,162.14 149.14,162.14 QV2.2
EN_TPLED: length 3.4
  BOTTOM w0.508: v2(204.8,7.96) 204.8,5.79 204.29,5.29 Q2410.1
  vias: v1(207.5,9.66)
EN_VCCIO: length 4.7
  BOTTOM w0.102: PR5008.1 124.58,121.13 v1(124.99,121.54)
  BOTTOM w0.254: PR5008.1 124.58,120.39 PC590.1 PR5007.2 124.19,119 PU509.11
EN_WOL#: length 436.4
  TOP w0.102: v2(319.88,52.73) 320.35,52.73 321.12,53.5 321.12,61.14 320.73,61.52 319.6,61.52 318.88,62.25 318.49,62.25 318.26,62.02 UE10.14 ; RE79.2 307.86,10.99 307.86,10.01 308.49,9.38 v2(308.49,8.8) 307.68,8.8 v1(307.5,8.63)
  IN2 w0.102: v2(190.32,68.13) 188.67,68.13 184.22,72.57 182.1,72.57 180.08,74.59 180.08,80.64 182.32,82.88 182.32,84.45 185.96,88.09 185.96,93.84 184.88,94.92 184.88,103.55 185.98,104.64 185.98,112.09 188.46,114.58 188.46,122.99 195.7,130.23 195.7,133.58 199.19,137.07 199.19,141.52 209.56,151.89 209.56,153.84 211.31,155.59 211.35,155.59 211.4,155.64 214.35,155.64 215.24,156.53 216.36,156.53 216.54,156.36 219.5,156.36 219.52,156.34 221.98,156.34 222.39,156.34 223.26,156.34 224.79,157.86 227.28,157.86 227.33,157.81 229.35,157.81 229.38,157.79 238.42,157.79 239.99,156.21 242.05,156.21 243.02,157.19 264.14,157.19 264.78,157.83 264.78,160.33 266.34,161.89 266.34,168.79 267.06,169.51 267.06,171.17 v2(266.15,172.09)
  IN3 w0.102: v2(308.49,8.8) 308.76,8.8 309.7,7.86 312.56,7.86 313.13,8.44 313.13,9.1 314.75,10.72 321.51,10.72 321.95,11.17 322.65,11.17 323.35,11.87 323.35,13.14 324.11,13.9 325.26,13.9 325.57,13.58 325.57,12.44 325.83,12.18 330.33,12.18 337.32,19.17 337.32,48.63 333.7,52.25 322.83,52.25 322.35,52.73 v2(319.88,52.73)
  IN6 w0.102: v2(190.32,68.13) 192.4,70.21 199.78,70.21 201.55,68.44 201.56,68.44 201.61,68.39 207.39,68.39 208.12,67.66 208.12,66.2 209.33,65 209.33,59.31 212,56.64 212,54.77 214.26,52.51 216.61,52.51 217.19,51.93 223.52,51.93 223.84,52.25 227.57,52.25 228.35,51.47 231.86,51.47 232.26,51.07 249.3,51.07 250.53,49.84 259.61,49.84 260.68,50.9 271.83,50.9 273.15,49.58 277.76,49.58 278.61,48.73 293.12,48.73 298.14,53.75 304.65,53.75 304.78,53.88 310.3,53.88 310.84,53.33 315.08,53.33 317.54,55.79 318.59,55.79 319.15,55.24 319.15,53.46 v2(319.88,52.73)
  BOTTOM w0.102: UL2.4 267.95,172.09 CL42.1 v2(266.15,172.09)
ENBKL: length 8.9
  TOP w0.089: UG30.5 215.97,113.52 215.72,113.26 215.08,113.26 215.02,113.33
  TOP w0.102: 215.02,113.33 v2(214.64,113.71) 214.46,113.88 v1(214.46,114.43)
  IN4 w0.089: 215.02,113.67 215.34,113.67 v2(217.45,111.56)
  IN4 w0.102: v2(214.64,113.71) 214.68,113.67 215.02,113.67
  BOTTOM w0.1: RG501.1 216.81,111.56 v2(217.45,111.56) 218.52,111.56 218.83,111.25 UG9.BB1
ENVDD: length 162.3
  TOP w0.089: 215.02,119.13 216.15,119.13 216.75,118.53 216.75,117.68 v2(216.72,117.66)
  TOP w0.102: RG151.1 195.26,113.8 196.23,114.76 197.57,114.76 198.21,115.4 198.21,116.38 199.62,117.8 203.35,117.8 204.76,116.38 208.54,116.38 209.93,117.77 v1(212.44,117.77) 213.8,119.13 215.02,119.13
  IN4 w0.102: v2(210.28,159.06) 210.7,159.06 211.84,157.92 211.84,156.97 211.85,156.97 211.85,156.63 211.35,156.14 210.77,156.14 209.81,155.17 207.4,155.17 206.64,154.41 206.64,153.47 207.01,153.1 207.24,153.1 207.48,152.86 207.48,150.29 206.64,149.45 206.64,145.75 209.85,142.54 209.85,132.86 210.85,131.86 210.85,130.24 210.57,129.97 210.57,128.66 v2(210.63,128.6) 212.4,126.84 215.72,126.84 215.91,126.84 216.67,126.08 216.67,122.26 216.63,122.22 216.63,120.37 216.57,120.31 216.57,119.35 216.57,118.57 216.57,118.57 216.57,117.81 v2(216.72,117.66)
  IN6 w0.102: 168.12,165.31 168.12,168.8 168.66,169.35 169.17,169.35 169.99,170.16 169.99,175.36 172.54,177.92 175.61,177.92 176.63,176.9 180.03,176.9 180.73,176.2 182.57,176.2 183.08,175.7 183.08,171.89 183.71,171.25 185.84,171.25 186.5,171.91 187.49,171.91 188.15,171.25 189.39,171.25 189.51,171.38 194.64,171.38 195.11,171.85 198.52,171.85 200.86,169.51 200.86,166.93 201.24,166.55 202.45,166.55 203.59,165.41 205.18,165.41 205.37,165.6 207.23,165.6 209.88,162.96 209.88,159.46 v2(210.28,159.06)
  IN6 w0.254: 168.12,165.31 168,165.19 167.98,165.19 167.7,164.91 167.7,164.89 167.15,164.34 164.09,164.34 v2(163.17,165.26)
  BOTTOM w0.089: UG9.BH3 220.06,115.14 218.51,115.14 217.94,115.71 217.94,117.21 217.5,117.66 v2(216.72,117.66)
  BOTTOM w0.102: v2(210.63,128.6) 211.16,128.07 QG506.2
  BOTTOM w0.254: v2(163.17,165.26) 163.6,165.69 UV17.4
EQA0: length 6.5
  BOTTOM w0.107: UM8.20 125.91,156.48 125.76,156.34 v1(125.76,155.43) 125.76,155.16 126.43,154.5 RM81.2 125.54,152.94 RM84.2
EQA1: length 5.1
  BOTTOM w0.107: RM70.2 RM76.2 126.88,153.43 v1(126.88,153.9) 126.88,154.55 126.11,155.32 126.11,155.79 126.3,155.98 UM8.19
EQB0: length 3.4
  BOTTOM w0.102: RM82.2 137.76,161.86 v1(137.48,161.86)
  BOTTOM w0.107: RM82.2 RM85.2 138,160.65 137.33,159.98 UM8.46
EQB1: length 5.4
  TOP w0.107: v2(137.74,162.55) 137.97,162.32 137.97,160.28 v1(137.74,160.05) v2(137.74,159.45)
  BOTTOM w0.107: v2(137.74,159.45) 137.71,159.48 UM8.47 ; v2(137.74,162.55) RM26.2 RM23.2
FB_1.0VS_VGAP: length 4
  BOTTOM w0.254: PC809.2 PR804.2 PR805.1 238.2,43.3 v1(239.07,43.3) PU800.14
FB_1.2V: length 17.1
  TOP w0.254: v2(94.9,47.12) 95.27,47.12 98.18,50.03 100.1,50.03 v1(100.52,50.45) 103.41,50.45 PR213.1 104.83,51.9 104.99,52.05 PR215.1
  BOTTOM w0.203: PR207.1 95.02,47.23 v2(94.9,47.12) 94.9,46.85 94.65,46.6 PU201.6
  BOTTOM w0.254: PR207.1 PR205.1
FB_2PH: length 12.9
  TOP w0.102: PC518.2 116.4,134.6 v1(115.99,135.02)
  TOP w0.203: PU500.34 120.61,142.3 120.45,142.14 120.08,142.14 v2(120.07,142.14)
  TOP w0.254: v2(120.07,142.14) 120.07,142.14 119.74,142.14 119.26,141.66 119.26,141.55 118.98,141.27 118.98,137.39 PR539.1 PC518.2
  BOTTOM w0.254: v2(120.07,142.14) 120.07,142.14 119.66,142.14 PC519.1 PR540.1
FB_3V: length 5.3
  BOTTOM w0.102: v1(58.11,51.87) 56.8,51.87 PR101.2
  BOTTOM w0.203: PR103.2 55.16,50.33 54.77,49.94 54.65,49.94 54.26,49.55 PU100.4
  BOTTOM w0.254: PR103.2 55.22,50.33 56.16,51.27 PR101.2
FB_4PH: length 4.8
  TOP w0.203: PU500.5 127.83,141.9 128.03,141.7 v2(128.18,141.7) 128.72,142.24 PR533.1 128.89,142.24 PR536.1
  BOTTOM w0.254: v2(128.18,141.7) 128.52,141.35 PC515.2 128.81,141.34 PC517.2
FB_5V: length 6.3
  BOTTOM w0.102: v1(48.98,51.95) 50.61,51.95 50.88,51.67 PR102.1
  BOTTOM w0.203: PR104.1 52.72,50.33 53.46,49.59 PU100.2
  BOTTOM w0.254: PR102.1 51.01,51.22 51.9,50.33 PR104.1
FB_+1.8VGS: length 12
  IN6 w0.254: v2(226.91,42.78) 224.76,42.78 223.49,44.05 220.68,44.05 v2(220.67,44.06)
  BOTTOM w0.102: PR811.1 v1(223.47,42.46)
  BOTTOM w0.254: PR811.1 222.83,43.41 PC819.2 PR810.2 221,43.73 v2(220.67,44.06) ; v2(226.91,42.78) 226.95,42.73 PU802.14
FB_+1VALWP: length 5.4
  TOP w0.254: PR307.1 PR308.1 242.12,16.95 242.39,17.21 242.39,19.99 242.7,20.31 PU300.4
FB_A_CLK0: length 35.3
  TOP w0.102: v2(274.34,101.3) 274.69,101.3 274.87,101.48 274.87,101.93 RG102.1
  IN6 w0.102: 249.88,100.64 v2(249.47,101.05)
  IN6 w0.107: v2(276.15,98.16) 276.36,98.37 276.36,98.61 276.53,98.79 276.53,99.12 275.31,100.34 275.15,100.34 274.91,100.58 274.91,100.73 v2(274.34,101.3) 274.92,101.3 275.02,101.41 275.02,101.76 274.9,101.89 272.93,101.89 272.57,101.52 263.3,101.52 263.07,101.29 258.27,101.29 258.16,101.19 258.16,101.02 257.94,100.8 257.5,100.8 257.26,101.05 257.26,101.21 257.16,101.31 255.47,101.31 255.25,101.09 253.98,101.09 253.18,100.3 250.65,100.3 250.31,100.64 249.88,100.64
  BOTTOM w0.102: UG9.AG45 v2(249.47,101.05)
  BOTTOM w0.119: v2(276.15,98.16) 276.15,97.89 276.28,97.76 UG1.J12
FB_A_CLK1: length 39.1
  TOP w0.119: v2(273.45,106.21) 273.57,106.21 273.93,105.85 273.93,105.59 RG103.1
  IN1 w0.102: v2(250.17,103.15) 250.1,103.07 250.1,102.92 250.29,102.73 253.25,102.73 253.69,103.18 253.86,103.18 254.37,103.69 254.45,103.69
  IN1 w0.107: v2(276.15,109.16) 276.35,108.96 276.35,108.81 276.54,108.62 276.54,107.59 275.89,106.93 274.95,106.93 274.62,106.61 273.84,106.61 v2(273.45,106.21) 273.98,106.21 274.09,106.11 274.09,105.91 273.8,105.62 267.04,105.62 266.93,105.72 266.93,106.32 266.71,106.54 266.23,106.54 266.01,106.32 266.01,105.72 265.9,105.62 265.58,105.62 265.47,105.72 265.47,106.32 265.25,106.54 264.77,106.54 264.55,106.32 264.55,105.72 264.44,105.62 264.07,105.62 263.96,105.72 263.96,106.39 263.74,106.61 263.26,106.61 263.03,106.39 263.03,105.72 262.93,105.62 261.4,105.62 259.47,103.69 259.39,103.69 259.39,103.69 254.45,103.69
  BOTTOM w0.102: v2(250.17,103.15) 250.11,103.09 250.11,102.87 250.19,102.79 250.41,102.79 UG9.AK46
  BOTTOM w0.119: UG2.J12 v2(276.15,109.16)
FB_A_CLK#0: length 35.1
  TOP w0.102: 275.15,101.45 275.29,101.3 v2(275.64,101.3)
  TOP w0.119: RG523.1 275.15,102.02 275.15,101.45
  IN6 w0.107: v2(250.17,101.05) 250.73,100.49 253.1,100.49 253.89,101.28 255.17,101.28 255.39,101.51 257.24,101.51 257.45,101.29 257.45,101.13 257.59,101 257.86,101 257.97,101.1 257.97,101.27 258.19,101.49 262.99,101.49 263.22,101.72 272.49,101.72 272.85,102.08 274.98,102.08 275.22,101.84 275.22,101.54 275.46,101.3 v2(275.64,101.3) 275.11,100.77 275.11,100.66 275.23,100.54 275.39,100.54 275.63,100.3 276.73,99.2 276.73,98.71 276.55,98.53 276.55,97.76 v2(276.15,97.36)
  BOTTOM w0.102: UG9.AG46 v2(250.17,101.05)
  BOTTOM w0.119: v2(276.15,97.36) UG1.J11
FB_A_CLK#1: length 39.2
  TOP w0.119: RG524.1 274.24,105.57 274.24,105.74 274.71,106.21 v2(274.75,106.21)
  IN1 w0.102: v2(249.47,103.15) 250.08,102.54 253.33,102.54 253.77,102.98 253.94,102.98 254.45,103.5
  IN1 w0.107: v2(276.15,109.96) 276.17,109.96 276.52,109.35 276.55,109.32 276.55,108.89 276.74,108.71 276.74,107.51 275.97,106.73 275.03,106.73 274.75,106.46 v2(274.75,106.21) 274.57,106.04 274.5,106.04 273.88,105.42 266.96,105.42 266.74,105.64 266.74,106.24 266.63,106.35 266.31,106.35 266.2,106.24 266.2,105.64 265.98,105.42 265.5,105.42 265.39,105.53 265.28,105.64 265.28,106.24 265.17,106.35 264.85,106.35 264.74,106.24 264.74,105.64 264.52,105.42 263.98,105.42 263.76,105.64 263.76,106.3 263.66,106.41 263.34,106.41 263.23,106.3 263.23,105.64 263.12,105.54 263.01,105.42 261.48,105.42 259.56,103.5 259.31,103.5 254.45,103.5
  BOTTOM w0.102: UG9.AK45 v2(249.47,103.15)
  BOTTOM w0.119: UG2.J11 v2(276.15,109.96)
FB_A_CMD0: length 34.9
  BOTTOM w0.102: 260.54,89.85 260.54,94.13 260.75,94.34 260.75,94.97 259.92,95.8 258.39,95.8 258.27,95.68 255,95.68 254.84,95.52 254.45,95.52 254.12,95.85 UG9.Y51
  BOTTOM w0.185: UG1.G3 277.75,90.16 277.75,88.77 277.95,88.57 277.95,88.26 277.12,87.43 276.2,87.43 275.42,86.64 269.16,86.64 268.77,86.25 264.14,86.25 260.54,89.85
FB_A_CMD1: length 32.6
  TOP w0.102: v2(276.95,90.16) 276.95,89.68 RG47.2
  BOTTOM w0.102: 261.26,92.27 260.84,92.69 260.84,93.97 260.95,94.08 260.95,95.07 259.87,96.15 258.16,96.15 257.94,95.93 254.75,95.93 UG9.Y52 ; UG1.J3 v2(276.95,90.16)
  BOTTOM w0.185: 261.26,92.27 261.26,91.04 261.76,90.54 261.76,89.84 264.52,87.08 275.32,87.08 276.14,87.89 276.68,87.89 276.97,88.19 276.97,88.54 276.95,88.56 276.95,88.75 276.95,88.76 v2(276.95,90.16)
FB_A_CMD2: length 32.2
  TOP w0.102: RG54.1 275.58,89.36 v2(276.15,89.36)
  BOTTOM w0.102: 261.7,92.34 261.17,92.87 261.17,93.7 261.15,93.71 261.15,95.27 259.97,96.45 257.93,96.45 257.68,96.2 252.92,96.2 UG9.Y49 ; v2(276.15,89.36) 276.4,89.61 276.4,89.61 UG1.J2
  BOTTOM w0.185: v2(276.15,89.36) 276.15,88.56 276.05,88.46 276.05,88.26 275.41,87.62 265.26,87.62 261.7,91.18 261.7,92.34
FB_A_CMD3: length 27.9
  BOTTOM w0.102: UG9.AA52 257.49,96.55 257.71,96.77 259.98,96.77 261.45,95.3 261.45,93.91 261.44,93.9 261.44,93.11
  BOTTOM w0.185: UG1.L3 275.35,90.16 275.35,88.76 274.72,88.13 267.15,88.13 263.55,91.73 262.82,91.73 261.44,93.11
FB_A_CMD4: length 26.2
  BOTTOM w0.102: UG9.AA51 254.17,96.55 254.5,96.88 254.82,96.88 254.88,96.82 257.24,96.82 257.58,97.16 259.88,97.16 261.76,95.28 261.76,93.52
  BOTTOM w0.185: 261.76,93.52 262.52,92.76 263.98,92.76 265.34,91.4 268.84,91.4 270.01,92.57 275.34,92.57 UG1.K5
FB_A_CMD5: length 27.8
  BOTTOM w0.102: UG9.AA50 253.42,96.55 253.77,96.9 254.17,96.9 254.37,97.1 256.98,97.1 257.36,97.48 259.86,97.48 262.07,95.27 262.07,94.31
  BOTTOM w0.185: 262.07,94.31 262.65,93.73 264.16,93.73 265.95,91.94 268.93,91.94 269.85,92.86 275.6,92.86 276.15,92.31 276.15,91.76 UG1.K4
FB_A_CMD6: length 26.8
  BOTTOM w0.102: UG9.AC50 253.62,97.6 254.12,97.6 254.37,97.35 256.73,97.35 257.22,97.84 259.9,97.84 262.44,95.3
  BOTTOM w0.185: 262.44,95.3 263.92,95.3 266.7,92.52 268.9,92.52 269.54,93.15 275.91,93.15 276.55,92.51 UG1.J5
FB_A_CMD7: length 27.4
  BOTTOM w0.102: UG9.AC51 254.12,97.95 254.47,97.6 256.44,97.6 256.98,98.14 259.94,98.14 262.24,95.84
  BOTTOM w0.185: UG1.J4 276.95,91.76 276.95,92.81 276.33,93.43 269.32,93.43 269.01,93.12 266.99,93.12 264.27,95.84 262.24,95.84
FB_A_CMD8: length 25.9
  BOTTOM w0.102: UG9.AC52 256.29,97.95 256.79,98.45 260,98.45 262.07,96.38
  BOTTOM w0.185: UG1.H5 277.35,92.86 276.49,93.72 267.28,93.72 264.61,96.38 262.07,96.38
FB_A_CMD9: length 29.7
  BOTTOM w0.102: UG9.AC49 252.92,98.3 256.17,98.3 256.63,98.76 260.22,98.76 261.71,97.27
  BOTTOM w0.185: UG1.H4 277.75,91.76 277.75,92.96 276.7,94.01 267.87,94.01 264.61,97.27 261.71,97.27
FB_A_CMD10: length 28.5
  BOTTOM w0.102: UG9.AD52 255.99,98.65 256.46,99.12 260.32,99.12 261.58,97.87
  BOTTOM w0.185: UG1.G12 277.75,97.36 277.75,95.06 276.98,94.3 268.35,94.3 264.78,97.87 261.58,97.87
FB_A_CMD11: length 26.8
  BOTTOM w0.102: UG9.AD51 254.17,98.65 254.5,98.98 254.86,98.98 254.9,98.94 255.81,98.94 256.24,99.37 260.59,99.37 261.56,98.41
  BOTTOM w0.185: 261.56,98.41 265,98.41 268.83,94.58 276.62,94.58 277.35,95.31 UG1.H10
FB_A_CMD12: length 28.4
  BOTTOM w0.102: 261.31,99.24 260.88,99.67 256.06,99.67 255.59,99.2 254.37,99.2 254.17,99 253.77,99 253.42,98.65 UG9.AD50
  BOTTOM w0.185: 261.31,99.24 265.25,99.24 267.69,96.8 267.69,96.23 269.05,94.87 276.41,94.87 276.95,95.41 276.95,96.56 UG1.H11
FB_A_CMD13: length 27.6
  BOTTOM w0.102: 262.82,99.95 256.01,99.95 255.5,99.44 254.38,99.44 254.12,99.7 253.62,99.7 UG9.AF50
  BOTTOM w0.185: UG1.K11 276.15,96.56 276.15,95.91 276.05,95.81 276.05,95.41 275.8,95.16 269.2,95.16 267.98,96.38 267.98,97.34 265.36,99.95 262.82,99.95
FB_A_CMD14: length 26
  BOTTOM w0.102: 261.34,100.89 260.82,100.37 256.08,100.37 255.42,99.7 254.47,99.7 254.12,100.05 UG9.AF51
  BOTTOM w0.185: UG1.K10 275.75,95.76 275.45,95.46 269.45,95.46 268.33,96.58 268.33,98 265.44,100.89 261.34,100.89
FB_A_CMD15: length 26.9
  BOTTOM w0.102: 261.45,101.72 260.45,100.72 256.11,100.72 255.73,100.35 255.73,100.33 255.45,100.05 UG9.AF52
  BOTTOM w0.185: UG1.L12 275.35,97.36 275.35,96.01 275.1,95.76 269.8,95.76 268.61,96.95 268.61,98.67 265.57,101.72 261.45,101.72
FB_A_CMD16: length 40.2
  BOTTOM w0.102: UG9.AN50 253.27,105.2 253.37,105.3 254.17,105.3 254.37,105.5 254.95,105.5 255,105.45 257.24,105.45 257.93,106.14 257.93,109.2
  BOTTOM w0.185: 257.93,109.2 259.09,110.36 259.09,114.48 259.53,114.93 259.53,116.07 263.28,119.82 265.95,119.82 267.73,121.59 275.47,121.59 277.85,119.21 277.85,118.66 277.72,118.53 277.72,117.19 UG2.L3
FB_A_CMD17: length 38.4
  TOP w0.102: v2(276.95,117.16) 276.98,117.14 RG48.2
  BOTTOM w0.102: UG2.J3 v2(276.95,117.16) ; UG9.AN51 254.17,104.95 254.52,105.3 254.82,105.3 254.92,105.2 257.39,105.2 258.35,106.15 258.35,108.95
  BOTTOM w0.185: 258.35,108.95 259.58,110.19 259.58,114.07 260.43,114.91 260.43,116.21 263.22,118.99 266.26,118.99 268.08,120.8 275.44,120.8 276.95,119.29 v2(276.95,117.16)
FB_A_CMD18: length 34.7
  TOP w0.102: v2(276.15,117.96) 276.12,117.99 RG53.1
  BOTTOM w0.102: 266.75,118.24 266.78,118.24 ; UG2.J2 276.37,117.74 276.37,117.74 v2(276.15,117.96) ; 258.63,108.57 258.63,106.07 257.51,104.95 UG9.AN52
  BOTTOM w0.185: 266.75,118.24 263.48,118.24 261.39,116.14 261.39,115.17 260.08,113.86 260.08,110.02 258.63,108.57 ; v2(276.15,117.96) 276.15,118.76 276.05,118.86 276.05,119.11 275.13,120.03 268.58,120.03 266.78,118.24
FB_A_CMD19: length 34.9
  BOTTOM w0.102: UG9.AM49 252.92,104.6 257.63,104.6 258.96,105.93 258.96,108.29
  BOTTOM w0.185: 258.96,108.29 260.54,109.88 260.54,113.62 264.39,117.47 267.28,117.47 269.08,119.26 274.68,119.26 275,118.95 275,118.89 275.35,118.54 275.35,117.16 UG2.G3
FB_A_CMD20: length 30.6
  BOTTOM w0.102: UG9.AM52 257.79,104.25 259.12,105.58 259.12,105.78 259.31,105.96 259.31,107.93
  BOTTOM w0.185: UG2.H5 275.32,114.74 269.98,114.74 268.02,116.7 264.47,116.7 261.14,113.37 261.14,109.76 259.31,107.93
FB_A_CMD21: length 32
  BOTTOM w0.102: 259.65,107.73 259.65,105.84 259.42,105.61 259.42,105.46 257.88,103.92 254.45,103.92 254.12,104.25 UG9.AM51
  BOTTOM w0.185: UG2.H4 276.15,115.56 276.15,115.01 275.59,114.45 269.76,114.45 268.29,115.92 265.23,115.92 261.77,112.46 261.77,109.85 259.65,107.73
FB_A_CMD22: length 31.4
  BOTTOM w0.102: 259.99,107.47 259.99,105.77 259.75,105.53 259.75,105.32 258.11,103.68 254.34,103.68 254.12,103.9 253.84,103.9 253.49,104.25 UG9.AM50
  BOTTOM w0.185: 259.99,107.47 262.47,109.95 262.47,111.58 266.05,115.15 268.56,115.15 269.55,114.16 275.95,114.16 276.55,114.76 UG2.J5
FB_A_CMD23: length 32.2
  BOTTOM w0.102: UG9.AK50 253.42,102.85 253.77,103.2 254.17,103.2 254.41,103.44 258.27,103.44 260.08,105.25 260.33,105.5 260.33,107.09
  BOTTOM w0.185: 260.33,107.09 264.06,110.82 264.06,112.09 266.36,114.38 268.83,114.38 269.34,113.87 276.36,113.87 276.95,114.46 276.95,115.56 UG2.J4
FB_A_CMD24: length 30.4
  BOTTOM w0.102: UG9.AK51 254.17,102.85 254.52,103.2 258.47,103.2 260.65,105.38 260.65,106.74
  BOTTOM w0.185: UG2.K5 277.35,114.36 276.57,113.59 266.7,113.59 264.83,111.72 264.83,110.57 262.77,108.51 262.42,108.51 260.65,106.74
FB_A_CMD25: length 31.1
  BOTTOM w0.102: 261.01,106.38 261.01,105.29 260.87,105.14 258.58,102.85 UG9.AK52
  BOTTOM w0.185: 261.01,106.38 262.38,107.74 263.08,107.74 265.61,110.27 265.61,111.6 267.31,113.3 276.84,113.3 277.75,114.21 277.75,115.56 UG2.K4
FB_A_CMD26: length 34.5
  BOTTOM w0.102: 261.44,106.06 261.44,105.24 261.21,105.01 258.7,102.5 252.92,102.5 UG9.AJ49
  BOTTOM w0.185: UG2.L12 277.75,109.96 277.75,112.06 276.8,113.01 267.56,113.01 266.77,112.23 266.77,110.04 263.71,106.97 262.35,106.97 261.44,106.06
FB_A_CMD27: length 29.8
  BOTTOM w0.102: 261.91,105.29 261.91,105.28 258.88,102.26 254.77,102.26 UG9.AJ52
  BOTTOM w0.185: 261.91,105.29 262.82,106.2 264.14,106.2 267.38,109.43 267.38,112.15 267.93,112.71 276.6,112.71 277.35,111.96 UG2.K10
FB_A_CMD28: length 31.1
  BOTTOM w0.102: 262.82,105.43 262.67,105.43 259.19,101.95 254.98,101.95 254.83,101.8 254.47,101.8 254.12,102.15 UG9.AJ51
  BOTTOM w0.185: 262.82,105.43 264.14,105.43 267.85,109.14 267.85,111.88 268.4,112.42 276.44,112.42 276.95,111.91 276.95,110.76 UG2.K11
FB_A_CMD29: length 31
  BOTTOM w0.102: UG9.AJ50 253.5,102.15 253.85,101.8 254.12,101.8 254.37,101.55 254.97,101.55 255.08,101.66 259.44,101.66 262.44,104.66 262.82,104.66
  BOTTOM w0.185: UG2.H11 276.17,110.78 276.17,111.34 276.05,111.46 276.05,111.86 275.78,112.13 268.67,112.13 268.23,111.7 268.23,108.76 264.13,104.66 262.82,104.66
FB_A_CMD30: length 29.5
  BOTTOM w0.102: UG9.AG50 253.51,100.75 253.86,101.1 254.17,101.1 254.37,101.3 255.15,101.3 255.27,101.43 256.43,101.43 256.56,101.3 259.55,101.3 262.14,103.89
  BOTTOM w0.185: 262.14,103.89 264.43,103.89 268.68,108.13 268.68,111.29 269.23,111.85 275.4,111.85 275.75,111.5 UG2.H10
FB_A_CMD31: length 29.9
  BOTTOM w0.102: 262.15,103.11 260.06,101.02 256.45,101.02 256.25,101.22 255.37,101.22 255.23,101.08 254.5,101.08 254.17,100.75 UG9.AG51
  BOTTOM w0.185: UG2.G12 275.35,109.96 275.35,111.31 275.1,111.56 269.7,111.56 269.19,111.05 269.19,107.87 264.43,103.11 262.15,103.11
FB_A_D0: length 18.9
  IN6 w0.102: v2(256.97,94.45) 257.39,94.03 262.71,94.03 262.77,93.97
  IN6 w0.13: 262.77,93.97 265.95,90.8 269.58,90.8 v2(269.75,90.96)
  BOTTOM w0.102: v2(269.75,90.96) 269.98,91.19 UG1.U4 ; UG9.U51 254.12,93.75 254.46,93.41 256.63,93.41 257.02,93.8 257.02,94.4 v2(256.97,94.45)
FB_A_D1: length 20.3
  IN6 w0.102: 262.77,92 261.67,93.1 254.87,93.1 254.62,93.35 v2(252.97,93.35)
  IN6 w0.13: v2(269.75,89.36) 265.41,89.36 262.77,92
  BOTTOM w0.102: UG1.U2 269.96,89.57 v2(269.75,89.36) ; v2(252.97,93.35) 252.92,93.4 252.45,93.4 252.1,93.75 UG9.U48
FB_A_D2: length 21.1
  IN6 w0.102: v2(257.57,94.45) 258.49,95.37
  IN6 w0.13: v2(270.55,90.96) 270.14,91.37 266.45,91.37 262.45,95.37 258.49,95.37
  BOTTOM w0.102: UG9.U50 253.48,93.75 253.83,93.4 254.12,93.4 254.34,93.18 256.8,93.18 257.44,93.82 257.57,93.95 v2(257.57,94.45) ; UG1.T4 270.95,91.36 v2(270.55,90.96)
FB_A_D3: length 23.8
  IN6 w0.102: 256.69,95.69 255.63,94.62 255.63,94.11 v2(255.62,94.1)
  IN6 w0.13: 256.69,95.69 263.85,95.69 267.53,92 269.44,92 269.63,92.19 270.71,92.19 270.94,91.96 270.94,90.56 v2(270.55,90.16)
  BOTTOM w0.102: UG1.T2 270.95,89.76 v2(270.55,90.16) ; UG9.U49 252.92,94.1 254.87,94.1 254.96,94.01 255.53,94.01 v2(255.62,94.1)
FB_A_D4: length 26.4
  IN6 w0.102: 262.77,90.41 261.44,91.75 ; 259.17,91.75 v2(258.57,92.35)
  IN6 w0.13: 261.44,91.75 259.17,91.75 ; v2(273.75,90.96) 274.15,90.56 274.15,88.26 273.23,87.34 265.85,87.34 262.77,90.41
  BOTTOM w0.102: UG1.N4 v2(273.75,90.96) ; v2(258.57,92.35) 258.19,92.73 254.55,92.73 254.17,92.35 UG9.R51
FB_A_D5: length 22.7
  IN6 w0.102: v2(259.22,92.35) 259.51,92.64 261.34,92.64 262.77,91.21
  IN6 w0.13: v2(272.95,89.36) 272.54,88.96 268.76,88.96 268.6,88.8 265.18,88.8 262.77,91.21
  BOTTOM w0.102: v2(259.22,92.35) 259.22,92.4 258.68,92.94 254.41,92.94 254.17,92.7 253.77,92.7 253.42,92.35 UG9.R50 ; UG1.N2 v2(272.95,89.36)
FB_A_D6: length 31.7
  IN6 w0.102: 262.77,89.62 261.09,91.3 ; 251.28,92.24 v2(250.87,92.65)
  IN6 w0.13: 261.09,91.3 258.38,91.3 257.87,91.81 254.96,91.81 254.53,92.24 251.28,92.24 ; v2(274.55,90.96) 275.01,90.5 275.01,87.36 274.3,86.66 265.74,86.66 262.77,89.62
  BOTTOM w0.102: UG1.M4 274.33,91.18 274.33,91.18 v2(274.55,90.96) ; UG9.R47 v2(250.87,92.65)
FB_A_D7: length 26
  IN6 w0.102: 262.77,93.08 262.32,93.53 255.01,93.53 254.63,93.91 251.23,93.91 v2(250.77,93.45)
  IN6 w0.13: 262.77,93.08 265.81,90.04 268.44,90.04 268.72,89.76 273.35,89.76 v2(273.75,89.36)
  BOTTOM w0.102: UG1.M2 274.15,89.76 v2(273.75,89.36) ; UG9.U46 v2(250.77,93.45)
FB_A_D8: length 23.5
  IN1 w0.13: v2(269.5,97.61) 269.1,97.61 268.5,98.22 262.64,98.22 262.2,97.78 258.71,97.78 257.77,96.84 254.48,96.84 253.72,96.07 250.08,96.07 249.81,95.8 249.81,95.13 v2(250.18,94.76)
  BOTTOM w0.102: UG9.V46 250.47,94.47 v2(250.18,94.76) ; UG1.U11 v2(269.5,97.61)
FB_A_D9: length 23.3
  IN1 w0.13: v2(249.37,95.45) 249.37,95.93 249.84,96.41 253.45,96.41 254.51,97.47 257.51,97.47 258.33,98.29 261.76,98.29 262.43,98.96 v2(269.75,98.96)
  BOTTOM w0.102: UG1.U13 v2(269.75,98.96) ; UG9.Y45 v2(249.37,95.45)
FB_A_D10: length 21.3
  IN1 w0.13: v2(270.55,97.36) 270.33,97.15 268.81,97.15 268.3,97.65 262.77,97.65 262.2,97.08 258.79,97.08 257.9,96.19 254.61,96.19 254.17,95.75 251.88,95.75 v2(251.57,95.45)
  BOTTOM w0.102: UG1.T11 v2(270.55,97.36) ; UG9.Y47 v2(251.57,95.45)
FB_A_D11: length 26.1
  IN1 w0.13: v2(270.55,98.96) 270.95,98.56 270.95,96.26 270.82,96.13 268.27,96.13 267.76,96.64 259.22,96.64 258.19,95.61 254.75,95.61 253.48,94.34 251.42,94.34 251.15,94.61 251.15,95.13 v2(250.8,95.49)
  BOTTOM w0.102: UG9.Y46 250.47,95.82 v2(250.8,95.49) ; UG1.T13 v2(270.55,98.96)
FB_A_D12: length 23.1
  IN1 w0.13: v2(272.95,97.36) 272.95,97.16 272.55,96.76 272.55,96.26 271.21,94.92 268.26,94.92 267.82,95.37 259.85,95.37 259.48,95 259.48,94.54 v2(259.51,94.51)
  BOTTOM w0.102: v2(259.51,94.51) 258.91,95.11 254.48,95.11 254.17,94.8 253.84,94.8 253.49,94.45 UG9.V50 ; UG1.N11 v2(272.95,97.36)
FB_A_D13: length 26.9
  IN1 w0.13: v2(250.77,94.85) 250.87,94.75 250.87,94.19 251.22,93.84 253.85,93.84 254.92,94.91 258.32,94.91 259.47,96.07 267.73,96.07 268.17,95.62 271.13,95.62 271.75,96.24 271.75,96.76 271.95,96.96 272.35,96.96 272.55,97.16 272.55,97.76 v2(272.95,98.16)
  BOTTOM w0.102: UG9.V47 v2(250.77,94.85) ; UG1.N13 v2(272.95,98.16)
FB_A_D14: length 22.9
  IN1 w0.13: v2(273.75,97.36) UG1.M11 274.15,96.26 271.39,93.5 261.1,93.5 260.83,93.78 258.77,93.78 258.58,93.97 256.55,93.97 v2(256.47,94.05)
  BOTTOM w0.102: UG1.M11 v2(273.75,97.36) ; UG9.U52 254.74,93.68 256.1,93.68 v2(256.47,94.05)
FB_A_D15: length 24.2
  IN1 w0.13: v2(273.75,98.96) 273.35,98.56 273.35,96.29 271.2,94.14 262.77,94.14 262.73,94.1 259.17,94.1 v2(258.77,94.5)
  BOTTOM w0.102: v2(258.77,94.5) 258.41,94.86 254.58,94.86 254.17,94.45 UG9.V51 ; v2(273.75,98.96) UG1.M13
FB_A_D16: length 46
  IN1 w0.13: v2(284.01,96.67) 285.33,97.99 285.33,101.26 281.95,104.64 261.63,104.64 259.95,102.96 255.07,102.96 254.35,102.24 249.16,102.24 248.77,101.85 v2(248.77,101.8)
  BOTTOM w0.102: v2(284.01,96.67) 283.67,97.01 283,97.01 UG1.A11 ; v2(248.77,101.8) 248.77,101.85 UG9.AJ44
FB_A_D17: length 35.7
  IN1 w0.13: v2(283.3,98.96) 282.98,99.28 282.98,100.49 280.52,102.95 262.54,102.95 262.5,103 260.9,101.4 256.83,101.4 255.81,100.38 255.3,100.38 v2(255.17,100.51)
  BOTTOM w0.102: v2(283.3,98.96) 283.3,98.91 UG1.A13 ; UG9.AG48 252.21,100.41 255.08,100.41 v2(255.17,100.51)
FB_A_D18: length 45.9
  IN1 w0.13: v2(249.47,101.85) 249.08,101.46 249.08,100.84 249.3,100.62 251.63,100.62 251.92,100.91 252.16,100.91 253.01,101.76 254.76,101.76 255.35,102.35 260.36,102.35 262.08,104.08 281.71,104.08 284.43,101.37 284.43,98.17 283.59,97.33 283.32,97.33 v2(282.55,96.56)
  BOTTOM w0.102: UG9.AJ45 v2(249.47,101.85) ; UG1.B11 v2(282.55,96.56)
FB_A_D19: length 37.8
  IN1 w0.13: v2(282.55,98.16) 282.8,98.41 283.47,98.41 283.83,98.77 283.83,100.98 281.3,103.52 262.41,103.52 260.77,101.87 255.75,101.87 254.83,100.95 253.02,100.95 252.92,101.05 v2(252.87,101.05)
  BOTTOM w0.102: v2(252.87,101.05) UG9.AG49 ; UG1.B13 v2(282.55,98.16)
FB_A_D20: length 34.5
  IN1 w0.13: v2(280.15,97.36) 279.74,96.96 279.51,96.96 279.19,96.96 279.18,96.96 278.86,96.96 277.98,97.84 277.98,97.93 275.72,100.19 269.01,100.19 268.6,99.78 262.42,99.78 261.63,98.99 258.09,98.99 257.15,98.05 251.17,98.05 v2(250.17,99.05)
  BOTTOM w0.102: UG9.AF46 250.47,99.35 v2(250.17,99.05) ; v2(280.15,97.36) UG1.E11
FB_A_D21: length 34.3
  IN1 w0.13: v2(250.87,99.75) 250.87,99.91 251.11,100.15 252.11,100.15 252.36,100.4 253.86,100.4 254.45,99.81 256.42,99.81 257.35,100.74 260.97,100.74 262.62,102.39 278.24,102.39 279.75,100.88 279.75,99.4 279.35,98.99 v2(279.35,98.96)
  BOTTOM w0.102: v2(250.87,99.75) UG9.AF47 ; UG1.E13 279.75,98.56 v2(279.35,98.96)
FB_A_D22: length 33.2
  IN1 w0.13: v2(279.35,97.36) 278.95,97.76 278.95,99.13 278.71,99.37 278.39,99.37 277.99,99.76 277.99,101.29 277.45,101.83 263.2,101.83 261.51,100.13 257.51,100.13 256.61,99.23 254.24,99.23 253.72,99.75 252.14,99.75 v2(252.06,99.67)
  BOTTOM w0.102: v2(279.35,97.36) UG1.F11 ; v2(252.06,99.67) UG9.AF48
FB_A_D23: length 30.8
  IN1 w0.13: v2(250.87,98.95) 251.29,98.53 253.22,98.53 253.32,98.63 256.78,98.63 257.68,99.53 261.41,99.53 262.3,100.42 268.44,100.42 268.78,100.75 275.95,100.75 276.25,100.46 276.61,100.46 276.81,100.27 276.81,99.81 277.22,99.4 277.92,99.4 278.35,98.96 v2(278.55,98.96)
  BOTTOM w0.102: UG1.F13 v2(278.55,98.96) ; v2(250.87,98.95) UG9.AD47
FB_A_D24: length 35.9
  IN6 w0.102: 254.37,99.58 253.58,98.79 253.03,98.79 v2(252.87,98.95)
  IN6 w0.13: v2(283.35,91.76) 283.35,92.54 280.71,95.18 277.71,95.18 276.78,96.11 269.58,96.11 265.68,100.01 262.87,100.01 262.44,99.58 254.37,99.58
  BOTTOM w0.102: UG9.AD49 v2(252.87,98.95) ; UG1.A4 v2(283.35,91.76)
FB_A_D25: length 39.6
  IN6 w0.102: 262.77,100.57 262.52,100.57 ; 253.88,100.07 253.62,99.81 253.03,99.81 252.27,99.05 252.09,99.05 v2(252.07,99.03)
  IN6 w0.13: 262.52,100.57 262.01,100.07 253.88,100.07 ; 262.77,100.57 265.98,100.57 269.59,96.96 277.5,96.96 278.35,96.11 280.75,96.11 283.8,93.06 283.8,90.61 v2(283.35,90.16)
  BOTTOM w0.102: v2(252.07,99.03) UG9.AD48 ; v2(283.35,90.16) 282.95,89.76 UG1.A2
FB_A_D26: length 37
  IN6 w0.102: v2(250.77,97.65) 250.89,97.65 251.65,98.41 254.02,98.41 254.73,99.12
  IN6 w0.13: 254.73,99.12 262.67,99.12 262.92,99.37 265.53,99.37 269.37,95.53 275.98,95.53 276.93,94.58 280.34,94.58 282.15,92.77 282.15,92.16 v2(282.55,91.76)
  BOTTOM w0.102: v2(250.77,97.65) UG9.AC46 ; v2(282.55,91.76) 282.31,91.52 282.31,91.52 UG1.B4
FB_A_D27: length 36.7
  IN6 w0.102: 254.93,98.56 254.43,98.06 251.88,98.06 v2(251.47,97.65)
  IN6 w0.13: 254.93,98.56 265.54,98.56 269.12,94.99 275.44,94.99 276.41,94.02 279.55,94.02 281.2,92.37 281.2,91.73 281.57,91.36 281.95,91.36 282.15,91.16 282.15,90.56 v2(282.55,90.16)
  BOTTOM w0.102: v2(251.47,97.65) UG9.AC47 ; v2(282.55,90.16) 282.15,89.76 UG1.B2
FB_A_D28: length 34.8
  IN6 w0.102: v2(250.87,96.85) 251.24,96.48 253.69,96.48 255.16,97.95
  IN6 w0.13: v2(279.35,90.96) UG1.E4 279.75,92.86 279.1,93.51 275.97,93.51 275.04,94.44 268.87,94.44 265.31,98 262.42,98 262.37,97.95 255.16,97.95
  BOTTOM w0.102: v2(279.35,90.96) 279.59,91.2 UG1.E4 ; UG9.AA47 v2(250.87,96.85)
FB_A_D29: length 35.4
  IN6 w0.102: 255.68,97.39 254.48,96.19 250.65,96.19 250.17,96.67 v2(250.17,96.85)
  IN6 w0.13: 255.68,97.39 262.25,97.39 262.3,97.44 265.08,97.44 268.68,93.84 274.77,93.84 275.63,92.98 278.78,92.98 278.95,92.81 278.95,90.56 v2(279.35,90.16)
  BOTTOM w0.102: UG9.AA46 v2(250.17,96.85) ; v2(279.35,90.16) 279.6,89.91 279.6,89.91 UG1.E2
FB_A_D30: length 33.3
  IN6 w0.102: 255.94,96.82 254.88,95.76 251.86,95.76 251.71,95.91 250.06,95.91 249.47,96.5 v2(249.47,96.85)
  IN6 w0.13: v2(278.55,91.76) 278.09,92.22 275.59,92.22 274.58,93.23 268.49,93.23 264.85,96.88 262.18,96.88 262.13,96.82 255.94,96.82
  BOTTOM w0.102: UG9.AA45 v2(249.47,96.85) ; UG1.F4 v2(278.55,91.76)
FB_A_D31: length 35.4
  IN6 w0.102: 256.41,96.4 254.35,94.34 249.36,94.34 249.06,94.64 249.06,95.19 248.77,95.48 v2(248.77,95.55)
  IN6 w0.13: 256.41,96.4 262.06,96.4 262.2,96.26 264.68,96.26 268.32,92.61 274.39,92.61 275.39,91.61 277.7,91.61 278.15,91.16 278.15,90.56 v2(278.55,90.16)
  BOTTOM w0.102: v2(278.55,90.16) 278.76,89.95 278.76,89.95 UG1.F2 ; UG9.Y44 v2(248.77,95.55)
FB_A_D32: length 20.2
  IN1 w0.13: v2(269.75,116.36) 269.73,116.38 262.08,116.38 257.77,112.07 257.28,112.07 256.54,111.33 256.54,110.45 255.11,109.02 254.7,109.02 v2(254.27,109.45)
  BOTTOM w0.102: UG2.A4 269.96,116.15 v2(269.75,116.36) ; UG9.AW51 v2(254.27,109.45)
FB_A_D33: length 20
  IN1 w0.13: v2(269.75,117.96) 269.6,118.11 266.99,118.11 266.98,118.12 266.04,118.12 266.03,118.11 260.49,118.11 255.6,113.22 255.6,111.3 255.58,111.28 255.58,111.27 255.17,110.85 v2(254.97,110.85)
  BOTTOM w0.102: UG9.BA52 v2(254.97,110.85) ; v2(269.75,117.96) 269.98,117.73 UG2.A2
FB_A_D34: length 21.6
  IN1 w0.13: v2(270.55,116.36) 270.01,115.82 262.97,115.82 257.42,110.27 257.09,110.27 255.45,108.63 254.28,108.63 253.57,109.35 v2(253.57,109.45)
  BOTTOM w0.102: UG2.B4 270.78,116.13 270.78,116.14 v2(270.55,116.36) ; UG9.AW50 v2(253.57,109.45)
FB_A_D35: length 21.4
  IN1 w0.13: v2(254.27,110.25) 254.46,110.44 255.7,110.44 256.03,110.77 256.03,111.51 256.41,111.89 256.41,112.67 256.83,113.09 257.27,113.09 261.74,117.56 262.53,117.56 262.54,117.55 266.26,117.55 266.27,117.56 270.14,117.56 v2(270.55,117.96)
  BOTTOM w0.102: UG2.B2 v2(270.55,117.96) ; UG9.BA51 v2(254.27,110.25)
FB_A_D36: length 29.9
  IN1 w0.13: v2(273.75,116.36) 273.34,116.77 273.34,119.07 272.24,120.17 260.29,120.17 253.62,113.5 253.62,112.28 253.12,111.78 253.12,111.3 v2(253.57,110.85)
  BOTTOM w0.102: UG9.BA50 v2(253.57,110.85) ; v2(273.75,116.36) 273.51,116.12 273.51,116.12 UG2.E4
FB_A_D37: length 25.1
  IN1 w0.13: v2(272.95,117.96) 272.55,118.36 272.55,118.98 272.05,119.48 260.69,119.48 254.4,113.19 254.4,112.38 v2(253.57,111.55)
  BOTTOM w0.102: UG9.BB50 v2(253.57,111.55) ; v2(272.95,117.96) 273.35,117.56 UG2.E2
FB_A_D38: length 34.6
  IN1 w0.13: v2(252.27,110.85) 251.87,111.25 251.87,112.7 252.03,112.86 252.03,113.91 259.85,121.73 272.54,121.73 275.03,119.24 275.03,116.84 v2(274.55,116.36)
  BOTTOM w0.102: v2(274.55,116.36) 274.32,116.14 UG2.F4 ; UG9.BA49 v2(252.27,110.85)
FB_A_D39: length 31.8
  IN1 w0.13: v2(252.27,109.45) 252.27,110.2 252.73,110.66 252.73,112.98 252.9,113.15 252.9,113.81 259.91,120.82 272.49,120.82 274.14,119.17 274.14,118.93 274.14,118.36 v2(273.75,117.96)
  BOTTOM w0.102: v2(273.75,117.96) UG2.F2 ; UG9.AW49 v2(252.27,109.45)
FB_A_D40: length 20.5
  IN6 w0.102: v2(252.17,108.15) 253.03,109.01 256.02,109.01 258.4,111.39
  IN6 w0.13: v2(269.75,109.96) 268.32,111.39 258.4,111.39
  BOTTOM w0.102: UG2.A11 269.95,110.16 v2(269.75,109.96) ; UG9.AV48 v2(252.17,108.15)
FB_A_D41: length 19.6
  IN6 w0.102: 258.73,109.9 257.01,108.17 254.45,108.17 253.55,107.27 252.95,107.27 v2(252.87,107.35)
  IN6 w0.13: v2(269.75,108.36) 269.34,108.36 267.8,109.9 258.73,109.9
  BOTTOM w0.102: UG9.AT49 v2(252.87,107.35) ; UG2.A13 269.99,108.6 v2(269.75,108.36)
FB_A_D42: length 24.9
  IN6 w0.102: v2(250.87,107.35) 251.36,106.86 254.37,106.86 255.25,107.74 257.47,107.74 259.04,109.31
  IN6 w0.13: 259.04,109.31 267.63,109.31 269,107.94 269.84,107.94 269.89,107.99 270.36,107.99 270.39,107.97 270.71,107.97 270.94,108.2 270.94,109.57 v2(270.55,109.96)
  BOTTOM w0.102: UG9.AT47 v2(250.87,107.35) ; UG2.B11 270.95,110.36 v2(270.55,109.96)
FB_A_D43: length 22
  IN6 w0.102: 258.61,110.56 256.72,108.67 253.49,108.67 v2(252.17,107.35)
  IN6 w0.13: 258.61,110.56 268.46,110.56 269.45,109.57 269.94,109.57 270.14,109.36 270.14,109.33 270.14,109.33 270.14,109 270.14,108.99 270.14,108.77 v2(270.55,108.36)
  BOTTOM w0.102: v2(270.55,108.36) 270.95,108.76 UG2.B13 ; UG9.AT48 v2(252.17,107.35)
FB_A_D44: length 27
  IN6 w0.102: v2(250.17,107.35) 251.02,106.5 255.31,106.5 255.65,106.84 258.15,106.84 260.03,108.72
  IN6 w0.13: v2(272.95,109.96) 272.55,109.56 272.55,109.01 272.54,109.01 272.54,109 272.31,108.77 272.3,108.77 272.29,108.76 271.99,108.76 271.75,108.53 271.75,108.1 271.41,107.76 270.83,107.76 270.81,107.74 270.29,107.74 270.27,107.76 269.99,107.76 269.94,107.71 268.45,107.71 267.44,108.72 260.03,108.72
  BOTTOM w0.102: UG9.AT46 v2(250.17,107.35) ; UG2.E11 v2(272.95,109.96)
FB_A_D45: length 28.7
  IN6 w0.13: v2(257.14,113.92) 257.66,113.4 269.81,113.4 270.96,112.25 272.21,112.25 273.35,111.11 UG2.E13 v2(273.75,108.36)
  BOTTOM w0.102: UG9.AV51 254.12,108.45 254.47,108.1 254.87,108.1 255.92,109.15 255.92,110.3 256.26,110.63 256.26,112.39 256.8,112.93 257.14,113.27 v2(257.14,113.92) ; UG2.E13 v2(273.75,108.36)
FB_A_D46: length 27.8
  IN6 w0.13: v2(257.92,114.68) 258.1,114.5 262.92,114.5 262.94,114.48 269.66,114.48 271.23,112.91 272.35,112.91 274.14,111.12 274.14,110.36 v2(273.75,109.96)
  BOTTOM w0.102: UG2.F11 273.95,110.16 v2(273.75,109.96) ; UG9.AV52 254.87,108.45 255.62,109.2 255.62,110.42 255.99,110.78 255.99,113.57 257.1,114.68 v2(257.92,114.68)
FB_A_D47: length 33
  IN6 w0.13: v2(274.55,108.36) 274.95,108.76 274.95,111.11 272.24,113.82 271.28,113.82 269.73,115.37 258.91,115.37 v2(258.76,115.52)
  BOTTOM w0.102: UG2.F13 274.3,108.61 v2(274.55,108.36) ; UG9.AV49 252.92,108.8 254.87,108.8 255.37,109.3 255.37,110.89 255.63,111.16 255.63,113.66 257.49,115.52 v2(258.76,115.52)
FB_A_D48: length 41.3
  IN6 w0.102: v2(252.17,101.85) 252.33,102.01 258.4,102.01 258.44,101.97 260.29,101.97 260.72,102.39 262.77,102.39
  IN6 w0.13: 262.77,102.39 272.27,102.39 272.59,102.71 280.34,102.71 281.77,104.14 284.12,104.14 284.98,105 284.98,109.29 284.31,109.96 v2(283.35,109.96)
  BOTTOM w0.102: v2(283.35,109.96) 283.12,110.19 283.12,110.19 UG2.U11 ; v2(252.17,101.85) UG9.AJ48
FB_A_D49: length 37.9
  IN6 w0.102: v2(250.77,101.85) 251.65,102.73 254.14,102.73 254.44,103.04 259.77,103.04 260.57,103.83 262.77,103.83
  IN6 w0.13: v2(283.35,108.36) 283.8,107.91 283.8,106.73 283.25,106.18 282.04,106.18 281.99,106.13 281.98,106.13 279.68,103.83 262.77,103.83
  BOTTOM w0.102: v2(250.77,101.85) UG9.AJ46 ; UG2.U13 v2(283.35,108.36)
FB_A_D50: length 41
  IN6 w0.102: v2(251.47,101.85) 252.02,102.4 260.03,102.4 260.9,103.27 262.77,103.27
  IN6 w0.13: v2(282.55,109.96) 282.94,109.57 283.5,109.57 283.51,109.56 283.51,109.56 283.74,109.33 283.74,109.32 284.42,108.64 284.42,105.52 283.67,104.77 281.51,104.77 280.01,103.27 262.77,103.27
  BOTTOM w0.102: v2(251.47,101.85) UG9.AJ47 ; v2(282.55,109.96) 282.34,110.17 UG2.T11
FB_A_D51: length 33.6
  IN6 w0.102: v2(253.02,103.3) 253.1,103.3 253.13,103.27 254.15,103.27 254.38,103.5 259.54,103.5 260.43,104.39 262.77,104.39
  IN6 w0.13: v2(282.55,108.36) 282.15,107.97 282.15,106.62 281.89,106.36 281.35,106.36 279.39,104.39 262.77,104.39
  BOTTOM w0.102: v2(282.55,108.36) UG2.T13 ; UG9.AK49 v2(253.02,103.3)
FB_A_D52: length 35.2
  IN6 w0.102: 262.77,105.23 260.57,105.23 259.27,103.93 254.28,103.93 253.96,104.25 251.77,104.25 v2(251.47,103.95)
  IN6 w0.13: v2(280.15,109.96) 280.55,109.56 280.55,106.57 278.93,104.95 263.05,104.95 262.77,105.23
  BOTTOM w0.102: UG2.N11 v2(280.15,109.96) ; UG9.AM47 v2(251.47,103.95)
FB_A_D53: length 33.2
  IN6 w0.102: 262.77,105.79 260.43,105.79 259.2,104.56 251.38,104.56 250.72,103.9 v2(250.72,103.85)
  IN6 w0.13: 262.77,105.79 278.97,105.79 279.75,106.57 279.75,107.96 v2(279.35,108.36)
  BOTTOM w0.102: UG9.AM46 250.72,104 v2(250.72,103.85) ; v2(279.35,108.36) 279.63,108.64 279.63,108.64 UG2.N13
FB_A_D54: length 31.6
  IN6 w0.102: 262.77,106.43 260.05,106.43 258.67,105.05 254.01,105.05 253.88,104.91 253.09,104.91 253.03,104.86 252.56,104.86 v2(252.17,105.25)
  IN6 w0.13: 262.77,106.43 269.55,106.43 269.89,106.09 269.9,106.09 269.92,106.06 272.51,106.06 273.09,106.64 276.3,106.64 277.62,107.96 278.79,107.96 278.95,108.12 278.95,109.56 v2(279.35,109.96)
  BOTTOM w0.102: UG2.M11 v2(279.35,109.96) ; v2(252.17,105.25) UG9.AN48
FB_A_D55: length 29.6
  IN6 w0.102: v2(252.87,105.25) 253.72,105.25 253.98,105.51 258.43,105.51 259.91,106.99 262.77,106.99
  IN6 w0.13: 262.77,106.99 269.32,106.99 269.75,106.56 269.75,106.55 269.99,106.32 269.99,106.32 270.02,106.29 271.9,106.29 272.16,106.55 272.15,106.55 272.15,107.53 272.39,107.76 272.39,107.76 272.51,107.88 276.36,107.88 277.38,108.89 278.02,108.89 v2(278.55,108.36)
  BOTTOM w0.102: UG2.M13 v2(278.55,108.36) ; v2(252.87,105.25) UG9.AN49
FB_A_D56: length 41.9
  IN1 w0.102: v2(248.77,103.95) 248.81,103.95 249.37,104.51 251.85,104.51 251.91,104.45 253.82,104.45 254.01,104.64
  IN1 w0.13: 254.01,104.64 258.39,104.64 265.05,111.3 276.72,111.3 277.98,112.56 281.31,112.56 283.11,114.36 283.11,115.8 v2(282.55,116.36)
  BOTTOM w0.102: UG2.U4 v2(282.55,116.36) ; UG9.AM44 v2(248.77,103.95)
FB_A_D57: length 43.7
  IN1 w0.102: 253.72,104.23 253.69,104.26 251.83,104.26 251.77,104.32 249.82,104.32 249.47,103.97 v2(249.47,103.95)
  IN1 w0.13: v2(282.55,117.96) UG2.U2 282.95,116.91 283.55,116.31 283.55,113.91 281.65,112.01 278.28,112.01 276.73,110.46 274.9,110.46 274.8,110.36 264.91,110.36 258.78,104.23 253.72,104.23
  BOTTOM w0.102: UG9.AM45 v2(249.47,103.95) ; UG2.U2 282.95,117.56 v2(282.55,117.96)
FB_A_D58: length 39.3
  IN1 w0.102: 253.89,105.01 253.52,104.64 251.99,104.64 251.93,104.7 250.2,104.7 250.02,104.88 250.02,104.88 249.8,105.1 249.8,105.1 249.65,105.25 v2(249.47,105.25)
  IN1 w0.13: v2(282.55,115.56) 282.15,115.16 282.15,114.43 280.87,113.15 277.01,113.15 275.86,112 264.93,112 257.95,105.02 253.9,105.02 253.89,105.01
  BOTTOM w0.102: v2(249.47,105.25) UG9.AN45 ; UG2.T4 v2(282.55,115.56)
FB_A_D59: length 41.5
  IN1 w0.102: v2(250.17,105.25) 249.85,105.57 249.85,106.85 249.79,106.92 249.79,108.37
  IN1 w0.13: 249.79,108.37 249.98,108.57 252.56,108.57 252.86,108.27 255.8,108.27 257.08,109.55 257.72,109.55 263.31,115.14 274.92,115.14 275.66,115.88 276.28,115.88 276.55,116.15 276.55,117.4 277.51,118.36 281.35,118.36 v2(281.75,117.96)
  BOTTOM w0.102: UG2.T2 v2(281.75,117.96) ; v2(250.17,105.25) UG9.AN46
FB_A_D60: length 32.9
  IN1 w0.13: v2(252.17,106.05) 252.58,106.05 252.77,106.24 253.53,106.24 253.68,106.09 254.77,106.09 255.58,106.9 257.77,106.9 264.12,113.25 275.36,113.25 276.36,114.25 277.44,114.25 278.35,115.16 278.76,115.16 278.95,115.35 278.95,115.96 v2(279.35,116.36)
  BOTTOM w0.102: UG2.N4 v2(279.35,116.36) ; v2(252.17,106.05) UG9.AR48
FB_A_D61: length 37.1
  IN1 w0.102: 253.42,105.22 253.08,104.88 252.02,104.88 252,104.89 251.34,104.89 250.99,105.25 v2(250.87,105.25)
  IN1 w0.13: v2(279.35,117.16) 279.75,116.76 279.75,115.88 280.08,115.55 280.08,114.92 278.91,113.75 276.93,113.75 275.82,112.64 264.53,112.64 257.48,105.59 254.04,105.59 253.68,105.22 253.42,105.22
  BOTTOM w0.102: v2(250.87,105.25) UG9.AN47 ; v2(279.35,117.16) 279.56,117.38 UG2.N2
FB_A_D62: length 32
  IN1 w0.13: v2(278.55,115.56) 277.75,115.56 276.94,114.75 276.06,114.75 275.17,113.86 263.76,113.86 257.93,108.02 256.99,108.02 256.45,107.48 254.82,107.48 253.92,106.58 252,106.58 v2(251.47,106.05)
  BOTTOM w0.102: v2(251.47,106.05) UG9.AR47 ; v2(278.55,115.56) 278.79,115.8 UG2.M4
FB_A_D63: length 34.5
  IN1 w0.13: v2(278.55,117.96) 277.34,116.76 277.34,115.91 276.73,115.3 275.77,115.3 275,114.52 263.56,114.52 257.67,108.63 256.89,108.63 256.14,107.88 254.66,107.88 253.71,106.93 251.2,106.93 250.77,106.5 v2(250.77,106.05)
  BOTTOM w0.102: UG9.AR46 v2(250.77,106.05) ; UG2.M2 v2(278.55,117.96)
FB_A_DBI0: length 23.7
  IN2 w0.117: v2(272.15,90.16) 271.75,89.76 266.97,89.76 263.33,93.4 254.53,93.4 254.15,93.78 251.75,93.78 251.47,93.5 v2(251.47,93.45)
  BOTTOM w0.102: UG1.P2 272.15,90.16 v2(272.15,90.16) ; UG9.U47 v2(251.47,93.45)
FB_A_DBI1: length 23.4
  IN2 w0.117: v2(272.15,98.96) 271.76,98.57 271.76,97.07 271.64,96.96 259.34,96.96 258.26,95.88 254.83,95.88 254.32,95.36 v2(253.06,95.36)
  BOTTOM w0.102: UG1.P13 v2(272.15,98.96) ; UG9.Y48 252.11,95.85 252.44,95.52 252.9,95.52 v2(253.06,95.36)
FB_A_DBI2: length 37.7
  IN2 w0.117: v2(280.95,98.16) 281.35,98.56 281.95,98.56 282.15,98.76 282.15,100.18 282.16,100.19 282.16,100.53 282.15,100.55 282.15,101.01 279.73,103.43 256.42,103.43 253.63,100.64 251.88,100.64 v2(251.47,101.05)
  BOTTOM w0.102: UG9.AG47 v2(251.47,101.05) ; UG1.D13 v2(280.95,98.16)
FB_A_DBI3: length 40.6
  IN2 w0.117: v2(280.15,89.36) 280.54,89.76 281.17,89.76 281.35,89.93 281.35,91.14 281.13,91.36 279.18,91.36 278.95,91.59 278.95,92.76 276.93,94.78 276.93,96.7 276.56,97.07 276.56,98.31 276.31,98.56 275.99,98.56 275.75,98.8 275.75,99.12 275.51,99.36 275.19,99.36 274.95,99.6 274.95,99.92 274.72,100.15 268.38,100.15 267.7,99.47 258.81,99.47 256.89,97.55 v2(252.97,97.55)
  BOTTOM w0.102: UG1.D2 280.37,89.58 v2(280.15,89.36) ; v2(252.97,97.55) 252.9,97.62 252.44,97.62 252.11,97.95 UG9.AC48
FB_A_DBI4: length 23.7
  IN2 w0.117: v2(272.15,117.96) 271.76,118.35 269.6,118.35 269.59,118.35 269.59,118.35 269.36,118.12 269.36,118.12 267.99,116.74 257.8,116.74 253.95,112.89 253.95,111.71 253.95,111.27 v2(254.27,110.95)
  BOTTOM w0.102: UG9.BB51 v2(254.27,110.95) ; UG2.D2 v2(272.15,117.96)
FB_A_DBI5: length 26.9
  IN2 w0.117: v2(256.94,112.5) 257.34,112.1 257.94,112.1 258.96,111.08 267.76,111.08 268.43,111.75 271.26,111.75 271.75,111.26 271.75,108.76 v2(272.15,108.36)
  BOTTOM w0.102: v2(272.15,108.36) 272.55,108.76 UG2.D13 ; UG9.AV50 253.62,108.1 254.12,108.1 254.33,107.89 255.06,107.89 256.22,109.05 256.22,110.2 256.55,110.53 256.55,112.11 v2(256.94,112.5)
FB_A_DBI6: length 33.3
  IN2 w0.117: v2(280.95,108.36) 281.35,107.96 281.35,106.61 279.71,104.97 276.13,104.97 276.12,104.96 262.5,104.96 262.48,104.97 254.09,104.97 v2(252.97,103.85)
  BOTTOM w0.102: UG2.P13 v2(280.95,108.36) ; UG9.AM48 252.09,104.25 252.44,103.9 252.92,103.9 v2(252.97,103.85)
FB_A_DBI7: length 37.3
  IN2 w0.117: v2(280.15,117.96) 279.75,117.56 278.4,117.56 278.39,117.55 278.39,117.55 278.16,117.32 278.16,117.32 278.14,117.3 278.14,113.9 276.34,112.1 276.34,112.1 276.11,111.87 276.11,111.87 275.75,111.51 275.75,108.09 275.43,107.77 269.23,107.77 268.86,108.14 257.76,108.14 v2(256.95,107.33)
  BOTTOM w0.102: UG2.P2 280.4,117.71 280.4,117.71 v2(280.15,117.96) ; v2(256.95,107.33) 256.08,107.33 255.38,106.63 254.87,106.63 254.8,106.7 252.92,106.7 UG9.AR49
FB_A_EDC0: length 22.4
  IN2 w0.117: v2(271.35,89.36) 270.94,88.95 266.45,88.95 262.54,92.87 254.09,92.87 253.48,92.26 252.56,92.26 v2(252.17,92.65)
  BOTTOM w0.102: UG1.R2 v2(271.35,89.36) ; v2(252.17,92.65) UG9.R48
FB_A_EDC1: length 22.2
  IN2 w0.117: v2(271.35,98.16) 270.96,98.55 268.99,98.55 268.21,97.77 259.34,97.77 257.96,96.4 254.41,96.4 254.02,96.01 253,96.01 252.55,95.56 252.55,95.14 v2(252.17,94.76)
  BOTTOM w0.102: UG1.R13 v2(271.35,98.16) ; UG9.V48 252.16,94.74 252.16,94.75 v2(252.17,94.76)
FB_A_EDC2: length 37
  IN2 w0.117: v2(281.75,98.96) 281.35,99.36 281.35,100.85 279.46,102.74 256.75,102.74 254.13,100.12 251.03,100.12 251.03,100.13 250.72,100.13 250.71,100.12 249.74,100.12 v2(249.37,99.75)
  BOTTOM w0.102: UG1.C13 v2(281.75,98.96) ; UG9.AF44 v2(249.37,99.75)
FB_A_EDC3: length 38.5
  IN2 w0.117: v2(280.95,90.16) 280.56,90.55 277.5,90.55 277.34,90.72 277.34,91.12 274.96,93.5 274.96,98 274.96,98 274.96,98.32 274.96,98.33 274.96,98.8 274.96,98.8 274.96,99.11 274.71,99.36 268.54,99.36 267.85,98.67 259.15,98.67 257.47,96.99 254.17,96.99 253.69,96.51 252.57,96.51 v2(252.18,96.9)
  BOTTOM w0.102: v2(280.95,90.16) 281.35,89.76 UG1.C2 ; UG9.AA48 252.18,96.86 v2(252.18,96.9)
FB_A_EDC4: length 20.7
  IN2 w0.117: v2(271.35,117.16) 270.95,116.76 269.37,116.76 268.68,116.07 258.01,116.07 254.71,112.77 254.71,112.19 v2(254.85,112.05)
  BOTTOM w0.102: UG2.C2 271.56,117.38 271.56,117.37 v2(271.35,117.16) ; v2(254.85,112.05) 254.8,112 254.8,111.59 254.8,111.59 254.8,111.38 UG9.BB52
FB_A_EDC5: length 24.3
  IN2 w0.117: v2(257.15,111.35) 258.1,110.4 268.52,110.4 269.36,111.24 270.61,111.24 270.71,111.15 270.71,111.15 270.94,110.92 270.94,110.92 270.95,110.91 270.95,109.56 v2(271.35,109.16)
  BOTTOM w0.102: UG9.AT50 253.42,107.05 253.77,107.4 254.17,107.4 254.22,107.45 255.41,107.45 256.91,108.95 256.91,109.57 257.38,110.04 257.38,111.12 v2(257.15,111.35) ; UG2.C13 271.58,108.93 v2(271.35,109.16)
FB_A_EDC6: length 35.4
  IN2 w0.117: v2(252.2,103.19) 252.46,102.92 253.95,102.92 255.28,104.26 279.95,104.26 282.14,106.45 282.14,108.77 v2(281.75,109.16)
  BOTTOM w0.102: v2(252.2,103.19) 251.87,102.86 UG9.AK48 ; UG2.R13 v2(281.75,109.16)
FB_A_EDC7: length 36.1
  IN2 w0.117: v2(256.37,106.34) 256.77,106.74 258.16,106.74 258.8,107.38 267.84,107.38 268.91,106.31 272.72,106.31 273.03,106.63 275.41,106.63 276.55,107.76 276.55,111.22 276.66,111.32 276.66,111.32 276.89,111.55 276.89,111.55 280.55,115.22 280.55,116.76 v2(280.95,117.16)
  BOTTOM w0.102: v2(280.95,117.16) UG2.R2 ; UG9.AR51 254.19,106.35 254.55,105.99 256.02,105.99 v2(256.37,106.34)
FB_A_WCK01: length 27
  IN2 w0.089: v2(249.47,93.45) 249.47,93.75 249.83,94.11 254.08,94.11 254.91,94.93 258.91,94.93 259.46,95.48 263.03,95.48 266.25,92.26 267.57,92.26 ; v2(272.15,90.97) 272.15,91.19
  IN2 w0.102: 267.57,92.26 271.41,92.26 271.75,91.93 271.75,91.6 272.15,91.19
  BOTTOM w0.102: v2(249.47,93.45) 249.47,93.61 249.62,93.76 249.76,93.76 UG9.U45
  BOTTOM w0.119: v2(272.15,90.97) 272.16,90.97 UG1.P4
FB_A_WCK23: length 39
  IN2 w0.089: v2(249.47,97.65) 249.36,97.76 249.36,97.86 249.37,97.88 249.37,98.08 249.55,98.26 249.55,98.27 249.69,98.41 256.29,98.41 258.33,100.45 275.19,100.45 277.64,98 277.64,94.93 277.96,94.61 277.95,94.6 279.76,92.8 279.76,92.15 v2(280.15,91.76)
  BOTTOM w0.102: UG9.AC45 v2(249.47,97.65)
  BOTTOM w0.119: UG1.D4 280.39,91.52 v2(280.15,91.76)
FB_A_WCK45: length 29.5
  IN2 w0.089: v2(250.87,108.15) 251.04,108.32 251.06,108.32 251.54,108.8 255.23,108.8 255.89,109.46 255.89,112.3 256.54,112.94 265.06,112.94 266.35,114.23 266.39,114.28 272.47,114.28 272.49,114.29 272.62,114.29 273.35,115.02 273.35,115.72 272.95,116.11 v2(272.95,116.36)
  BOTTOM w0.102: v2(250.87,108.15) UG9.AV47
  BOTTOM w0.119: UG2.D4 272.73,116.14 v2(272.95,116.36)
