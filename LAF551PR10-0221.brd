# Allegro board LAF551PR10-0221.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PR714  100K_0402_1%  [R_0402]  56.04 28.84 270 top
PR715  120K_0402_5%  [R_0402]  57.24 26.66 270 bottom
PR716  324K_0402_1%  [R_0402]  55.16 28.84 270 top
PR717  0_0402_5%  [R0402_0OHM]  53.88 27.42 180 top
PR718  10K_0402_1%  [R_0402]  56.14 20.45 270 top
PR719  49.9K_0402_1%  [R_0402]  55.32 26.67 270 bottom
PR720  0_0402_5%  [R0402_0OHM]  52.91 23.81 0 top
PR721  0_0402_5%  [R0402_0OHM]  52.92 22.92 0 top
PR722  10_0402_1%  [R_0402]  58.37 20.39 270 top
PR723  10_0402_1%  [R_0402]  57.48 20.39 270 top
PR724  0_0402_5%  [R_0402]  52.91 24.69 0 top
PR725  4.7_0402_5%  [R_0402]  67.26 35.17 0 top
PR726  4.7_0402_5%  [R_0402]  66.21 42.36 0 top
PR727  0_0402_5%  [R0402_0OHM]  55.25 19.54 90 top
PR728  0_0402_5%  [R_0402]  56.27 24.36 180 bottom
PR733  10K_0402_1%  [R_0402]  79.89 29.2 180 top
PR734  10_0402_1%  [R_0402]  78.9 31.19 270 top
PR801  0_0402_5%  [R_0402]  238.08 42.54 180 bottom
PR802  1M_0402_1%  [R_0402]  238.08 40.76 180 bottom
PR803  4.7_0603_5%  [R_0603]  247.24 45.96 0 bottom
PR804  21.5K_0402_1%  [R_0402]  237.17 44.31 0 bottom
PR805  31.6K_0402_1%  [R_0402]  238.08 43.42 180 bottom
PR806  0_0603_5%  [R_0603]  247.24 43.55 0 bottom
PR807  100K_0402_1%  [R_0402]  224.29 40.38 90 bottom
PR808  1M_0402_1%  [R_0402]  225.18 40.36 90 bottom
PR809  4.7_0603_5%  [R_0603]  232.1 45.65 0 bottom
PR810  20K_0402_1%  [R_0402]  221.62 44.64 270 bottom
PR811  10K_0402_1%  [R_0402]  223.47 43.41 90 bottom
PR812  0_0402_5%  [R_0402]  238.08 43.74 180 top
PR813  0_0402_5%  [R0402_0OHM]  237.17 42.85 0 top
PR814  0_0402_5%  [R_0402]  226.27 43.04 180 bottom
PR815  0_0402_5%  [R0402_0OHM]  225.36 42.15 0 bottom
PR816  0_0603_5%  [R_0603]  232.67 42.85 0 bottom
PR817  10K_0402_1%  [R_0402]  223.4 41.28 270 bottom
PR820  10K_0402_1%  [R_0402]  228.55 39.06 270 bottom
PR821  10K_0402_1%  [R_0402]  241.26 40.88 180 top
PR1300  100K_0402_1%  [R_0402]  97.52 51.51 270 bottom
PR1301  0_0402_5%  [R0402_0OHM]  98.34 52.52 90 bottom
PR1302  1M_0402_1%  [R_0402]  99.23 52.52 90 bottom
PR1304  21.5K_0402_1%  [R_0402]  101.17 43.97 180 bottom
PR1305  10K_0402_1%  [R_0402]  99.35 43.96 180 bottom
PR5001  0_0402_5%  [R0402_0OHM]  181.06 148.5 270 bottom
PR5002  4.7_1206_5%  [R_1206]  181.7 137.79 0 top
PR5004  2_0603_5%  [R_0603]  158.82 149.54 270 bottom
PR5005  3.9_0603_1%  [R_0603]  184.55 149.37 270 bottom
PR5006  0_0402_5%  [R0402_0OHM]  180.19 148.51 270 bottom
PR5007  0_0402_5%  [R0402_0OHM]  125.5 118.61 180 bottom
PR5008  1M_0402_1%  [R_0402]  124.58 120.39 0 bottom
PR5009  4.7_1206_5%  [R_1206]  121.04 112.13 180 bottom
PR5010  0_0603_5%  [R_0603]  118.31 116.58 270 bottom
PR5012  21K_0402_1%  [R_0402]  123.71 123.4 90 bottom
PR5014  10_0402_1%  [R_0402]  124.62 124.32 270 bottom
PR5015  35.7K_0402_1%  [R_0402]  122.83 124.3 270 bottom
PR5016  10K_0402_1%  [R_0402]  122.77 121.97 270 bottom
PR5017  0_0402_5%  [R0402_0OHM]  125.82 123.46 0 bottom
PR5018  0_0402_5%  [R0402_0OHM]  125.82 124.35 0 bottom
PR5020  2_0603_5%  [R_0603]  166.43 149.5 270 bottom
PR5022  2_0603_5%  [R_0603]  142.42 152.87 270 bottom
PR5024  2_0603_5%  [R_0603]  174.94 149.48 270 bottom
PR5025  2_0603_5%  [R_0603]  182.1 149.47 270 bottom
PR5033  0_0402_5%  [R_0402]  124.58 116.64 0 bottom
PR5034  0_0402_5%  [R_0402]  125.5 117.59 180 bottom
PR6000  10K_0402_1%  [R_0402]  267.28 143.3 90 bottom
PR6001  20K_0402_1%  [R_0402]  265.11 139.5 0 bottom
PR6002  20K_0402_1%  [R_0402]  265.11 137.66 0 bottom
PR6003  20K_0402_1%  [R_0402]  265.11 135.75 0 bottom
PR6004  20K_0402_1%  [R_0402]  265.11 133.87 0 bottom
PR6005  0_0402_5%  [R_0402]  268.89 139.44 90 bottom
PR6006  91K_0402_1%  [R_0402]  266.39 144.21 270 bottom
PR6007  12.4K_0402_1%  [R_0402]  269.76 140.33 0 bottom
PR6008  0_0402_5%  [R_0402]  270.7 138.51 180 bottom
PR6009  0_0402_5%  [R_0402]  268.89 138.51 270 bottom
PR6010  1_0402_1%  [R_0402]  265.11 138.61 0 bottom
PR6011  1_0402_1%  [R_0402]  265.11 136.77 0 bottom
PR6012  0_0402_5%  [R_0402]  266.9 137.67 270 bottom
PR6013  1_0402_1%  [R_0402]  265.11 134.86 0 bottom
PR6014  1_0402_1%  [R_0402]  265.11 132.96 0 bottom
PR6015  0_0402_5%  [R_0402]  267.29 141.53 180 bottom
PR6016  0_0402_5%  [R_0402]  268.88 142.1 270 bottom
PR6017  2.4K_0402_1%  [R_0402]  270.66 142.99 180 bottom
PR6018  0_0402_5%  [R_0402]  269.74 142.1 0 bottom
PR6019  0_0402_5%  [R_0402]  269.74 144.77 0 bottom
PR6020  499_0402_1%  [R_0402]  269.78 137.62 0 bottom
PR6021  0_0402_5%  [R_0402]  247.99 123.18 180 top
PR6022  0_0402_5%  [R_0402]  269.76 145.71 90 bottom
PR6023  100_0402_1%  [R_0402]  248.85 123.18 0 top
PR6024  1K_0402_1%  [R_0402]  271.53 145.71 90 bottom
PR6025  0_0402_5%  [R_0402]  244.92 123.18 0 top
PR6026  2.2K_0402_1%  [R_0402]  271.65 133.98 90 bottom
PR6027  2.2K_0402_1%  [R_0402]  272.6 133.98 90 bottom
PR6028  2K_0402_1%  [R_0402]  273.57 134.53 90 bottom
PR6029  100_0402_1%  [R_0402]  244.05 123.18 180 top
PR6030  2K_0402_1%  [R_0402]  274.46 134.53 90 bottom
PR6031  0_0402_5%  [R_0402]  279.62 140.95 0 bottom
PR6032  100K_0402_1%  [R_0402]  276.23 134.53 90 bottom
PR6034  30K_0402_1%  [R_0402]  274.89 143.23 270 top
PR6035  2.2_0603_1%  [R_0603]  277.31 133.98 90 bottom
PR6036  0_0402_5%  [R_0402]  275.92 150.49 90 top
PR6037  0_0402_5%  [R_0402]  276.54 145 90 top
PR6038  33K_0402_5%  [R_0402]  282.73 140.92 180 bottom
PR6039  0_0402_5%  [R_0402]  276.42 145.14 90 bottom
PR6040  6.19K_0402_1%  [R_0402]  279.09 145.14 90 bottom
PR6041  0_0402_5%  [R_0402]  276.65 142.32 90 top
PR6042  100K_0402_1%  [R_0402]  277.31 146.05 270 bottom
PR6043  0_0402_5%  [R_0402]  280.56 137.4 180 bottom
PR6044  0_0402_5%  [R_0402]  278.2 146.05 270 bottom
PR6045  4.32K_0402_1%  [R_0402]  280.56 143.63 180 bottom
PR6046  43K_0402_5%  [R_0402]  279.66 133.3 270 bottom
PR6047  10K_0402_1%  [R_0402]  282.43 138.87 0 bottom
PR6048  51K_0402_5%  [R_0402]  278.44 133.3 270 bottom
PR6049  0_0402_5%  [R_0402]  280.56 138.29 180 bottom
PR6050  36K_0402_5%  [R_0402]  280.87 133.3 270 bottom
PR6051  10K_0402_1%  [R_0402]  282.43 137.02 0 bottom
PR6052  10K_0402_1%  [R_0402]  282.43 135.18 0 bottom
PR6053  16.5K_0402_1%  [R_0402]  279.65 142.74 0 bottom
PR6054  0_0402_5%  [R_0402]  280.56 139.18 180 bottom
PR6055  0_0402_5%  [R_0402]  280.56 140.07 180 bottom
PR6056  8.2K_0402_5%  [R_0402]  279.66 135.46 270 bottom
PR6057  8.2K_0402_5%  [R_0402]  280.87 135.46 270 bottom
PR6058  0_0402_5%  [R_0402]  283.35 139.75 180 bottom
PR6059  0_0402_5%  [R_0402]  283.35 137.9 180 bottom
PR6060  0_0402_5%  [R_0402]  278.44 135.46 270 bottom
PR6061  309_0402_1%  [R_0402]  281.81 142.74 0 bottom
PR6062  0_0402_5%  [R_0402]  283.35 136.06 180 bottom
PR6063  20.5K_0402_1%  [R_0402]  279.65 141.85 0 bottom
PR6064  0_0402_5%  [R_0402]  280.56 140.07 180 top
PR6065  0_0402_5%  [R_0402]  280.56 139.18 180 top
PR6066  0_0402_5%  [R_0402]  280.56 138.29 180 top
PR6067  0_0402_5%  [R_0402]  280.56 137.4 180 top
PR6068  0_0402_5%  [R_0402]  271.87 147.56 180 bottom
PR6069  10K_0402_1%  [R_0402]  280.03 150.36 90 top
PR6070  100K_0402_1%  [R_0402]  275.34 134.53 90 bottom
PR6100  0.005_2512_1%  [RL-3264-9W-R005-FNH_2512_2512]  87.41 27.16 0 top
PR6101  0.005_2512_1%  [RL-3264-9W-R005-FNH_2512_2512]  201.81 147.46 270 bottom
PR6102  0_0402_5%  [R_0402]  252.05 154.49 180 bottom
PR6103  10K_0402_1%  [R_0402]  251.15 152.7 90 bottom
PR6104  1K_0402_1%  [R_0402]  253.49 153.39 270 top
PR6105  0_0402_5%  [R_0402]  252.6 152.48 90 top
PR6106  2.2_0603_1%  [R_0603]  250.71 153.41 270 top
PR6107  0_0402_5%  [R_0402]  255.09 155.58 270 top
PR6108  2.2_0603_1%  [R_0603]  257.88 145.6 270 top
PR6109  0_0402_5%  [R_0402]  238.27 154.42 180 bottom
PR6110  10K_0402_1%  [R_0402]  237.37 152.63 90 bottom
PR6111  1K_0402_1%  [R_0402]  239.68 153.34 270 top
PR6112  0_0402_5%  [R_0402]  238.79 152.43 90 top
PR6113  2.2_0603_1%  [R_0603]  236.93 153.34 270 top
PR6114  0_0402_5%  [R_0402]  241.25 155.58 270 top
PR6115  2.2_0603_1%  [R_0603]  244.1 145.47 270 top
PR6200  0_0402_5%  [R_0402]  225.45 154.61 180 bottom
PR6201  10K_0402_1%  [R_0402]  223.59 153.08 90 bottom
PR6202  1K_0402_1%  [R_0402]  225.98 153.23 270 top
PR6203  0_0402_5%  [R_0402]  225.09 152.31 90 top
PR6204  2.2_0603_1%  [R_0603]  223.27 152.14 270 bottom
PR6205  0_0402_5%  [R_0402]  227.59 155.45 270 top
PR6206  2.2_0603_1%  [R_0603]  230.39 145.41 270 top
PR6207  0_0402_5%  [R_0402]  210.78 154.36 180 bottom
PR6208  10K_0402_1%  [R_0402]  210.02 153.34 180 bottom
PR6209  1K_0402_1%  [R_0402]  211.65 154.79 90 bottom
PR6210  0_0402_5%  [R_0402]  211.59 152.19 90 top
PR6211  2.2_0603_1%  [R_0603]  209.62 152.39 270 bottom
PR6212  0_0402_5%  [R_0402]  213.81 155.64 270 bottom
PR6213  2.2_0603_1%  [R_0603]  209.01 142.43 180 bottom
PR6400  2.2_0603_1%  [R_0603]  304.63 48.86 90 top
PR6401  0.005_2512_1%  [RL-3264-9W-R005-FNH_2512_2512]  272.29 35.1 0 bottom
PR6403  0_0402_5%  [R_0402]  308.19 57.52 180 top
PR6404  100K_0402_1%  [R_0402]  308.2 54.85 180 top
PR6405  2.2_0603_1%  [R_0603]  306.71 52.82 0 top
PR6406  0_0402_5%  [R_0402]  311.17 57.77 180 top
PR6407  2.2_0603_1%  [R_0603]  300.03 53.42 180 top
PR6408  10K_0402_1%  [R_0402]  299.74 55.55 180 top
PR6409  2.2_0603_1%  [R_0603]  289 52.58 180 top
PR6410  0_0402_5%  [R0402_0OHM]  311.17 55.84 180 top
PR6411  51.1K_0402_1%  [R_0402]  299.71 57.33 270 top
PR6412  0_0402_5%  [R_0402]  308.2 59.27 180 top
PR6413  0_0402_5%  [R_0402]  310.26 56.89 0 top
PR6414  49.9_0603_1%  [R_0603]  299.74 60.39 270 top
PR6415  10K_0402_1%  [R_0402]  297.8 59.18 0 top
PR6416  6.19K_0402_1%  [R_0402]  305.91 59.16 90 top
PR6417  4.32K_0402_1%  [R_0402]  304.98 59.15 90 top
PR6418  16.5K_0402_1%  [R_0402]  303.22 59.15 90 top
PR6419  45.3K_0402_1%  [R_0402]  302.31 60.03 270 top
PR6420  86.6K_0402_1%  [R_0402]  301.4 59.15 90 top
PR6421  0_0402_5%  [R0402_0OHM]  298.82 62.61 270 top
PR6422  0_0402_5%  [R0402_0OHM]  297.86 62.61 270 top
PR6423  309_0402_1%  [R_0402]  303.23 60.93 0 top
PR6424  2.2_0603_1%  [R_0603]  278.93 54.01 180 top
PR6425  100_0402_1%  [R_0402]  250.64 120.89 180 bottom
PR6426  20.5K_0402_1%  [R_0402]  302.45 62.07 0 top
PR6427  100_0402_1%  [R_0402]  247.98 120.89 0 bottom
PR6428  0_0402_5%  [R0402_0OHM]  306.26 50.47 0 top
PR6429  0_0402_5%  [R0402_0OHM]  307.27 53.97 0 top
PR6430  100K_0402_1%  [R_0402]  308.43 50.52 90 top
PR6431  0_0402_5%  [R0402_0OHM]  299.74 54.66 180 top
PR6432  0_0402_5%  [R0402_0OHM]  300.19 51.04 180 top
PR6433  100K_0402_1%  [R_0402]  297.67 53.2 90 top
PR6434  100K_0402_1%  [R_0402]  304.24 51.22 90 top
PR6435  100K_0402_1%  [R_0402]  302.84 51.22 90 top
PR6436  30K_0402_1%  [R_0402]  307.27 58.4 0 top
PR8200  2.2_0603_5%  [R_0603]  247.97 35.05 0 bottom
PR8201  2.2_0402_1%  [R_0402]  240.53 37.2 0 bottom
PR8202  383K_0402_1%  [R_0402]  241.45 35.42 180 bottom
PR8203  100K_0402_1%  [R_0402]  244.99 38.2 90 bottom
PR8204  4.7_1206_5%  [R_1206]  265.12 35.36 270 top
PR8205  2.2_0603_5%  [R_0603]  247.59 31.62 180 bottom
PR8206  7.5K_0402_1%  [R_0402]  248.81 33.96 180 bottom
PR8207  2.2_0603_5%  [R_0603]  246.45 39.11 270 bottom
PR8208  10K_0402_1%  [R_0402]  241.69 33.47 270 bottom
PR8209  100_0402_1%  [R_0402]  244.1 38.2 90 bottom
PR8210  4.7_1206_5%  [R_1206]  252.48 35.42 270 top
PR8211  34.8K_0402_1%  [R_0402]  241.58 35.35 180 top
PR8214  0_0402_5%  [R_0402]  238.25 30.41 0 bottom
PR8215  52.3K_0402_1%  [R_0402]  240.66 32.68 0 top
PR8216  0_0402_5%  [R0402_0OHM]  312.89 59.19 180 top
PR8217  0_0402_5%  [R_0402]  237.17 39.86 0 bottom
PR8218  68.1K_0402_1%  [R_0402]  240.66 34.46 0 top
PR8219  0_0402_5%  [R0402_0OHM]  244.04 30.65 90 top
PR8220  10K_0402_1%  [R_0402]  239.66 36.06 180 bottom
PR9000  0_0402_5%  [R0402_0OHM]  29.23 12.88 180 bottom
PR9001  100K_0402_1%  [R_0402]  28.32 13.77 0 bottom
PU100  -  [TPS51225CRUKR_QFN20_3X3]  53.06 49.03 0 bottom
PU201  -  [RT8207PGQW_WQFN20_3X3]  91.89 47.35 0 bottom
PU300  -  [TPS51212DSCR_SON10_3X3]  243.27 21.81 270 top
PU500  NCP81215DPA0MNTXG_QFN52_6X6  [NCP81215MNTXG_QFN52_6X6]  127.22 140.3 180 top
PU502  -  [NCP302045MNTXG_PQFN33_5X5]  149.69 149.78 0 bottom
PU503  -  [NCP302045MNTXG_PQFN33_5X5]  157.49 146.65 0 bottom
PU504  -  [NCP302045MNTXG_PQFN33_5X5]  165.1 146.61 0 bottom
PU507  -  [NCP302045MNTXG_PQFN33_5X5]  142.12 149.77 0 bottom
PU509  -  [SY8286RAC_QFN20_3X3]  120.06 117.2 0 bottom
PU510  -  [NCP302045MNTXG_PQFN33_5X5]  173.86 146.28 0 bottom
PU511  NCP302035MNTXG_PQFN33_5X5  [NCP302045MNTXG_PQFN33_5X5]  181.16 146.29 0 bottom
PU700  BQ24780SRUYR_QFN28_4X4  [BQ24780RUYR_WQFN28_4X4]  58.64 26.08 270 top
PU800  -  [SY8286RAC_QFN20_3X3]  243.37 43.75 180 bottom
PU802  -  [SY8286RAC_QFN20_3X3]  231.17 43.18 180 bottom
PU1300  -  [RT9059GSP_SO8]  98.98 50.8 0 bottom
PU6000  -  [UP9511PQGJ_VQFN40_5X5]  277.96 141.87 180 bottom
PU6100  -  [SIC632CDT1GE3_POWERPAK31_5X5]  253.21 153.18 270 bottom
PU6101  -  [SIC632CDT1GE3_POWERPAK31_5X5]  239.43 153.11 270 bottom
PU6200  -  [SIC632CDT1GE3_POWERPAK31_5X5]  225.72 153.05 270 bottom
PU6201  -  [SIC632CDT1GE3_POWERPAK31_5X5]  212.06 153.05 270 bottom
PU6400  -  [UP1666QQKF_WQFN20_3X3]  304.99 54.65 180 top
PU8200  RT8812AGQW-GP  [RT8812AGQW_WQFN20_3X3]  245.53 33.16 180 bottom
PU9000  RT9013-18GB_SOT23-5  [RT9193-18GB_SOT23-5]  31.76 17.3 180 bottom
Q7  -  [DMN65D8LDW-7_SOT363-6]  321.19 46.8 180 top
Q8  -  [DMN65D8LDW-7_SOT363-6]  322.54 42.85 180 top
Q9  -  [DMN65D8LDW-7_SOT363-6]  327.75 42.85 180 top
Q28  -  [DMN66D0LDW-7_SOT363-6]  112.88 24.29 0 top
Q29  -  [DMN66D0LDW-7_SOT363-6]  118.22 24.25 0 top
Q34  -  [DMN66D0LDW-7_SOT363-6]  107.74 24.29 0 top
Q2407  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  143.58 132.9 270 bottom
Q2408  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  275.73 132.6 180 top
Q2409  SI3456DDV-T1-GE3_TSOP6~D  [SI3456DDV-T1-GE3_TSOP6]  205.89 6.34 90 top
Q2410  L2N7002WT1G 1N SC-70-3  [SSM3K7002FU_SC70-3]  203.75 5.29 270 bottom
Q2411  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  286.14 34.92 180 bottom
QE1  -  [DMN66D0LDW-7_SOT363-6]  325.27 42.85 180 top
QE2  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  309.8 9.49 180 top
QE3  -  [DMN66D0LDW-7_SOT363-6]  326.48 46.79 180 top
QE4  -  [DMN66D0LDW-7_SOT363-6]  323.94 46.79 180 top
QE5  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  288.21 23.18 90 top
QE8  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  208.45 162.46 180 top
QE13  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  203.24 175.15 180 top
QE21  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  200.76 175.15 180 top
QE22  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  205.71 175.15 180 top
QE29  -  [MMDT3904-7-F_SOT363-6]  233.95 32.42 90 bottom
QE39  -  [MMDT3904-7-F_SOT363-6]  228.04 22.71 90 bottom
QE40  -  [MMDT3904-7-F_SOT363-6]  228.04 25.95 90 bottom
QE41  -  [MMDT3904-7-F_SOT363-6]  228.04 29.19 90 bottom
QE42  -  [MMDT3904-7-F_SOT363-6]  228.04 32.42 90 bottom
QE43  -  [MMDT3904-7-F_SOT363-6]  233.95 29.19 90 bottom
QE44  -  [MMDT3904-7-F_SOT363-6]  233.95 25.95 90 bottom
QE45  -  [MMDT3904-7-F_SOT363-6]  233.95 22.71 90 bottom
QE46  -  [MMDT3904-7-F_SOT363-6]  235.85 32.42 90 top
QE47  -  [MMDT3904-7-F_SOT363-6]  235.85 29.19 90 top
QE48  -  [MMDT3904-7-F_SOT363-6]  235.85 25.95 90 top
QE49  -  [DMN66D0LDW-7_SOT363-6]  228.02 27.25 270 top
QE50  -  [DMN66D0LDW-7_SOT363-6]  225.94 24.37 180 top
QE51  -  [DMN66D0LDW-7_SOT363-6]  228.02 30.49 270 top
QE52  -  [DMN66D0LDW-7_SOT363-6]  228.02 24.01 270 top
QE53  -  [DMN66D0LDW-7_SOT363-6]  228.02 33.72 270 top
QE54  -  [BC857BS_SOT363-6]  225.94 27.74 180 top
QE55  -  [BC857BS_SOT363-6]  225.94 30.81 180 top
QE56  -  [BC857BS_SOT363-6]  224.54 33.96 180 top
QE57  -  [DMN66D0LDW-7_SOT363-6]  271.22 36.28 0 top
QE58  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  300.52 32.19 270 top
QG2  -  [MESS138W-G_SOT323-3]  284.06 103.85 180 bottom
QG3  -  [MESS138W-G_SOT323-3]  284.1 69.03 180 bottom
QG4  -  [MESS138W-G_SOT323-3]  230.35 53.66 90 bottom
QG6  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  206.42 151.71 270 bottom
QG7  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  205.21 122.69 270 bottom
QG8  -  [MESS138W-G_SOT323-3]  191.73 86.42 0 bottom
QG500  -  [DMN66D0LDW-7_SOT363-6]  210.27 123.75 180 bottom
QG501  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  205.21 119.96 270 bottom
QG502  DMN53D0LDW-7_SOT363-6  [2N7002DW-7-F_SOT363-6]  212.05 158.01 0 top
QG503  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  191.33 112.12 90 top
QG504  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  188.89 106.9 0 top
QG505  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  192.58 107.09 0 top
QG506  -  [MESS138W-G_SOT323-3]  209.43 127.42 270 bottom
QG507  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  289.53 88.02 0 bottom
QG508  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  290.39 80.04 180 bottom
QG510  -  [MESS138W-G_SOT323-3]  198.23 123.39 180 bottom
QG511  -  [MESS138W-G_SOT323-3]  310.18 52.74 180 top
QG512  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  180.69 72.06 270 top
QH5  DMN66D0LDW-7  [DMN66D0LDW-7_SOT363-6]  188.98 32.96 270 bottom
QL3  -  [2N7002K_SOT23-3]  267.83 160.14 270 top
QM1  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  143.65 166.6 90 bottom
QM2  -  [DMN66D0LDW-7_SOT363-6]  151.45 168.22 270 bottom
QM3  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  154.25 165.38 180 bottom
QS3  DMN65D8LW-7_SOT323-3  [SSM3K7002FU_SC70-3]  188.54 68.19 0 top
QT2  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  183.79 12.36 90 bottom
QU1  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  295.84 63.36 0 top
QU2  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  18.03 55.67 90 bottom
QV1  -  [SI3457CDV-T1-GE3_TSOP6]  159.84 172.52 270 bottom
QV2  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  148.88 161.46 180 bottom
QV3  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  236.97 163.19 90 top
QV96  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  215.86 163.36 0 bottom
QV97  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  219.58 159.34 90 top
QX1  LBSS138LT1G_SOT-23-3  [LBSS138LT1G_SOT23-3]  220.86 165.22 90 bottom
QX2  S TR MMST3904-7-F NPN SOT323-3  [MMST3904-7-F_SOT323-3]  227.78 168.9 0 bottom
QX3  S TR MMST3904-7-F NPN SOT323-3  [MMST3904-7-F_SOT323-3]  212.25 162.86 270 bottom
R144  2.2K_0402_5%  [R_0402]  111.82 23.45 90 top
R145  2.2K_0402_5%  [R_0402]  110.04 23.45 90 top
R146  2.2K_0402_5%  [R_0402]  111.82 25.35 90 top
R147  2.2K_0402_5%  [R_0402]  110.04 26.27 270 top
R150  2.2K_0402_5%  [R_0402]  116.15 25.91 270 top
R151  0_0402_5%  [R_0402]  107.67 27.21 0 top
R152  0_0402_5%  [R_0402]  118.11 27.08 180 top
R153  0_0402_5%  [R_0402]  112.56 27.14 0 top
R154  2.2K_0402_5%  [R_0402]  117.09 24.97 90 top
R174  10K_0402_5%  [R_0402]  64.44 19.64 270 bottom
R179  300K_0402_5%~D  [R_0402]  206.59 9.52 180 top
R180  1.5M_0402_5%~D  [R_0402]  207.26 7.74 0 top
R181  10K_0402_5%  [R_0402]  186.43 41.52 0 bottom
R182  0_0402_5%  [R_0402]  63.48 19.64 270 bottom
R184  0_0402_5%  [R0402_0OHM]  186.96 50.89 270 bottom
R185  0_0402_5%  [R0402_0OHM]  189.18 42.92 90 bottom
R307  100K_0402_1%  [R_0402]  321.32 38.65 90 top
R325  100K_0402_1%  [R_0402]  326.4 38.97 90 top
R363  10K_0201_5%  [R_0201]  327.84 33.06 0 top
R364  10K_0201_5%  [R_0201]  235.63 19.43 0 bottom
R365  10K_0201_5%  [R_0201]  274.01 9.07 0 top
R366  10K_0201_5%  [R_0201]  203.59 12.67 270 bottom
R367  10K_0402_5%  [R_0402]  228.75 44.81 0 top
RA1  0_0603_5%  [R0603_0OHM]  16.79 29.58 90 top
RA2  22_0402_1%  [R_0402]  38.41 29.49 270 bottom
RA3  0_0603_5%  [R0603_0OHM]  30.43 42.09 270 top
RA4  0_0603_5%  [R0603_0OHM]  25.54 18.72 270 top
RA5  0_0603_5%  [R_0603]  33.8 24.75 0 bottom
RA6  0_0603_5%  [R0603_0OHM]  28.65 35.23 0 top
RA7  0_0603_5%  [R0603_0OHM]  15.07 3.6 0 top
RA8  0_0603_5%  [R0603_0OHM]  29.17 38.59 0 top
RA9  10K_0402_5%  [R_0402]  36.6 26.9 90 top
RA11  0_0603_5%  [R0603_0OHM]  40.79 31.74 270 top
RA12  0_0201_5%  [R_0201]  31.28 24.5 0 bottom
RA13  10K_0402_5%  [R_0402]  20.85 27.11 180 top
RA15  1K_0402_1%  [R_0402]  31.2 23.6 90 top
RA16  10K_0402_5%  [R_0402]  30.23 23.6 90 top
RA17  0_0201_5%  [R_0201]  39 27.24 90 bottom
RA18  22_0402_5%  [R_0402]  38.07 27.16 180 bottom
RA19  0_0201_5%  [R0201_0OHM]  35.9 37.52 180 bottom
RA21  100K_0201_1%  [R_0201]  33.73 38.83 270 bottom
RA22  1K_0402_1%  [R_0402]  32.97 37.57 90 bottom
RA24  10K_0402_5%  [R_0402]  38.39 33.26 180 top
RA25  0_0201_5%  [R0201_0OHM]  38.06 30.59 180 top
RA26  2.2K_0201_5%  [R_0201]  25.69 21.43 0 bottom
RA27  33_0402_5%  [R_0402]  37.28 36.36 90 top
RA28  2.2K_0201_5%  [R_0201]  27.68 23.8 0 top
RA29  33_0402_5%  [R_0402]  35.82 36.43 90 top
RA30  33_0402_5%  [R_0402]  37.28 35.41 90 bottom
RA31  33_0402_5%  [R_0402]  37.22 34.4 0 bottom
RA32  100K_0402_1%  [R_0402]  38.39 30.59 180 bottom
RA33  33_0402_5%  [R_0402]  38.55 34.39 90 top
RA34  200K_0402_1%  [R_0402]  37.47 31.48 0 top
RA35  2_0402_1%  [R_0402]  26.04 19.56 270 bottom
RA36  100K_0402_1%  [R_0402]  37.47 32.37 0 top
RA37  2_0402_1%  [R_0402]  20.02 22.47 180 top
RA38  0_0201_5%  [R0201_0OHM]  22.67 22.52 180 top
RA39  0_0201_5%  [R0201_0OHM]  19.34 23.23 0 top
RA40  2.2K_0201_5%  [R_0201]  25.37 26.91 180 top
RA41  2.2K_0201_5%  [R_0201]  25.37 28.37 180 top
RA42  8.2_0402_5%~D  [R_0402]  25.37 26.02 180 top
RA43  8.2_0402_5%~D  [R_0402]  25.37 29.32 180 top
RA44  22K_0201_5%  [R_0201]  22.75 26.79 180 top
RA45  22K_0201_5%  [R_0201]  23.52 23.74 270 top
RA46  0_0201_5%  [R0201_0OHM]  24.43 30.66 180 top
RA47  0_0201_5%  [R0201_0OHM]  22.68 28.02 90 top
RA50  1K_0402_5%  [R_0402]  40.15 12.32 180 bottom
RA51  0_0402_5%  [R0402_0OHM]  37.53 12.33 270 bottom
RA52  1K_0201_1%  [R_0201]  37.6 13.1 90 bottom
RA53  1K_0402_5%  [R_0402]  40.15 11.43 180 bottom
RA55  0_0402_5%  [R_0402]  40.45 18.11 270 top
RA56  0_0402_5%  [R_0402]  39.57 18.11 270 top
RA57  0.2_0805_1%  [R_0805]  38.17 3.58 90 bottom
RA58  39K_0402_0.1%  [R_0402]  33.34 18.11 270 top
RA59  39K_0402_0.1%  [R_0402]  32.46 18.04 270 top
RA60  0.2_0805_1%  [R_0805]  32.71 4.5 180 bottom
RA61  39K_0402_0.1%  [R_0402]  29.79 18.04 270 top
RA62  22.1K_0402_1%  [R_0402]  38.38 9.64 180 bottom
RA63  39K_0402_0.1%  [R_0402]  28.84 17.59 270 top
RA64  39K_0402_0.1%  [R_0402]  27.74 15.75 0 top
RA65  39K_0402_0.1%  [R_0402]  27.74 13.02 0 top
RA66  10K_0402_5%  [R_0402]  35.64 17.72 270 bottom
RA67  10K_0402_5%  [R_0402]  34.74 16.81 90 bottom
RA68  0_0603_5%  [R0603_0OHM]  29.22 40.31 180 bottom
RA69  0_0603_5%  [R_0603]  34.44 38.59 90 top
RA70  10K_0402_5%  [R_0402]  37.79 18.1 270 top
RA73  10_0402_1%  [R_0402]  40.21 7.03 45 bottom
RA74  10_0402_1%  [R_0402]  35.81 3.42 0 top
RA75  10_0402_1%  [R_0402]  33.79 4.45 270 bottom
RA76  10_0402_1%  [R_0402]  31.07 3.36 180 top
RA77  10K_0402_0.1%  [R_0402]  34.23 17.19 90 top
RA78  10K_0402_0.1%  [R_0402]  31.56 17.13 90 top
RA79  10K_0402_0.1%  [R_0402]  30.67 17.13 90 top
RA80  10K_0402_0.1%  [R_0402]  27.96 16.88 180 top
RA81  10K_0402_0.1%  [R_0402]  28.65 14.86 180 top
RA82  10K_0402_0.1%  [R_0402]  28.65 13.9 180 top
RA84  0_0201_5%  [R0201_0OHM]  21.18 30.08 180 top
RA85  0_0201_5%  [R_0201]  21.18 29.44 180 top
RC2  24.9_0402_1%  [R_0402]  170.95 91.72 180 bottom
RC9  100K_0402_5%  [R_0402]  127.47 162.68 180 top
RC30  24.9_0402_1%  [R_0402]  176.35 123.19 270 bottom
RC35  51_0402_1%  [R_0402]  126.62 158.36 0 top
RC62  49.9K_0402_1%  [R_0402]  203.03 10.34 270 top
RC63  49.9K_0402_1%  [R_0402]  203.92 10.34 270 top
RC66  20_0402_5%  [R_0402]  175.72 116.4 270 bottom
RC348  51_0402_1%  [R_0402]  126.62 159.25 0 top
RC353  1K_0402_5%  [R_0402]  129.37 160.58 180 top
RC354  1K_0402_1%  [R_0402]  128.33 162.68 0 top
RC355  1K_0402_1%  [R_0402]  126.68 160.58 0 top
RD1  0_0402_5%  [R_0402]  178.25 53.98 270 top
RD2  0_0402_5%  [R_0402]  178.76 54.97 90 top
RD3  0_0402_5%  [R_0402]  156.55 49.49 270 top
RD4  0_0402_5%  [R_0402]  176.67 41.41 270 top
RD5  0_0402_5%  [R_0402]  177.55 41.41 270 top
RD6  0_0402_5%  [R_0402]  157.12 40.32 90 top
RD28  0_0402_5%  [R_0402]  177.36 53.06 90 top
RD29  0_0402_5%  [R_0402]  177.87 56.05 90 top
RD30  0_0402_5%  [R_0402]  155.66 48.57 90 top
RD31  0_0402_5%  [R_0402]  138.32 53.15 90 top
RD35  470_0402_1%  [R_0402]  136.54 53.15 90 top
RD38  0_0402_5%  [R_0402]  176.35 38.55 270 top
RD39  0_0402_5%  [R_0402]  177.24 38.55 270 top
RD40  0_0402_5%  [R_0402]  156.23 41.23 270 top
RE1  4.7K_0402_5%  [R_0402]  309.19 27.66 90 top
RE2  4.7K_0402_5%  [R_0402]  310.08 27.66 90 top
RE3  1M_0402_5%~D  [R_0402]  317.45 7.15 90 top
RE4  100K_0402_5%  [R_0402]  322.51 9.83 0 top
RE5  100K_0402_5%  [R_0402]  308.3 28.58 270 top
RE6  100K_0402_5%  [R_0402]  316.05 21.5 90 top
RE7  100K_0402_5%  [R_0402]  316.94 21.5 90 top
RE8  10K_0402_5%  [R_0402]  312.94 22.46 0 top
RE9  15_0402_5%  [R_0402]  97.7 22.41 180 bottom
RE10  15_0402_5%  [R_0402]  101.99 17 270 bottom
RE11  15_0402_5%  [R_0402]  100.24 27.26 180 bottom
RE12  10K_0402_5%~D  [R_0402]  102.94 16.08 90 bottom
RE13  10K_0402_5%~D  [R_0402]  102.36 28.23 270 bottom
RE14  10K_0402_5%~D  [R_0402]  101.09 16.08 90 bottom
RE15  100K_0402_5%  [R_0402]  290.72 30.1 270 top
RE16  100K_0402_5%  [R_0402]  323.48 48.9 270 top
RE17  100K_0402_5%  [R_0402]  325 48.9 270 top
RE18  0_0201_5%  [R_0201]  316.7 6.72 90 top
RE19  0_0201_5%  [R_0201]  316.7 8.53 270 top
RE20  10K_0402_5%  [R_0402]  99.39 30.27 90 bottom
RE21  100K_0402_5%  [R_0402]  326.4 48.9 270 top
RE22  33_0402_5%  [R_0402]  99.32 28.15 0 bottom
RE23  100K_0402_5%  [R_0402]  325.07 38.65 90 top
RE24  0_0603_5%  [R0603_0OHM]  309.17 22.55 0 top
RE25  4.7K_0402_1%  [R_0402]  224.47 163.44 0 top
RE26  4.7K_0402_1%~D  [R_0402]  185.12 26.77 270 top
RE27  4.7K_0402_1%  [R_0402]  186.08 25.86 90 top
RE28  100K_0402_5%  [R_0402]  205.94 159.5 90 top
RE29  4.7K_0402_1%~D  [R_0402]  183.87 23.97 180 top
RE30  4.7K_0402_1%  [R_0402]  183.87 23.01 180 top
RE31  10K_0402_5%~D  [R_0402]  225.19 159.44 180 top
RE32  4.7K_0402_1%  [R_0402]  189.95 27.11 270 top
RE33  10K_0201_5%  [R_0201]  185.51 17.69 90 bottom
RE37  10K_0402_5%  [R_0402]  187.03 25.86 90 top
RE40  4.7K_0402_1%~D  [R_0402]  224.28 157.66 0 top
RE42  4.7K_0402_1%~D  [R_0402]  225.12 156.34 270 top
RE43  4.7K_0402_1%~D  [R_0402]  224.28 158.55 0 top
RE44  4.7K_0402_1%~D  [R_0402]  226.01 156.34 270 top
RE63  100K_0402_5%  [R_0402]  310.02 16.73 180 top
RE64  100K_0402_1%  [R_0402]  288.06 10.1 270 top
RE66  0_0402_1%  [R_0402]  288.96 9.19 90 top
RE70  10K_0402_5%  [R_0402]  310.02 18.64 180 top
RE71  0_0402_5%  [R_0402]  187.08 16.51 270 bottom
RE74  43_0402_1%  [R_0402]  310.02 14.7 180 top
RE75  10K_0402_5%  [R_0402]  292.16 27.28 90 top
RE76  43_0402_1%  [R_0402]  309.11 20.42 0 top
RE79  10K_0402_5%  [R_0402]  308.81 11.03 90 top
RE83  10K_0402_5%  [R_0402]  309.11 25.75 0 top
RE84  10K_0402_5%  [R_0402]  310.02 13.81 180 top
RE85  53.6K_0402_5%  [R_0402]  309.71 12.94 180 top
RE89  0_0402_5%  [R_0402]  302.13 28.62 270 top
RE90  2.2K_0804_8P4R_5%  [RP_0804_8P4R]  299.32 7.87 270 top
RE91  47K_0402_5%  [R_0402]  330.46 40.11 90 top
RE100  4.7K_0402_5%  [R_0402]  301.79 6.56 90 top
RE101  4.7K_0402_5%  [R_0402]  302.68 6.56 90 top
RE102  100K_0402_5%  [R_0402]  288.36 14.21 180 top
RE154  10K_0402_5%  [R_0402]  201.91 176.99 270 top
RE155  1K_0402_1%  [R_0402]  200.53 177.02 270 top
RE156  10K_0402_5%  [R_0402]  198.41 173.83 90 top
RE157  1K_0402_1%  [R_0402]  205.74 176.1 90 top
RE158  10K_0402_5%  [R_0402]  204.31 177.03 270 top
RE160  1K_0402_1%  [R_0402]  203.32 177.02 270 top
RE161  10K_0402_5%  [R_0402]  152.47 165.93 270 top
RE162  4.7K_0402_1%  [R_0402]  304.92 32.01 270 top
RE163  4.7K_0402_1%  [R_0402]  301.9 34.03 180 top
RE164  4.7K_0402_1%  [R_0402]  301.9 34.92 180 top
RE165  4.7K_0402_1%  [R_0402]  303.91 31.09 90 top
RE166  4.7K_0402_1%  [R_0402]  300.78 38.92 0 top
RE167  10K_0402_5%~D  [R_0402]  301.89 35.8 180 top
RE300  10K_0201_1%  [R_0201]  158.23 165.03 180 top
RE396  10K_0201_1%  [R_0201]  236.74 32.15 90 bottom
RE397  1M_0201_1%  [R_0201]  236.74 33.42 90 bottom
RE398  1M_0201_1%  [R_0201]  234.62 34.66 180 bottom
RE399  10K_0201_1%  [R_0201]  233.05 34 270 bottom
RE400  1M_0201_1%  [R_0201]  235.3 34.66 0 bottom
RE401  1M_0201_1%  [R_0201]  233.05 32.73 270 bottom
RE449  10K_0201_1%  [R_0201]  227.15 27.52 270 top
RE451  1M_0201_1%  [R_0201]  229.4 24.95 0 bottom
RE452  1M_0201_1%  [R_0201]  228.71 24.95 180 bottom
RE453  1M_0201_1%  [R_0201]  227.15 23.08 270 bottom
RE454  10K_0201_1%  [R_0201]  227.15 24.29 270 bottom
RE455  10K_0201_1%  [R_0201]  230.83 22.43 90 bottom
RE456  1M_0201_1%  [R_0201]  230.83 23.7 90 bottom
RE457  1M_0201_1%  [R_0201]  229.4 28.18 0 bottom
RE458  1M_0201_1%  [R_0201]  227.15 26.06 270 bottom
RE459  1M_0201_1%  [R_0201]  228.71 28.18 180 bottom
RE460  10K_0201_1%  [R_0201]  227.15 27.27 270 bottom
RE461  10K_0201_1%  [R_0201]  230.83 25.67 90 bottom
RE462  1M_0201_1%  [R_0201]  230.83 26.94 90 bottom
RE463  1M_0201_1%  [R_0201]  229.4 31.36 0 bottom
RE464  1M_0201_1%  [R_0201]  228.71 31.36 180 bottom
RE465  1M_0201_1%  [R_0201]  227.15 29.56 270 bottom
RE466  10K_0201_1%  [R_0201]  230.83 28.91 90 bottom
RE467  10K_0201_1%  [R_0201]  227.15 30.76 270 bottom
RE468  1M_0201_1%  [R_0201]  230.83 30.18 90 bottom
RE469  1M_0201_1%  [R_0201]  228.71 34.66 180 bottom
RE470  1M_0201_1%  [R_0201]  229.4 34.66 0 bottom
RE471  10K_0201_1%  [R_0201]  230.83 32.15 90 bottom
RE472  1M_0201_1%  [R_0201]  227.15 32.79 270 bottom
RE473  1M_0201_1%  [R_0201]  230.83 33.42 90 bottom
RE474  10K_0201_1%  [R_0201]  227.15 34 270 bottom
RE475  1M_0201_1%  [R_0201]  234.62 31.42 180 bottom
RE476  10K_0201_1%  [R_0201]  236.74 28.91 90 bottom
RE477  1M_0201_1%  [R_0201]  235.3 31.42 0 bottom
RE478  1M_0201_1%  [R_0201]  236.74 30.18 90 bottom
RE479  1M_0201_1%  [R_0201]  233.05 29.49 270 bottom
RE480  10K_0201_1%  [R_0201]  233.05 30.76 270 bottom
RE481  1M_0201_1%  [R_0201]  234.62 28.18 180 bottom
RE482  10K_0201_1%  [R_0201]  236.74 25.67 90 bottom
RE483  1M_0201_1%  [R_0201]  235.3 28.18 0 bottom
RE484  1M_0201_1%  [R_0201]  236.74 26.94 90 bottom
RE485  1M_0201_1%  [R_0201]  233.05 26.25 270 bottom
RE486  10K_0201_1%  [R_0201]  233.05 27.52 270 bottom
RE487  1M_0201_1%  [R_0201]  234.62 24.95 180 bottom
RE488  10K_0201_1%  [R_0201]  236.74 22.43 90 bottom
RE489  1M_0201_1%  [R_0201]  235.3 24.95 0 bottom
RE490  1M_0201_1%  [R_0201]  236.74 23.7 90 bottom
RE491  1M_0201_1%  [R_0201]  233.05 23.02 270 bottom
RE492  10K_0201_1%  [R_0201]  233.05 24.29 270 bottom
RE493  1M_0201_1%  [R_0201]  235.3 34.66 0 top
RE494  1M_0201_1%  [R_0201]  234.62 34.66 180 top
RE495  10K_0201_1%  [R_0201]  233.05 32.25 90 top
RE496  1M_0201_1%  [R_0201]  236.74 32.73 270 top
RE497  1M_0201_1%  [R_0201]  233.05 33.42 90 top
RE498  10K_0201_1%  [R_0201]  236.74 34 270 top
RE499  1M_0201_1%  [R_0201]  234.7 31.42 180 top
RE500  1M_0201_1%  [R_0201]  235.3 31.42 0 top
RE501  1M_0201_1%  [R_0201]  236.74 29.49 270 top
RE502  10K_0201_1%  [R_0201]  233.05 28.67 90 top
RE503  10K_0201_1%  [R_0201]  236.74 30.76 270 top
RE504  1M_0201_1%  [R_0201]  233.05 29.87 90 top
RE505  1M_0201_1%  [R_0201]  235.3 28.18 0 top
RE506  1M_0201_1%  [R_0201]  234.62 28.18 180 top
RE507  10K_0201_1%  [R_0201]  233.05 25.73 90 top
RE508  1M_0201_1%  [R_0201]  233.82 24.37 180 top
RE509  1M_0201_1%  [R_0201]  233.05 26.94 90 top
RE510  10K_0201_1%  [R_0201]  233.05 23.17 90 top
RE511  10K_0201_1%  [R_0201]  227.15 26.25 270 top
RE512  1M_0201_1%  [R_0201]  230.83 26.25 270 top
RE513  1K_0201_1%  [R_0201]  230.83 27.52 270 top
RE514  10K_0201_1%  [R_0201]  223.4 26.13 270 top
RE515  1M_0201_1%  [R_0201]  223.4 23.14 270 top
RE516  1K_0201_1%  [R_0201]  223.4 24.41 270 top
RE517  10K_0201_1%  [R_0201]  223.4 27.33 270 top
RE518  10K_0201_1%  [R_0201]  227.15 29.49 270 top
RE519  1M_0201_1%  [R_0201]  230.83 29.49 270 top
RE520  1K_0201_1%  [R_0201]  230.83 30.76 270 top
RE521  10K_0201_1%  [R_0201]  227.15 30.76 270 top
RE522  10K_0201_1%  [R_0201]  227.15 23.02 270 top
RE523  1M_0201_1%  [R_0201]  230.83 23.02 270 top
RE524  1K_0201_1%  [R_0201]  230.83 24.29 270 top
RE525  10K_0201_1%  [R_0201]  227.15 24.29 270 top
RE526  10K_0201_1%  [R_0201]  227.15 32.73 270 top
RE527  1M_0201_1%  [R_0201]  230.83 32.73 270 top
RE528  1K_0201_1%  [R_0201]  230.83 34 270 top
RE529  10K_0201_1%  [R_0201]  227.15 34 270 top
RE530  47K_0402_5%  [R_0402]  318.16 56.06 180 top
RE630  100K_0201_1%  [R_0201]  143.37 13.39 270 top
RE631  100K_0201_1%  [R_0201]  143.95 13.39 270 top
RE632  100K_0201_1%  [R_0201]  144.53 13.39 270 top
RE633  100K_0201_1%  [R_0201]  145.17 13.39 270 top
RE634  100K_0201_1%  [R_0201]  145.87 13.39 270 top
RE635  100K_0201_1%  [R_0201]  146.5 13.39 270 top
RE636  1.1K_0402_1%  [R_0402]  273.44 35.32 180 top
RE637  1K_0201_1%  [R_0201]  272.64 39.59 180 top
RE638  1M_0201_1%  [R_0201]  272.06 39.02 0 top
RE639  1.1K_0402_1%  [R_0402]  270.33 39.22 0 top
RE640  1K_0201_1%  [R_0201]  271.17 34.84 0 top
RE641  1M_0201_1%  [R_0201]  271.75 35.47 180 top
RE642  4.7K_0402_5%  [R_0402]  299.16 28.64 270 top
RE643  4.7K_0402_5%  [R_0402]  298.27 28.64 270 top
RE644  100K_0402_5%  [R_0402]  206.82 118.67 0 bottom
RE645  10K_0402_5%  [R_0402]  319.54 27.63 180 top
RE646  0_0201_5%  [R_0201]  305.06 28.22 270 top
RE647  0_0402_5%  [R_0402]  157.57 166.27 90 bottom
RE648  0_0402_5%  [R_0402]  156.68 166.27 90 bottom
RE649  10K_0402_5%  [R_0402]  27.94 46.98 0 top
RE650  10K_0402_5%  [R_0402]  289.26 23.93 270 top
RE651  0_0402_5%  [R_0402]  322.51 16.18 0 top
RE652  10K_0402_5%  [R_0402]  144.45 166.4 90 top
RE653  0_0402_5%  [R_0402]  186.19 16.51 270 bottom
RE654  0_0402_5%  [R_0402]  202.4 8.75 180 bottom
RE655  0_0402_5%  [R_0402]  202.4 7.86 180 bottom
RE656  10K_0402_5%  [R_0402]  141.82 6.47 180 top
RE657  10K_0402_5%  [R_0402]  313.06 27.31 270 top
RE658  10K_0402_5%  [R_0402]  287.31 22.15 0 top
RE659  0_0402_5%  [R_0402]  187.51 6.12 0 top
RE660  0_0402_5%  [R_0402]  187.51 5.26 0 top
RE661  10K_0201_5%  [R_0201]  195.75 15.34 0 top
RE662  10K_0402_5%  [R_0402]  301.11 30.34 0 top
RE663  10K_0201_5%  [R_0201]  186.38 19.05 270 bottom
RE664  0_0603_5%  [R_0603]  285.19 8.3 180 bottom
RE665  0_0603_5%  [R_0603]  285.19 9.53 180 bottom
RE666  0_0603_5%  [R_0603]  285.19 10.77 180 bottom
RE667  0_0603_5%  [R_0603]  285.19 12 180 bottom
RE668  0_0201_5%  [R_0201]  286.09 8.05 180 top
RE669  0_0201_5%  [R_0201]  286.1 7.47 180 top
RE670  0_0201_5%  [R_0201]  286.09 8.63 180 top
RE671  0_0201_5%  [R_0201]  286.1 6.9 180 top
RE672  10K_0402_5%  [R_0402]  295.49 8.06 270 top
RF1  10K_0402_5%  [R_0402]  104.2 59.62 0 top
RF2  10K_0402_5%  [R_0402]  104.21 63.06 270 top
RF3  10K_0402_5%  [R_0402]  104.2 61.21 0 top
RF4  10K_0402_5%  [R_0402]  287.69 75.58 180 top
RF5  10K_0402_5%  [R_0402]  287.69 76.48 180 top
RF6  10K_0402_5%  [R_0402]  292.83 75.35 90 top
RG1  0_0201_5%  [R_0201]  197.28 120.18 270 bottom
RG2  10K_0201_5%  [R_0201]  234.77 121.49 90 bottom
RG3  10K_0201_5%  [R_0201]  200.33 124.58 180 bottom
RG4  0_0201_5%  [R_0201]  234.2 122.08 270 bottom
RG7  0_0201_5%  [R_0201]  198.73 118.29 0 bottom
RG8  10K_0201_5%  [R_0201]  216.45 113.53 180 bottom
RG9  10K_0201_5%  [R_0201]  197.96 125.34 0 bottom
RG11  1.8K_0402_1%  [R_0402]  207.73 122.42 180 bottom
RG12  1.8K_0402_1%  [R_0402]  207.73 121.47 180 bottom
RG13  10K_0201_5%  [R_0201]  199.12 124.58 180 bottom
RG14  10K_0201_5%  [R_0201]  200.39 120.83 0 bottom
RG15  10K_0201_5%  [R_0201]  213.78 111.08 90 bottom
RG16  100K_0201_5%  [R_0201]  222.28 114.29 0 top
RG17  1.8K_0402_5%  [R_0402]  207.73 123.69 180 bottom
RG18  1.8K_0402_5%  [R_0402]  207.73 124.58 180 bottom
RG19  1.8K_0402_5%  [R_0402]  208.97 121.66 0 bottom
RG20  1.8K_0402_5%  [R_0402]  207.73 119.93 180 bottom
RG21  10K_0201_5%  [R_0201]  196.67 119.59 90 bottom
RG22  10K_0201_5%  [R_0201]  226.3 25.64 180 bottom
RG23  2.49K_0402_1%  [R_0402]  243.4 116.18 90 top
RG24  100K_0201_5%  [R_0201]  191.11 102.29 0 top
RG25  1M_0201_1%  [R_0201]  223.76 163.4 90 top
RG26  10K_0201_5%  [R_0201]  230.64 121.49 90 bottom
RG36  1K_0402_1%  [R_0402]  243.06 121.61 90 bottom
RG37  1K_0402_1%  [R_0402]  232.1 116.31 90 top
RG38  1K_0402_1%  [R_0402]  228.71 115.67 90 top
RG47  10K_0402_5%  [R_0402]  277.71 89.53 180 top
RG48  10K_0402_5%  [R_0402]  277.69 118.05 270 top
RG49  10K_0402_5%  [R_0402]  250.83 59.29 90 top
RG50  10K_0402_5%  [R_0402]  276.11 78.97 90 top
RG51  10K_0402_5%  [R_0402]  219.22 60.38 180 top
RG52  10K_0402_5%  [R_0402]  244.56 59.49 180 top
RG53  10K_0402_5%  [R_0402]  275.51 117.99 270 top
RG54  10K_0402_5%  [R_0402]  275.47 89.26 90 top
RG55  10K_0402_5%  [R_0402]  275.23 79.81 180 top
RG56  10K_0402_5%  [R_0402]  250.69 61.84 0 top
RG57  10K_0402_5%  [R_0402]  244.5 61.79 180 top
RG58  10K_0402_5%  [R_0402]  218.31 61.33 0 top
RG59  10_0402_1%  [R_0402]  191.86 113.53 180 bottom
RG60  1.8K_0402_1%  [R_0402]  195.92 119.1 180 bottom
RG61  1.8K_0402_1%  [R_0402]  195.92 118.21 180 bottom
RG62  10_0402_1%  [R_0402]  189.04 113.53 0 bottom
RG64  10_0402_1%  [R_0402]  186.44 117.07 90 bottom
RG65  10K_0402_1%  [R_0402]  195.92 119.99 180 bottom
RG66  10_0402_1%  [R_0402]  186.44 119.76 270 bottom
RG67  40.2_0402_1%  [R_0402]  247.74 92 180 top
RG68  40.2_0402_1%  [R_0402]  254.25 91.42 0 top
RG69  60.4_0402_1%  [R_0402]  254.2 92.43 90 top
RG70  10K_0402_5%  [R_0402]  195 116.45 0 bottom
RG71  4.7K_0402_1%  [R_0402]  198.87 114.6 90 bottom
RG74  10K_0402_5%  [R_0402]  212.68 109.91 180 bottom
RG75  33_0402_5%  [R_0402]  201.32 107.37 180 bottom
RG76  33_0402_5%  [R_0402]  212.68 108.64 180 bottom
RG77  33_0402_5%  [R_0402]  201.32 106.1 180 bottom
RG78  100K_0402_1%  [R_0402]  205.25 111.31 180 top
RG79  100K_0402_1%  [R_0402]  205.25 112.2 180 top
RG80  100K_0402_1%  [R_0402]  215.54 117.34 180 bottom
RG81  100K_0402_1%  [R_0402]  201.61 111.31 0 top
RG82  100K_0402_1%  [R_0402]  201.93 112.2 0 top
RG83  100K_0402_1%  [R_0402]  217.88 115.89 270 top
RG84  10K_0402_1%  [R_0402]  200.4 110.35 0 bottom
RG85  10K_0402_1%  [R_0402]  200.57 112.37 180 top
RG86  10K_0402_1%  [R_0402]  201.32 114.74 180 bottom
RG87  10K_0402_1%  [R_0402]  201.32 111.24 180 bottom
RG88  10K_0402_1%  [R_0402]  199.65 113.25 0 top
RG89  10K_0402_1%  [R_0402]  201.32 108.39 180 bottom
RG90  100K_0402_1%  [R_0402]  204.34 110.42 0 top
RG91  100K_0402_1%  [R_0402]  203.7 113.08 0 top
RG92  100K_0402_1%  [R_0402]  214.63 118.23 0 bottom
RG93  100K_0402_1%  [R_0402]  202.52 110.42 180 top
RG94  100K_0402_1%  [R_0402]  202.84 113.34 180 top
RG95  100K_0402_1%  [R_0402]  222.2 115.61 90 top
RG98  10K_0402_5%  [R_0402]  215.54 116.45 180 bottom
RG99  10M_0402_5%  [R_0402]  213.11 119.38 270 bottom
RG101  10K_0402_5%  [R_0402]  195.83 108.74 90 top
RG102  40.2_0402_1%  [R_0402]  274.51 102.29 90 top
RG103  40.2_0402_1%  [R_0402]  273.62 105.27 270 top
RG104  1K_0402_1%  [R_0402]  276.5 87.56 180 top
RG105  1K_0402_1%  [R_0402]  274.72 119.5 180 top
RG106  1K_0402_1%  [R_0402]  275.8 95.62 180 top
RG107  1K_0402_1%  [R_0402]  276.25 110.93 180 top
RG108  121_0402_1%  [R_0402]  276.25 100.37 180 top
RG109  121_0402_1%  [R_0402]  276.93 108.27 270 top
RG110  549_0402_1%  [R_0402]  278.66 102.61 180 bottom
RG111  931_0402_1%  [R_0402]  278.66 103.62 180 bottom
RG112  1.33K_0402_1%  [R_0402]  276.86 102.9 180 bottom
RG113  40.2_0402_1%  [R_0402]  263.41 63.88 0 bottom
RG114  40.2_0402_1%  [R_0402]  273.68 70.27 270 top
RG115  1K_0402_1%  [R_0402]  249.06 60.65 270 top
RG116  1K_0402_1%  [R_0402]  275.23 84.76 180 top
RG117  1K_0402_1%  [R_0402]  257.5 60.2 270 top
RG118  1K_0402_1%  [R_0402]  277.05 76.25 0 top
RG119  121_0402_1%  [R_0402]  260.47 60.38 0 top
RG120  121_0402_1%  [R_0402]  276.36 72.33 270 top
RG121  549_0402_1%  [R_0402]  263.98 58.59 90 bottom
RG122  931_0402_1%  [R_0402]  277.26 69.78 180 bottom
RG123  1.33K_0402_1%  [R_0402]  263.98 60.37 90 bottom
RG124  40.2_0402_1%  [R_0402]  228.48 63.88 0 top
RG125  40.2_0402_1%  [R_0402]  231.85 63.88 180 top
RG126  1K_0402_1%  [R_0402]  218.31 59.49 0 top
RG127  1K_0402_1%  [R_0402]  246.26 60.68 90 top
RG128  1K_0402_1%  [R_0402]  222.26 61.57 90 top
RG129  1K_0402_1%  [R_0402]  238.71 60.07 270 top
RG130  121_0402_1%  [R_0402]  226.07 61.06 90 top
RG131  121_0402_1%  [R_0402]  234.15 61.01 180 top
RG132  549_0402_1%  [R_0402]  228.04 58.59 90 bottom
RG133  931_0402_1%  [R_0402]  228.93 58.59 90 bottom
RG134  1.33K_0402_1%  [R_0402]  228.93 60.37 90 bottom
RG137  10_0402_1%  [R_0402]  191.86 123.24 180 bottom
RG138  10_0402_1%  [R_0402]  189.16 123.24 0 bottom
RG146  33_0402_5%  [R_0402]  212.62 114.74 180 bottom
RG147  10K_0402_5%  [R_0402]  212.62 115.94 180 bottom
RG148  33_0402_5%  [R_0402]  201.32 113.4 180 bottom
RG149  33_0402_5%  [R_0402]  201.32 112.13 180 bottom
RG150  100K_0201_5%  [R_0201]  188.79 104.28 90 top
RG151  100K_0201_5%  [R_0201]  193.43 113.8 270 top
RG154  1.33K_0402_1%  [R_0402]  196.4 86.03 0 bottom
RG155  549_0402_1%  [R_0402]  194.62 87.81 0 bottom
RG156  931_0402_1%  [R_0402]  194.62 86.92 0 bottom
RG157  121_0402_1%  [R_0402]  198.71 91.88 180 top
RG158  1K_0402_1%  [R_0402]  198.97 103.31 180 top
RG159  1K_0402_1%  [R_0402]  198.52 95.81 180 top
RG160  40.2_0402_1%  [R_0402]  201.06 88.76 270 bottom
RG161  1K_0402_1%  [R_0402]  199.13 71.05 0 top
RG162  121_0402_1%  [R_0402]  198.65 82.35 180 top
RG163  1K_0402_1%  [R_0402]  198.52 78.6 180 top
RG164  40.2_0402_1%  [R_0402]  201.89 85.37 90 bottom
RG200  0_0402_5%  [R_0402]  190.46 59.9 270 bottom
RG450  10K_0402_5%  [R_0402]  200.12 72.71 90 top
RG451  10K_0402_5%  [R_0402]  197.8 101.46 0 top
RG452  10K_0402_5%  [R_0402]  197.87 72.75 90 top
RG453  10K_0402_5%  [R_0402]  200.06 101.54 270 top
RG500  10K_0201_5%  [R_0201]  206 124.86 90 bottom
RG501  100K_0201_5%  [R_0201]  216.63 111.38 180 bottom
RG502  10K_0201_5%  [R_0201]  211.91 125.24 90 bottom
RG503  10K_0201_5%  [R_0201]  222.37 113.19 0 top
RG504  10K_0201_5%  [R_0201]  219.38 115.05 180 top
RG506  10K_0201_5%  [R_0201]  214.18 159.2 90 top
RG508  0_0201_5%  [R_0201]  203.72 128.92 90 bottom
RG509  10K_0402_5%  [R_0402]  188.48 111.86 90 top
RG510  51_0402_5%  [R_0402]  192.29 112.79 90 top
RG511  10K_0402_5%  [R_0402]  188.72 109.85 0 top
RG512  51_0402_5%  [R_0402]  190.71 105.91 180 top
RG513  10K_0402_5%  [R_0402]  191.27 108.84 270 top
RG514  51_0402_5%  [R_0402]  194.92 107.85 270 top
RG515  10K_0402_5%  [R_0402]  192.63 106.06 0 top
RG516  10K_0201_5%  [R_0201]  211.93 160.72 90 top
RG517  10K_0201_5%  [R_0201]  207.91 127.94 0 bottom
RG518  10K_0201_5%  [R_0201]  233.12 121.49 90 bottom
RG519  100K_0201_5%  [R_0201]  211.15 125.24 90 bottom
RG522  10K_0201_5%  [R_0201]  195.35 121.29 0 bottom
RG523  40.2_0402_1%  [R_0402]  275.42 102.29 90 top
RG524  40.2_0402_1%  [R_0402]  274.53 105.27 270 top
RG525  40.2_0402_1%  [R_0402]  263.41 62.97 0 bottom
RG526  40.2_0402_1%  [R_0402]  274.6 70.27 270 top
RG527  40.2_0402_1%  [R_0402]  228.48 62.97 0 top
RG528  40.2_0402_1%  [R_0402]  231.85 62.97 180 top
RG529  0_0201_5%  [R_0201]  191.92 114.89 270 bottom
RG530  10K_0201_5%  [R_0201]  207.77 126.62 90 bottom
RG531  40.2_0402_1%  [R_0402]  200.15 88.76 270 bottom
RG532  40.2_0402_1%  [R_0402]  201.01 85.37 90 bottom
RG533  100K_0201_5%  [R_0201]  306.64 62.64 0 top
RG534  10K_0201_1%  [R_0201]  309.15 59.92 0 top
RG535  100K_0201_5%  [R_0201]  188.32 99.04 0 top
RG536  2.2K_0201_5%  [R_0201]  188.48 102.67 180 top
RG540  0_0201_5%  [R_0201]  208.45 127.21 270 bottom
RG541  10K_0402_5%  [R_0402]  290.25 84.93 180 bottom
RG542  10K_0402_5%  [R_0402]  289.96 89.14 0 bottom
RG543  10K_0402_5%  [R_0402]  290.6 83 180 bottom
RG544  10K_0402_5%  [R_0402]  287.96 81.12 270 bottom
RG545  2.2K_0201_1%  [R_0201]  278.74 156.96 0 top
RG549  100K_0402_5%  [R_0402]  280.73 165.24 0 top
RG550  39K_0402_1%  [R_0402]  276.55 166.69 270 top
RG551  0_0201_5%  [R_0201]  277.31 145.44 90 top
RG553  0_0201_5%  [R_0201]  212.11 156.8 0 top
RG554  0_0201_5%  [R_0201]  217.03 159.05 270 bottom
RG555  10K_0201_1%  [R_0201]  187.65 37.05 270 bottom
RG556  10K_0201_1%  [R_0201]  187.68 37.65 0 bottom
RG557  10K_0402_1%  [R_0402]  312.87 60.06 180 top
RG561  100K_0201_5%  [R_0201]  312.9 56.18 270 top
RG562  100K_0402_5%  [R_0402]  204.38 123.98 90 bottom
RG564  0_0201_5%  [R_0201]  221.18 113.19 0 top
RG565  0_0201_5%  [R_0201]  219.96 113.19 0 top
RG566  2.2K_0201_5%  [R_0201]  216.01 114.48 180 top
RG567  100K_0201_5%  [R_0201]  214.96 111.05 0 top
RG568  100K_0201_5%  [R_0201]  307.29 60.53 90 top
RG569  0_0201_5%  [R_0201]  215.43 115.05 0 top
RG570  0_0201_5%  [R_0201]  187.24 54.28 180 bottom
RG571  0_0201_5%  [R_0201]  187.24 55.05 180 bottom
RG572  0_0201_5%  [R_0201]  192.73 56.15 90 bottom
RG573  10K_0201_5%  [R_0201]  186.04 54.28 180 bottom
RG574  10K_0201_5%  [R_0201]  186.04 55.05 180 bottom
RG575  2.2K_0201_1%  [R_0201]  180.29 73.75 270 top
RG576  100K_0402_5%  [R_0402]  197.35 117.53 0 bottom
RG579  0_0402_5%  [R_0402]  215.18 117.67 90 top
RG580  0_0402_5%  [R_0402]  199.09 108.96 90 top
RG581  330_0402_1%  [R_0402]  216.23 156.28 180 top
RG582  0_0201_5%  [R_0201]  192.13 59 270 bottom
RH1  1K_0402_1%  [R_0402]  224.04 26.36 270 bottom
RH2  10K_0402_5%  [R_0402]  218.14 19.35 180 top
RH4  0_0402_5%  [R_0402]  220.75 17.07 180 top
RH5  1K_0402_5%  [R_0402]  213.8 45.79 270 bottom
RH6  0_0402_5%  [R_0402]  217.48 18.47 0 top
RH7  0_0402_5%  [R_0402]  217.84 16.36 180 top
RH9  100K_0402_5%  [R_0402]  210.26 39.41 90 top
RH11  10K_0402_5%  [R_0402]  218.42 22.08 270 top
RH12  0_0805_5%  [R_0805]  196.26 21.83 0 top
RH14  12.1_0402_1%  [R_0402]  206.31 40.31 0 top
RH15  30_0402_5%  [R_0402]  207.65 44.43 90 bottom
RH16  1K_0402_1%  [R_0402]  221.57 37.84 180 bottom
RH21  10K_0201_5%  [R_0201]  216 33.65 0 top
RH22  10K_0201_5%  [R_0201]  215.38 33.65 180 top
RH25  10K_0201_5%  [R_0201]  220.86 33.85 0 bottom
RH26  10K_0201_5%  [R_0201]  220.18 33.85 180 bottom
RH27  10K_0201_5%  [R_0201]  216 34.22 0 top
RH28  10K_0201_5%  [R_0201]  215.38 34.22 180 top
RH29  10K_0201_5%  [R_0201]  220.86 33.23 0 bottom
RH30  10K_0201_5%  [R_0201]  220.19 33.23 180 bottom
RH38  30_0402_5%  [R_0402]  213.95 48.83 225 bottom
RH39  30_0402_5%  [R_0402]  210.42 45.32 270 bottom
RH59  49.9_0402_1%  [R_0402]  129.87 111.28 180 bottom
RH63  150K_0402_1%  [R_0402]  219.91 24.49 90 bottom
RH70  10M_0402_5%  [R_0402]  212.28 15.29 0 bottom
RH71  2.7K_0402_1%  [R_0402]  201.49 43.35 90 bottom
RH72  1M_0402_5%~D  [R_0402]  193.51 45.32 0 bottom
RH73  12.1_0402_1%  [R_0402]  208.54 44.43 90 bottom
RH75  1K_0402_5%  [R_0402]  220.82 24.6 180 top
RH78  1K_0402_5%  [R_0402]  220.82 23.71 180 top
RH79  620_0402_5%  [R_0402]  204.67 43.92 90 bottom
RH83  20K_0402_5%~D  [R_0402]  213.52 17.49 90 top
RH84  20K_0402_5%~D  [R_0402]  214.49 15.95 0 top
RH85  8.2K_0402_5%  [R_0402]  215.32 27.35 0 top
RH88  10K_0402_5%  [R_0402]  220.75 16.18 180 top
RH89  22_0402_5%  [R_0402]  216.94 23.49 180 top
RH90  100K_0402_5%  [R_0402]  216.37 17.96 90 top
RH91  33_0201_5%  [R_0201]  192.63 44.58 0 bottom
RH92  33_0201_5%  [R_0201]  194.38 44.58 180 bottom
RH95  4.7K_0402_5%  [R_0402]  209.6 28.82 0 top
RH99  100K_0402_5%  [R_0402]  201.63 13.52 180 bottom
RH100  4.7K_0402_5%  [R_0402]  200.92 14.46 90 bottom
RH104  15_0402_1%  [R_0402]  225.45 21.27 135 bottom
RH109  113_0402_1%  [R_0402]  190.1 43.84 270 bottom
RH111  10K_0402_5%~D  [R_0402]  215.32 26.46 0 top
RH130  4.7K_0402_5%~D  [R_0402]  216.24 28.21 180 top
RH135  10K_0402_5%  [R_0402]  220.95 32.92 180 top
RH148  121_0402_1%  [R_0402]  172.88 92.18 180 bottom
RH149  75_0402_1%  [R_0402]  169.16 91.65 90 bottom
RH150  100_0402_1%  [R_0402]  168.27 91.65 90 bottom
RH151  100_0402_1%  [R_0402]  126.73 120.61 0 bottom
RH152  56.2_0402_1%  [R_0402]  126.73 121.57 0 bottom
RH153  220_0402_5%  [R_0402]  126.73 122.52 0 bottom
RH154  60.4_0402_1%  [R_0402]  174.26 102.53 90 top
RH155  20_0402_5%  [R_0402]  126.73 118.58 0 bottom
RH156  51_0402_5%  [R_0402]  128.95 116.68 0 bottom
RH158  499_0402_1%  [R_0402]  128.96 118.16 0 bottom
RH163  1K_0402_5%  [R_0402]  167.94 117.18 180 top
RH164  1K_0402_5%  [R_0402]  174.26 100.75 90 top
RH165  1K_0402_5%  [R_0402]  126.73 117.63 0 bottom
RH167  30_0402_5%  [R_0402]  209.53 44.4 90 bottom
RH168  10K_0402_5%  [R_0402]  212.48 41.66 90 top
RH180  10K_0402_5%  [R_0402]  216.67 46.14 270 bottom
RH181  20K_0402_1%  [R_0402]  215.78 47.02 0 bottom
RH182  20K_0402_1%  [R_0402]  215.78 46.14 270 bottom
RH184  1K_0402_5%  [R_0402]  133.33 113.97 180 top
RH185  1K_0402_5%  [R_0402]  129.87 107.22 180 bottom
RH186  1K_0402_5%  [R_0402]  134.77 107.59 180 top
RH187  1K_0402_5%  [R_0402]  129.87 108.17 180 bottom
RH188  1K_0402_5%  [R_0402]  129.87 109.12 180 bottom
RH192  30_0402_5%  [R_0402]  175.78 111.91 180 top
RH193  100_0402_1%  [R_0402]  190.56 35.49 0 bottom
RH197  100_0402_1%  [R_0402]  155.59 124.31 90 bottom
RH199  100K_0402_5%  [R_0402]  219.33 36.88 0 top
RH201  100_0402_1%  [R_0402]  173.37 126.11 270 bottom
RH203  100_0402_1%  [R_0402]  151.4 125.22 270 bottom
RH206  1K_0402_1%~D  [R_0402]  153.56 54.06 270 top
RH207  1K_0402_1%~D  [R_0402]  152.66 41.22 0 top
RH209  1K_0402_1%~D  [R_0402]  155.34 53.15 90 top
RH210  1K_0402_1%~D  [R_0402]  154.44 40.33 0 top
RH211  24.9_0402_1%  [R_0402]  154.45 56.28 270 top
RH212  24.9_0402_1%  [R_0402]  154.44 39.38 0 top
RH213  150_0402_1%  [R_0402]  222.34 42.35 180 bottom
RH214  200_0402_1%  [R_0402]  218.12 40.44 0 top
RH215  200_0402_1%  [R_0402]  218.12 41.39 0 top
RH216  200_0402_1%  [R_0402]  219.62 42.32 0 bottom
RH218  10K_0402_5%  [R_0402]  211.15 37.42 270 top
RH453  10K_0402_5%  [R_0402]  220.71 17.96 90 top
RH460  1K_0402_5%  [R_0402]  221.13 30.57 180 bottom
RH461  1K_0402_5%  [R_0402]  221.13 29.71 180 bottom
RH462  1K_0402_5%  [R_0402]  221.19 30.66 180 top
RH463  1K_0402_5%  [R_0402]  221.19 29.77 180 top
RH466  100_0402_1%  [R_0402]  153.73 125.14 270 bottom
RH469  100_0402_1%  [R_0402]  172.48 126.11 270 bottom
RH472  100_0402_1%  [R_0402]  152.84 125.14 270 bottom
RH484  2_0402_1%  [R_0402]  156.23 54.06 270 top
RH485  2_0402_1%  [R_0402]  152.66 40.33 0 top
