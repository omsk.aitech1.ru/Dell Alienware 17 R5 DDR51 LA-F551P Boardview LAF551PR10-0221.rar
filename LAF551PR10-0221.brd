# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_DP_P1_C: length 10.8
  TOP w0.107: JDP.9 234.95,175.12 234.95,173.71 236.46,172.19 238.55,172.19 239.83,170.92 241.1,170.92 241.82,170.2 241.82,170.04 241.67,169.89 CV28.2
GPU_DP_P2: length 102.9
  IN6 w0.089: v2(227.77,113.05) 227.94,113.22 228.13,113.22 228.34,113.43 228.34,118.42 226.61,120.14 226.61,121.51 226.63,121.52 226.63,121.6 226.64,121.61 226.64,122.4 226.61,122.42 226.61,123.25 223.35,126.51 222.59,126.51 214.42,134.68 214.39,134.68 214.37,134.71 209.02,134.71 206.23,137.5 206.23,142.77 205.57,143.43 205.57,148.75 208.88,152.06 208.88,155.37 211.67,158.17 211.67,158.38 211.85,158.56 212.19,158.56 212.52,158.89 212.52,159.23 212.9,159.6 215.13,159.6 215.49,159.97 216.08,159.97 216.76,160.65 220.4,160.65 221.02,161.27 221.4,161.27 222.28,162.15 222.28,162.45 222.56,162.73 222.56,164.72 223.35,165.51 223.35,166.94 224.67,168.26 227.82,168.26 229.12,169.56 230.51,169.56 231.81,168.26 232.79,168.26 233.79,167.26 233.79,166.23 234.47,165.54 237.61,165.54 239.48,167.41 240.25,167.41 v2(240.67,166.99)
  BOTTOM w0.101: UG9.BE14 v2(227.77,113.05)
  BOTTOM w0.107: CV32.1 241.43,168.27 241.43,167.5 241.12,167.19 240.87,167.19 v2(240.67,166.99)
GPU_DP_P2_C: length 8.9
  BOTTOM w0.107: CV32.2 241.49,169.22 241.49,169.61 238.65,172.44 238.65,174.26 238.01,174.9 237.26,174.9 JDP.15
GPU_DP_P3: length 97.3
  IN6 w0.089: v2(227.68,115.59) 227.68,115.84 227.59,115.93 227.36,115.93 227.28,115.84 227.28,115.32 227.19,115.23 226.97,115.23 226.58,115.62 226.58,117.84 225.12,119.3 225.12,120.63 225.94,121.46 225.94,123.02 224.4,124.56 223.64,124.56 214.16,134.05 208.12,134.05 205.6,136.57 205.6,142.41 204.87,143.14 204.87,148.93 204.94,148.99 204.94,149.01 208.25,152.33 208.25,155.64 211.04,158.43 211.04,160.05 211.5,160.51 212.57,160.51 214.07,162.01 218.75,162.01 221.04,164.3 221.04,165.53 224.41,168.89 227.52,168.89 229.05,170.42 231.59,170.42 233.69,168.33 234.28,168.33 235.09,167.52 235.09,167.1 v2(234.7,166.72)
  BOTTOM w0.101: v2(227.68,115.59) 227.82,115.45 UG9.BH14
  BOTTOM w0.107: CV29.1 234.9,169.18 234.9,166.91 v2(234.7,166.72)
GPU_DP_P3_C: length 2.7
  BOTTOM w0.107: CV29.2 234.95,170.2 234.95,171.16 234.77,171.33 JDP.10
GPU_FAN_FB: length 64.9
  TOP w0.102: RF4.1 287.69,74.2 288.11,73.78 290.95,73.78 DF2.2 291.05,74.69 v2(291.15,74.79)
  TOP w0.107: v2(296.3,40.44) 296.3,39.67 295.02,38.4 295.02,37.49 294.52,36.98 293.1,36.98 292.49,36.38 292.49,35.37 293.19,34.67 293.19,30.9 294.66,29.43 294.66,27.02 294.34,26.69 UE5.29
  BOTTOM w0.102: v2(296.3,40.44) 296.3,40.42 296.27,40.42 296.27,40.47 296.66,40.85 296.66,40.99 296.89,41.23 297.04,41.23 297.23,41.42 298.42,41.42 298.97,41.96 298.97,47.55 299.49,48.07 299.49,58.72 299.36,58.85 299.36,63.51 298.76,64.11 298.76,68.55 295.85,71.46 294.48,71.46 v1(291.95,74) v2(291.15,74.79)
GPU_FAN_PWM: length 66.6
  TOP w0.102: RF5.1 287.94,76.74 289.53,76.74 v2(289.62,76.83) JFAN2.2
  TOP w0.107: UE5.27 295.14,26.66 295.33,26.85 295.33,29.55 294.84,30.04 294.84,31.8 294.06,32.58 294.06,34.13 292.72,35.46 292.72,36.13 293.33,36.73 294.6,36.73 295.26,37.39 295.26,38.31 296.95,40 v1(296.95,40.33) 296.95,40.36 296.65,40.65 296.65,40.72 v2(296.22,41.15)
  BOTTOM w0.102: v2(289.62,76.83) 289.62,75.75 294.13,71.23 295.75,71.23 298.53,68.45 298.53,64.01 299.13,63.41 299.13,58.75 299.26,58.63 299.26,48.17 298.74,47.65 298.74,42.06 298.33,41.65 296.74,41.65 296.25,41.15 v2(296.22,41.15)
GPU_GC6_FB_EN: length 317.8
  TOP w0.102: v2(310.31,61.42) 310.31,62.13 310.55,62.38 UG27.1 ; v2(308.66,56.8) 308.66,55.54 308.92,55.27 309.28,55.27 309.53,55.02 QG511.3 ; v2(210.87,156.58) 211.16,156.29 211.91,156.29 212.11,156.49 RG553.1
  IN1 w0.102: v2(226.58,27.36) 226.07,27.36 222.64,30.79 222.64,32.69 222.36,32.97 221.52,32.97 219.82,34.67 219.82,35.33 219.29,35.86 219.29,42.8 220.23,43.74 220.23,44.92 215.64,49.5 215.64,51.13 212.46,54.3 212.46,60.62 v2(212.01,61.08) ; v2(308.66,56.8) 309.08,56.8 310.35,58.07 310.35,59.17 309.75,59.77 309.75,60.54 310.28,61.08 310.28,61.4 v2(310.31,61.42)
  IN3 w0.102: v2(212.01,61.08) 206.9,55.97 v2(206.54,55.97)
  IN4 w0.102: v2(310.31,61.42) 310.31,61.32 309.75,60.76 309.75,60.61 309.65,60.51 298.08,60.51 296.37,58.8 296.37,51.85 295.36,50.84 273.47,50.84 271.7,52.62 262.54,52.62 262.09,52.16 251.08,52.16 250.88,52.35 240.66,52.35 240.28,52.73 238.26,52.73 237.85,52.33 233.92,52.33 233.49,52.77 233.49,53.15 232.1,54.54 230.99,54.54 230.43,53.98 226.44,53.98 225.16,52.7 222.34,52.7 222.08,52.97 214.54,52.97 213.98,53.53 213.98,56.79 211.62,59.15 211.62,60.68 v2(212.01,61.08) 211.98,61.1 211.98,66.9 212.31,67.22 212.31,107.46 214.08,109.24 214.99,109.24 v2(215.21,109.46) 215.21,112.46 214.23,113.44 214.23,114.21 214.61,114.59 215.04,114.59 215.73,115.28 215.73,119.74 216.44,120.45 216.44,125.98 215.82,126.61 212.05,126.61 208.94,129.72 208.51,129.72 207.65,130.58 207.65,132.61 209.47,134.42 209.47,142.54 206.14,145.87 206.14,154.24 207.31,155.4 209.71,155.4 210.87,156.56 v2(210.87,156.58)
  BOTTOM w0.089: UG9.BB5 221.43,110.91 221.43,110.29 221.31,110.16 220.8,110.16 220.61,109.97 220.61,109.88 220.19,109.46 v1(216.1,109.46) v2(215.21,109.46)
  BOTTOM w0.102: UG31.6 192.14,54.88 194.23,52.79 194.23,51.9 194.76,51.36 199.66,51.36 203.28,54.98 206.07,54.98 206.54,55.46 v2(206.54,55.97) ; v2(226.58,27.36) 226.3,27.08 RG22.1
GPU_HDMI_CLKN: length 91.1
  IN1 w0.076: v2(229.87,113.75) 229.87,113.64 229.99,113.51 230.21,113.51 230.33,113.63 230.33,116.51 229.37,117.47 229.37,122.26 225.47,126.16 217.32,126.16 216.9,126.58 213.1,126.58 212.57,127.12 211.71,127.12 210.84,127.98 210.38,127.98 209.32,129.04 207.84,129.04 207.26,129.62 207.26,131.3 208.13,132.17 208.13,142.95 207.49,143.59 206.17,143.59 205,144.76 205,148.09 208.57,151.66 208.57,156.11 208.89,156.43 208.89,157.4 208.98,157.5 208.98,159.5 208.41,160.07 208.41,165.08 208.19,165.3 208.19,166.18 209.27,167.26 216.22,167.26 218.17,165.3 219.41,165.3 v2(219.49,165.38)
  BOTTOM w0.089: v2(219.49,165.38) 219.49,165.32 219.38,165.21 219.2,165.21 218.87,164.89 218.18,164.89 218.09,164.98 218.09,165.23 218.29,165.44 CV1057.2
  BOTTOM w0.101: UG9.BF17 v2(229.87,113.75)
GPU_HDMI_CLKP: length 91.1
  IN1 w0.076: v2(229.87,113.05) 229.87,113.19 229.97,113.29 230.31,113.29 230.55,113.54 230.55,116.6 229.59,117.56 229.59,122.35 225.56,126.38 217.42,126.38 216.99,126.81 213.2,126.81 212.66,127.34 211.8,127.34 210.94,128.21 210.47,128.21 209.42,129.26 207.94,129.26 207.48,129.72 207.48,131.21 208.35,132.08 208.35,143.04 207.58,143.81 206.26,143.81 205.23,144.85 205.23,148 208.79,151.57 208.79,156.02 209.11,156.33 209.11,157.31 209.21,157.41 209.21,159.59 208.64,160.16 208.64,165.17 208.42,165.4 208.42,166.09 209.36,167.03 216.12,167.03 218.08,165.08 219.16,165.08 219.36,164.87 v2(219.36,164.81)
  BOTTOM w0.089: CV1058.2 217.85,165.34 217.85,164.88 218.08,164.65 v4(218.63,164.65) 218.97,164.65 219.14,164.81 v2(219.36,164.81)
  BOTTOM w0.101: UG9.BE17 v2(229.87,113.05)
GPU_HDMI_CTRL_CLK: length 63
  IN4 w0.102: v2(220.25,161.33) 220.25,161.46 220.13,161.57 219.72,161.57 218.27,160.12 218.27,159.63 217.37,158.73 214.01,158.73 212.58,157.3 212.58,156.24 210.07,153.72 210.07,149.54 209.91,149.38 209.91,148.99 210.64,148.26 210.64,134.87 213.11,132.4 213.11,131.63 222.36,122.38 222.39,122.38 223.1,121.67 223.37,121.67 v2(223.59,121.9)
  BOTTOM w0.101: UG9.BK9 224.89,117.17 224.89,117.79 225.12,118.02 v4(225.12,120.82) 225.12,121.24 224.47,121.88 223.61,121.88 v2(223.59,121.9)
  BOTTOM w0.102: v2(220.25,161.33) 219.94,161.64 219.31,161.64 RV648.2 217.38,160.93 217.16,161.15 QV96.4
GPU_HDMI_CTRL_DAT: length 69
  IN4 w0.102: v2(220.25,161.96) 220.09,161.8 219.63,161.8 218.04,160.22 218.04,159.72 217.27,158.96 213.91,158.96 212.35,157.39 212.35,156.33 209.84,153.82 209.84,149.63 209.69,149.48 209.69,148.89 210.41,148.17 210.41,134.77 212.89,132.3 212.89,131.54 222.23,122.19 222.31,122.19 223.02,121.48 223.47,121.48 v2(223.59,121.35)
  BOTTOM w0.101: v2(223.59,121.35) 223.59,121.38 223.89,121.67 224.39,121.67 224.91,121.15 224.91,118.11 224.67,117.87 224.44,117.87 224.25,117.68 224.25,117.4 224.32,117.33 224.47,117.33 224.57,117.43 UG9.BL9
  BOTTOM w0.102: v2(220.25,161.96) 220.82,162.54 220.82,162.93 220.91,163.02 220.91,163.58 220.62,163.87 218.86,163.87 218.77,163.96 218.17,163.96 217.75,164.38 216.14,164.38 215.86,164.1 QV96.1 215.73,163.24 214.96,163.24 RV652.2
GPU_HDMI_HPD#: length 157.8
  TOP w0.102: QV97.6 217.88,159.13 v2(217.88,158.12) ; v1(235.88,157.23) v2(235.88,156.65)
  IN4 w0.089: 220.1,122.36 219.53,121.78
  IN4 w0.102: 219.53,121.78 216.94,119.19 216.94,118.72 216.94,118.22 217.27,117.88 217.27,116.85 217.77,116.36 217.77,115.48 217.67,115.38 216.77,115.38 216.19,114.8 216.19,113.1 217.32,111.97 217.62,111.97 218.11,111.48 218.11,109.95 v2(218.07,109.92) ; 220.1,122.36 220.35,122.61 220.95,122.61 222.26,121.3 222.26,120.77 223.44,119.59 225.4,119.59 225.91,120.1 225.91,121.96 229.67,125.72 236.02,125.72 239.15,128.86 261.9,128.86 264.65,131.61 268.59,131.61 269.55,132.58 269.55,144.77 264.07,150.25 257.23,150.25 255.71,148.73 253.12,148.73 251.89,149.96 244.69,149.96 243.11,151.54 241.15,151.54 239.94,152.75 238.01,152.75 237.6,153.17 237.6,155.15 236.11,156.65 v2(235.88,156.65)
  BOTTOM w0.1: UG9.BA4 220.82,110.55 220.5,110.23 218.39,110.23 v2(218.07,109.92)
  BOTTOM w0.102: RX7.2 213.5,158.18 213.5,157.58 213.73,157.36 215.27,157.36 216,158.08 217.84,158.08 v2(217.88,158.12) 218.32,157.67 218.32,156.84 219.05,156.11 231.48,156.11 232.01,156.65 v2(235.88,156.65)
GPU_HDMI_TX_N0: length 81.9
  IN1 w0.076: v2(214.25,165.93) 214.25,165.75 214.15,165.66 213.96,165.66 213.49,166.13 209.77,166.13 209.09,165.45 209.09,160.35 209.67,159.78 209.67,157.22 209.57,157.12 209.57,156.14 209.25,155.83 209.25,151.38 205.68,147.81 205.68,145.09 206.5,144.27 207.77,144.27 208.81,143.23 208.81,131.89 207.94,131.02 207.94,130.01 208.23,129.72 210.07,129.72 211.96,127.83 216.65,127.83 217.65,126.84 225.75,126.84 230.05,122.54 230.05,119.07 230.72,118.41 230.72,115.43 230.81,115.33 230.81,114.82 231.17,114.46 v2(231.17,114.35)
  BOTTOM w0.089: v2(214.25,165.93) 214.25,165.84 213.85,165.44 213.85,165.22 213.6,164.98 213.47,164.98 213.29,165.16 213.29,165.29 CV1060.2
  BOTTOM w0.101: UG9.BF18 v2(231.17,114.35)
GPU_HDMI_TX_N1: length 81.4
  IN1 w0.076: v2(216.85,165.6) 216.85,165.5 216.77,165.42 215.4,165.42 214.74,164.76 213.84,164.76 213.16,165.44 210.47,165.44 210.13,165.1 210.13,163.86 209.77,163.5 209.77,161.01 210.78,160.01 210.78,157.37 210.25,156.84 210.25,155.86 209.93,155.55 209.93,151.1 206.36,147.53 206.36,145.43 206.84,144.95 208.55,144.95 209.89,143.61 209.89,131.53 212.46,128.96 216.8,128.96 218.23,127.52 226.04,127.52 230.73,122.83 230.73,120.51 231.97,119.27 231.97,116.58 231.78,116.39 231.78,116.13 231.54,115.89 231.54,115.53 231.97,115.1 v2(231.97,115.05)
  BOTTOM w0.089: v2(216.85,165.6) 216.85,165.34 216.76,165.25 216.67,165.25 216.51,165.09 215.83,165.09 215.74,165.18 215.74,165.31 CV1062.2
  BOTTOM w0.101: UG9.BG20 232.27,114.87 232.09,115.05 v2(231.97,115.05)
GPU_HDMI_TX_N2: length 75.1
  IN1 w0.076: v2(211.77,164.72) 211.77,164.72 211.77,164.51 211.64,164.38 211.31,164.38 211.24,164.31 211.1,164.17 211.1,163.46 211.73,162.84 212.6,162.84 212.7,162.74 212.7,161.82 213.03,161.5 213.03,160.49 212.61,160.08 212.61,156.4 211.24,155.02 211.24,153.19 211.24,153.19 211.24,150.57 210.61,149.94 210.08,149.94 209.36,149.22 209.36,145.29 210.57,144.08 210.57,131.81 212.59,129.78 217.24,129.78 218.82,128.2 226.32,128.2 231.76,122.76 231.76,120.79 232.58,119.98 232.58,113.63 232.48,113.53 232.19,113.53 v2(231.97,113.75)
  BOTTOM w0.089: v2(211.77,164.72) 211.79,164.7 211.79,164.44 211.57,164.22 211.22,164.22 211,164.45 211,164.74 210.87,164.87 210.87,165.28 CV1064.2
  BOTTOM w0.101: UG9.BF20 v2(231.97,113.75)
GPU_HDMI_TX_P0: length 81.9
  IN1 w0.076: v2(231.17,115.05) 231.17,114.81 231.25,114.74 231.49,114.74 231.56,114.81 231.56,115.16 231.28,115.44 231.02,115.44 230.94,115.52 230.94,118.5 230.27,119.17 230.27,122.64 225.85,127.07 217.74,127.07 216.75,128.06 212.05,128.06 210.17,129.94 208.32,129.94 208.16,130.1 208.16,130.93 209.03,131.8 209.03,143.32 207.86,144.49 206.6,144.49 205.91,145.18 205.91,147.72 209.48,151.29 209.48,155.73 209.79,156.05 209.79,157.03 209.89,157.12 209.89,159.87 209.32,160.44 209.32,165.36 209.86,165.9 213.39,165.9 213.86,165.43 214.11,165.43 214.25,165.29 v2(214.25,165.26)
  BOTTOM w0.089: CV1059.2 212.99,165.41 212.99,165.12 213.11,164.99 213.12,164.99 213.37,164.74 213.7,164.74 214.22,165.26 v2(214.25,165.26)
  BOTTOM w0.101: UG9.BG18 v2(231.17,115.05)
GPU_HDMI_TX_P1: length 81.4
  IN1 w0.076: v2(216.84,164.85) 216.91,164.92 216.91,165.12 216.83,165.2 215.5,165.2 214.83,164.54 213.75,164.54 213.07,165.22 210.56,165.22 210.35,165.01 210.35,163.77 210,163.41 210,161.11 211,160.1 211,157.27 210.47,156.74 210.47,155.77 210.16,155.45 210.16,151 206.59,147.44 206.59,145.52 206.93,145.17 208.65,145.17 210.11,143.71 210.11,131.62 212.55,129.18 216.89,129.18 218.33,127.75 226.13,127.75 230.95,122.92 230.95,120.6 232.2,119.36 232.2,116.49 232,116.29 232,116.19 232.29,115.9 232.29,115.49 232.21,115.41 231.98,115.41 231.9,115.49 v2(231.9,115.73)
  BOTTOM w0.089: CV1061.2 215.5,165.3 215.5,165.08 215.73,164.85 v2(216.84,164.85)
  BOTTOM w0.101: UG9.BH20 232.03,115.69 231.94,115.69 v2(231.9,115.73)
GPU_HDMI_TX_P2: length 75.1
  IN1 w0.076: v2(231.97,113.05) 232.22,113.31 232.57,113.31 232.8,113.53 232.8,120.07 231.98,120.89 231.98,122.86 226.41,128.43 218.92,128.43 217.34,130.01 212.69,130.01 210.79,131.9 210.79,144.17 209.58,145.38 209.58,149.12 210.17,149.72 210.71,149.72 211.46,150.47 211.46,153.28 211.46,153.28 211.46,154.93 212.84,156.3 212.84,159.99 213.25,160.4 213.25,161.59 212.92,161.91 212.92,162.83 212.7,163.06 211.82,163.06 211.32,163.56 211.32,164.08 211.4,164.15 211.69,164.15 211.77,164.08 211.77,163.87 v2(211.78,163.87)
  BOTTOM w0.089: v2(211.78,163.87) 211.67,163.98 211.12,163.98 210.76,164.35 210.76,164.64 210.63,164.77 210.63,165.39 CV1063.2
  BOTTOM w0.101: UG9.BE20 v2(231.97,113.05)
GPU_INV_PWM: length 47.8
  TOP w0.089: v2(224.3,112.55) v1(223.66,112.55)
  TOP w0.102: RG150.1 188.85,104.23 UG24.5 188.85,101.61 v2(188.31,101.08)
  IN6 w0.102: v2(224.3,112.55) 223.43,112.55 223.08,112.89 219.4,112.89 218.51,112 218.51,109.84 214.56,105.88 209.93,105.88 207.09,103.05 196.99,103.05 196.64,103.39 191.21,103.39 188.89,101.08 v2(188.31,101.08)
  BOTTOM w0.089: v2(224.3,112.55) 223.27,112.55 UG9.BD7
GPU_LPC: length 17
  IN1 w0.254: v2(275.17,144.31) 275.17,144.04 277.96,141.25 277.96,137.82 278.99,136.79 278.99,135.97 279.37,135.59 281.35,135.59 v2(281.82,136.06)
  BOTTOM w0.102: v2(281.82,136.06) 281.75,136.06 v1(281.34,136.48)
  BOTTOM w0.203: v2(275.17,144.31) 275.21,144.28 PU6000.35
  BOTTOM w0.254: PR6052.1 282.43,135.18 PR6062.2 v2(281.82,136.06)
GPU_OVERT#: length 632.4
  TOP w0.102: v2(327.92,44.89) 328.75,44.89 328.8,44.83 UE6.21 ; QG502.3 213.35,157.92 213.98,157.29 v2(213.98,156.71) ; UG23.6 309.74,60.6 RG534.2 309.74,59.81 310.13,59.41 310.13,58.48 309.82,58.17 309.82,57.72 309.1,57 v2(309.1,55.73) ; DG3.1 281.73,173.33 v2(281.73,173.07)
  TOP w0.107: v2(289.19,14.34) 289.06,14.21 RE102.1
  IN1 w0.102: v2(213.98,156.71) 213.69,156.42 213.69,155.79 212.56,154.67 212.56,153.45 213.88,152.14 224.7,152.14 224.98,152.42 227.34,152.42 227.62,152.14 238.95,152.14 239.32,152.5 241.77,152.5 241.91,152.37 251.69,152.37 252.4,153.07 252.4,155.42 253.57,156.59 264.17,156.59 265.13,155.63 270.39,155.63 271.12,154.91 273.72,154.91 274.49,155.67 279.9,155.67 v2(282.75,158.51) 283.73,159.49 283.73,168.94 281.73,170.93 v2(281.73,173.07)
  IN2 w0.102: v2(327.92,44.89) 327.99,44.95 327.99,49.43 326.56,50.85 322.72,50.85 322.13,51.44 319.47,51.44 318.72,52.19 312.64,52.19 v2(309.1,55.73) 308.18,56.65 308.18,58.57 306.11,60.65 301.05,60.65 300.27,61.42 300.27,63.55 299.47,65.62 299.47,70.98 294.97,75.48 294.97,79.74 294.97,79.75 295.22,81.46 295.35,82.31 292.6,87.95 289.56,93.72 288.2,98.31 288.2,98.48 288.2,98.49 288.2,143.32 282.75,148.76 v2(282.75,158.51)
  IN3 w0.102: v2(289.19,14.34) 290.65,14.34 291.22,13.77 291.22,10.07 293.58,7.71 298.22,7.71 298.95,6.98 304.97,6.98 307.78,9.79 312.18,9.79 315.87,13.48 315.87,15.1 316.4,15.63 316.4,15.64 317.27,16.5 317.27,16.91 319.66,19.3 319.66,19.37 321.95,21.67 321.95,26.22 322.02,26.28 322.02,29.97 327.03,34.97 327.03,37.76 328.43,39.17 328.43,41.58 329.23,42.38 329.23,44.59 328.94,44.89 v2(327.92,44.89)
  IN4 w0.102: v2(202.66,120.44) 202.66,110.13 204.25,108.55 204.25,105.53 204.69,105.08 206.19,105.08 208.14,103.14 208.14,70.23 207.12,69.21 207.12,58.11 207.65,57.58 207.65,55.97 210.07,53.55 210.07,49.83 211.56,48.33 213.48,48.33 214.6,47.21 214.6,46.52 214.8,46.32 223.38,46.32 223.74,46.69 228.88,46.69 229.24,46.32 237.47,46.32 238.27,47.12 246.62,47.12 248.17,45.57 259.63,45.57 260.21,45 266.55,45 273.58,37.97 276.02,37.97 278.9,40.85 286.94,40.85 288.84,38.94 296.3,38.94 297.77,38.94 298.56,39.73 298.56,40.84 299.58,41.86 311.45,41.86 312.35,42.76 318.9,42.76 319.15,42.51 323.52,42.51 323.86,42.85 325.64,42.85 326.86,44.07 327.11,44.07 327.33,44.29 327.33,44.29 327.57,44.53 327.57,44.53 v2(327.92,44.89)
  BOTTOM w0.102: UG31.4 192.92,55.68 193.29,56.05 193.29,58.59 193.5,58.8 193.52,58.85 193.52,59.24 194.03,59.75 194.03,59.95 194.38,60.31 194.38,62.43 192.71,64.1 190.19,64.1 189.39,64.9 188.42,64.9 187.59,65.73 187.59,66.8 187.97,67.19 187.97,84.7 188.41,85.14 188.41,99.62 186.86,101.18 182.48,101.18 181.87,101.78 181.87,104.45 185.14,107.71 185.14,114.8 183.61,116.32 183.61,119.78 188.67,124.83 196.16,124.83 196.99,124.01 196.99,122.46 197.09,122.36 197.1,122.36 197.31,122.14 199.23,122.14 199.46,121.91 199.46,120.96 199.65,120.77 199.65,119.31 v1(200.38,118.58) 200.54,118.42 202.07,118.42 202.7,119.05 202.7,119.34 QG501.6 202.83,120.44 v2(202.66,120.44)
GPU_PEX_RST_HOLD#: length 24.4
  IN1 w0.081: v2(201.7,119.15) 204.63,116.22 209.14,116.22 209.88,115.48 211.76,115.48 212.45,116.18 213.1,116.18 213.27,116.36 215.76,116.36 216.74,115.37 217.46,115.37 218.06,114.77 219.95,114.77 220.06,114.66 v2(220.06,114.38)
  BOTTOM w0.109: v2(220.06,114.38) 220.37,114.69 UG9.BG3
  BOTTOM w0.114: RG14.1 200.39,119.65 200.89,119.15 v2(201.7,119.15)
GPU_PH1: length 28.6
  IN1 w0.508: v2(271.65,133.34) 271.65,132.85 271.14,132.34 267.09,132.34 266.58,132.85 266.58,144.71 263.88,147.41 261.66,147.41 260.8,146.55 258.52,146.55 v2(258.07,146.99)
  BOTTOM w0.508: PR6026.1 v2(271.65,133.34)
  vias: v1(258.48,146.69) v2(257.44,146.99)
GPU_PH2: length 43
  IN1 w0.508: v2(244.36,146.87) 244.36,147.98 245.23,148.86 251.97,148.86 252.92,147.91 256.3,147.91 257.25,148.86 264.26,148.86 267.29,145.84 268.04,145.84 268.55,145.33 268.55,140.88 269.38,140.05 269.38,135.8 270.84,134.35 272.09,134.35 272.6,133.84 v2(272.6,133.34)
  BOTTOM w0.508: PR6027.1 v2(272.6,133.34)
  vias: v1(244.78,146.56) v2(243.72,146.87)
GPU_PH3: length 60.1
  TOP w0.102: v1(229.28,146.62) 229.49,146.42 229.83,146.42
  IN1 w0.508: v2(230.51,146.8) 230.51,148.23 231.78,149.5 237.24,149.5 238.93,147.81 243.28,147.81 244.97,149.5 252.24,149.5 253.19,148.55 256.03,148.55 256.98,149.5 264.52,149.5 267.55,146.47 268.35,146.47 269.19,145.63 269.19,141.14 270.02,140.31 270.02,136.06 270.96,135.12 272.5,135.12 273.57,134.05 v2(273.57,133.91)
  BOTTOM w0.508: PR6028.1 v2(273.57,133.91)
  vias: v2(229.88,146.8)
GPU_PH4: length 83
  IN1 w0.508: v2(274.46,133.91) 274.46,134.06 272.76,135.75 271.23,135.75 270.65,136.33 270.65,140.57 269.82,141.41 269.82,145.9 268.61,147.11 267.81,147.11 264.38,150.54 264.38,151.33 263.2,152.52 253.03,152.52 252.64,152.12 252.64,151.11 251.66,150.13 244.71,150.13 243.02,148.44 239.2,148.44 237.51,150.13 231.52,150.13 229.55,148.16 225.69,148.16 224.35,149.5 217.78,149.5 216.8,148.52 v2(216.8,146.8)
  BOTTOM w0.508: 213.06,144.43 211.07,142.43 PR6213.1 ; PR6030.1 v2(274.46,133.91)
GPU_PROG1: length 14
  IN1 w0.254: v2(279.66,133.91) 279.2,133.44 277.99,133.44 276,135.44 274.33,135.44 272.37,137.4 272.37,138.27 271.55,139.09 v2(271.5,139.09)
  BOTTOM w0.203: v2(271.5,139.09) 271.63,139.09 272.01,139.47 PU6000.24
  BOTTOM w0.254: PR6046.1 279.66,133.91 v2(279.66,133.91) PR6056.2
GPU_PROG2: length 16.5
  IN1 w0.254: v2(271.5,138.45) 271.64,138.45 271.99,138.11 271.99,137.25 274.18,135.06 275.84,135.06 277.83,133.06 280.02,133.06 v2(280.87,133.91)
  BOTTOM w0.102: v1(282.05,133.3) PR6050.1
  BOTTOM w0.203: PU6000.23 272.19,139.07 271.57,138.45 v2(271.5,138.45)
  BOTTOM w0.254: PR6050.1 v2(280.87,133.91) PR6057.2
GPU_PROG3: length 20
  IN1 w0.254: v2(283.94,140.39) 283.94,142.87 281.42,145.39 274.39,145.39 273.54,144.54 v2(273.54,144.22)
  BOTTOM w0.102: v2(283.94,140.39) v1(284.68,140.39)
  BOTTOM w0.203: v2(273.54,144.22) 273.54,144.12 274.41,143.26 PU6000.33
  BOTTOM w0.254: PR6047.1 282.43,138.87 PR6058.2 283.07,140.39 v2(283.94,140.39)
GPU_PROG4: length 19.3
  IN1 w0.254: v2(274.56,144.33) 274.58,144.35 274.58,144.4 275.1,144.92 277.77,144.92 278.38,144.31 278.38,137.94 279.27,137.05 280.86,137.05 280.98,136.92 281.57,136.92 281.82,137.18 v2(281.82,137.9)
  BOTTOM w0.102: v2(274.56,144.33) 274.58,144.35 274.58,144.54 v1(274.34,144.78)
  BOTTOM w0.203: v2(274.56,144.33) 274.56,144 274.81,143.75 PU6000.34
  BOTTOM w0.254: v2(281.82,137.9) PR6059.2 282.43,137.02 PR6051.1
GPU_PROG5: length 13.2
  IN1 w0.254: v2(271.5,140.36) 271.55,140.36 272.77,139.14 272.77,137.54 274.49,135.82 276.15,135.82 278.04,133.93 v2(278.44,133.93)
  BOTTOM w0.203: v2(271.5,140.36) 271.59,140.27 PU6000.26
  BOTTOM w0.254: PR6060.2 v2(278.44,133.93) PR6048.1
GPU_PROG6: length 1.7
  BOTTOM w0.203: PR6031.1 278.79,140.95 278.66,141.07 PU6000.3
GPU_PSI: length 6.4
  TOP w0.102: PR6041.2 277.49,143.24 v1(277.83,142.89)
  TOP w0.254: PR6037.1 276.87,144.67 v2(276.87,144.34) 276.87,143.75 276.65,143.53 PR6041.2
  BOTTOM w0.203: PU6000.37 276.01,143.45 276.87,144.31 v2(276.87,144.34) 276.87,144.69 PR6039.1
GPU_PWM1: length 46.5
  TOP w0.102: v1(281.73,137.29) 281.62,137.4 v2(281.19,137.4)
  TOP w0.254: PR6105.2 252.6,153.58 v2(253.06,154.04)
  IN2 w0.254: v2(253.06,154.04) 253.06,153.99 253.86,153.19 256.43,153.19 256.71,152.91 263.25,152.91 269.27,146.89 273.95,146.89 274.71,146.13 281.7,146.13 282.86,144.97 282.86,138.26 282,137.4 v2(281.19,137.4)
  BOTTOM w0.254: PR6043.1 v2(281.19,137.4)
  BOTTOM w0.305: PU6100.1 253.21,153.63 253.06,153.79 v2(253.06,154.04)
  BOTTOM w0.508: v2(253.06,154.04) 252.61,154.49 PR6102.1
GPU_PWM2: length 58.2
  TOP w0.102: v1(239.16,154.49) 239.16,154.48 239.15,154.47 v2(239.15,153.98)
  TOP w0.254: v2(239.15,153.98) 238.79,153.62 PR6112.2
  IN2 w0.254: v2(281.19,138.29) 282.48,139.59 282.48,144.81 281.54,145.75 274.56,145.75 273.79,146.51 269.12,146.51 263.3,152.33 256.37,152.33 255.95,152.75 240.95,152.75 240.5,153.2 239.88,153.2 239.15,153.93 v2(239.15,153.98)
  BOTTOM w0.254: PR6049.1 v2(281.19,138.29)
  BOTTOM w0.305: v2(239.15,153.98) 239.15,153.85 239.43,153.57 PU6101.1
  BOTTOM w0.508: PR6109.1 238.71,154.42 v2(239.15,153.98)
GPU_PWM3: length 70.2
  TOP w0.102: v2(225.43,153.91) 225.43,153.95 v1(224.98,154.41)
  TOP w0.254: v2(225.43,153.91) 225.09,153.57 PR6203.2
  IN2 w0.254: v2(225.43,153.91) 225.43,153.87 226.48,152.82 240.34,152.82 240.8,152.37 254.5,152.37 255.15,151.72 257.1,151.72 259,149.83 263.54,149.83 267.24,146.13 273.64,146.13 274.4,145.37 281.38,145.37 282.1,144.65 282.1,140.1 v2(281.19,139.18)
  BOTTOM w0.254: PR6054.1 v2(281.19,139.18)
  BOTTOM w0.305: PU6200.1 225.72,153.51 225.43,153.79 v2(225.43,153.91)
  BOTTOM w0.508: PR6200.1 225.43,154.6 v2(225.43,153.91)
GPU_PWM4: length 83.2
  TOP w0.102: PR6210.2 v1(212.82,153.1)
  TOP w0.254: PR6210.2 211.59,153.55 211.84,153.81 v2(211.86,153.81)
  IN2 w0.254: v2(281.19,140.07) 281.72,140.61 281.72,144.49 281.22,144.99 274.24,144.99 273.48,145.75 267.08,145.75 263.38,149.44 258.84,149.44 256.95,151.34 253.15,151.34 252.5,151.98 240.64,151.98 240.18,152.44 216.01,152.44 215.03,153.42 212.24,153.42 v2(211.86,153.81)
  BOTTOM w0.254: PR6055.1 v2(281.19,140.07)
  BOTTOM w0.305: 211.84,153.81 212.06,153.59 212.06,153.39 212.06,153.38 PU6201.1 ; 211.84,153.81 211.8,153.85 211.29,153.85 PR6207.1 ; 211.84,153.81 v2(211.86,153.81)
GPU_PWR_EN: length 24.7
  TOP w0.102: RG551.2 277.9,146.61 UG25.2 277.9,148.52 278.08,148.69 278.85,148.69 279.29,148.25 v1(280.54,148.25) 281.61,148.25 281.97,148.62 281.97,152.31 281.4,152.89 277.36,152.89 277.07,153.18 UG26.1 277.07,154.67 277.58,155.18 278.52,155.18 280.29,156.95 UG28.1
GPU_SNB1: length 1.4
  TOP w0.102: PR6108.2 v1(256.5,144.2)
GPU_SNB2: length 1.4
  TOP w0.102: PR6115.2 v1(242.73,144.07)
GPU_SNB3: length 1.4
  TOP w0.102: PR6206.2 v1(228.96,144.01)
GPU_SNB4: length 1.4
  BOTTOM w0.102: v1(205.95,144.33) 206.33,143.95 PC6227.1
GPU_STRAP5_EC: length 202.1
  TOP w0.102: QG512.2 182.29,70.93 179.6,68.24 174.9,68.24 174.32,67.66 174.32,40.4 174.53,40.19 174.53,38.8 174.96,38.37 174.96,38.1 175.48,37.58 175.48,31.72 174.68,30.92 v2(174.68,29.29) ; v2(295.54,15.92) 295.61,15.84 295.61,11.01 295.54,10.94 UE5.71 295.54,8.11 RE672.1
  IN2 w0.089: 191.27,22.16 193,22.16 193.19,21.97 193.68,21.97 194.55,21.1 196.01,21.1 196.37,20.74 197.26,20.74 198.71,22.19 203.98,22.19 206,20.17 206.31,20.17 207.8,18.68 208.77,18.68 208.83,18.75 211.36,18.75 213.15,16.96
  IN2 w0.102: v2(295.54,15.92) 295.46,15.99 293.75,15.99 293.12,16.62 292.73,17.01 280.53,17.01 279.48,18.06 278.04,18.06 277.86,18.25 277.86,19.36 276.92,20.3 276.21,20.3 275.58,20.92 273.85,20.92 271.59,23.17 270.39,23.17 270.17,22.94 258.51,22.94 255.73,25.72 255.54,25.72 248.46,25.72 248.33,25.59 248.33,25.59 248.18,25.44 248.18,21.67 248.18,21.55 248.58,21.15 248.71,21.01 248.71,18.25 248.2,17.73 246.92,17.73 246.89,17.71 237.6,17.71 236.85,16.96 236.51,16.61 232.29,16.61 231.88,16.2 221.74,16.2 221.51,16.43 219.67,16.43 219.41,16.17 218.86,16.17 218.57,16.46 213.65,16.46 213.15,16.96 ; v2(174.68,29.29) 174.68,28.82 175.78,27.73 180.69,27.73 181.99,29.02 183.49,29.02 183.92,28.59 188.66,28.59 189.1,28.15 189.1,24.26 191.2,22.16 191.27,22.16
GPU_VID: length 3.1
  BOTTOM w0.203: PR6044.2 278.2,144.43 277.54,143.76 v1(277.48,143.76) 276.81,143.09 PU6000.39
GSYNC_ID: length 6.7
  BOTTOM w0.089: 219.18,32.78 219,32.96 v1(218.69,32.96) 218.34,32.96 217.98,33.32 217.68,33.32 217.63,33.26 217.62,33.26 217.08,32.72 216.27,32.72 215.91,33.07 215.53,33.07 215.38,33.22 UH1.BE17
  BOTTOM w0.102: 219.18,32.78 219.82,32.78 220.19,33.15 RH30.1 RH29.1
GT_SW1: length 6.4
  TOP w0.102: PR584.1 v1(142.66,141.67)
  TOP w0.254: PR605.1 143.85,139.55 v2(143.95,139.45)
  TOP w0.508: PR584.1 v2(141.75,143.28)
  BOTTOM w0.254: PL505.1 v2(143.95,139.45)
H_CPUPWRGD: length 236.5
  TOP w0.089: v3(131.1,118.61) 131.1,118.13 131.2,118.04 v2(131.2,117.6) 131.2,117.07 CH194.1
  IN1 w0.081: v2(204.73,56) 204.73,55.73 208.74,51.73 208.74,48.28 208.42,47.96 208.42,45.64 209.37,44.69 209.37,41.77
  IN1 w0.089: v2(205.07,39.6) 205.51,39.6 206.51,38.6 207.59,38.6 207.65,38.66 208.23,38.66 208.42,38.47 208.8,38.47 209.37,39.04 209.37,41.77
  IN3 w0.127: v2(117.6,36.88) 116.59,36.88 116.42,37.05 116.42,39.73 115.83,40.31 113.46,40.31 109.51,44.27 109.51,59.26 110.99,60.74 110.99,60.74 111.23,60.99 111.24,60.99 114.54,64.29 115.95,64.29 128.69,77.02 128.69,96.7 132.14,100.15 132.14,104.55 135.45,107.86 136.16,107.86 136.55,108.25 136.55,112.83 135.53,113.85 135.53,114.43 135.71,114.61 135.71,115.41 134.95,116.17 132.94,116.17 131.5,117.6 v2(131.2,117.6)
  IN6 w0.081: v2(117.6,36.88) 120.07,34.41 130.91,34.41 132.26,33.06 178.74,33.06 183.64,37.96 185.07,37.96 185.08,37.97 185.98,37.97 186.71,38.69 186.71,41.43 189.42,44.14 189.42,52.27 189.7,52.55 190.26,52.55 190.89,53.18 194.03,53.18 195.39,51.82 199.2,51.82 199.56,52.17 199.56,52.77 202.72,55.93 203.28,55.93 203.3,55.95 204.68,55.95 v2(204.73,56)
  BOTTOM w0.107: UC1.BT31 131.24,117.56 v2(131.2,117.6)
  BOTTOM w0.122: UH1.AE3 205.43,39.96 v2(205.07,39.6)
H_DRAMRST#: length 140.9
  TOP w0.114: v2(134.56,55.82) 135.06,55.82 v1(135.49,55.39) 135.96,54.92 135.96,54.9 136.54,54.32 RD35.2 137.21,54.73 138.02,54.73 138.32,54.42 RD31.2
  IN1 w0.081: v2(203.53,61.27) 203.97,61.27 204.16,61.46 204.9,61.46 206.99,59.37 206.99,55.03 207.02,55.01 210.48,51.54 210.48,46.04 211.38,45.15 211.38,43.58 211.25,43.46 211.25,42.57 211.07,42.39 211.07,38.5 210.73,38.15 210.73,37.76 212.84,35.64 214.99,35.64 215.65,34.98 215.65,32.01 216.18,31.49 216.73,31.49 216.96,31.26 216.96,31.26 217.26,30.97 217.45,30.97 217.66,30.76 217.66,29.79 218.23,29.23 218.23,27.95 218.17,27.9 218.17,27.78 218.05,27.66 218.05,26.71 217.59,26.25 217.59,24.98 217.76,24.81 218.21,24.81 218.39,24.63 218.39,24.12 218.07,23.8 218.07,22.96 v2(218.09,22.94)
  IN4 w0.089: v2(218.09,22.94) 218.09,22.62 218.07,22.6 218.07,21.5 217.61,21.05 217.29,21.05 216.44,20.2 216.44,19.46 215.2,18.22 v2(214.83,18.22)
  IN6 w0.081: v2(203.53,61.27) 203.24,60.98 201.73,60.98 200.6,62.11 200.31,62.41 200.31,62.77 199.34,63.74 198.38,63.74 197.98,63.35 197.14,63.35 197.03,63.24 196.71,63.24 196.14,62.67 195.74,62.27 195.64,62.27 195.3,61.93 195.1,61.8 194.62,61.48 194.29,61.26 194.27,61.15 193.83,60.71 193.34,59.97 193.16,59.79 191.6,59.79 190.91,60.49 190.91,60.59 189.32,62.18 189.16,62.34 186.97,62.34 186.51,62.81 185.81,62.81 185.35,62.35 184.03,62.35 181.35,59.66 178.87,59.66 177.43,58.22 177.43,55.74 176.83,55.14 170.41,55.14 168.99,53.71 148.34,53.71 148.1,53.96 137.16,53.96 135.3,55.82 v2(134.56,55.82)
  BOTTOM w0.089: v2(214.83,18.22) 214.7,18.22 214.43,18.49 214.43,18.49 214.34,18.57 UH1.BB46
H_PECI: length 346.6
  TOP w0.114: RE76.2 310.5,20.42 v2(310.65,20.56)
  IN3 w0.127: v2(116.93,37.61) 116.93,40.11 116.09,40.95 114.12,40.95 112.48,42.59 112.48,48.56 111.09,49.94 111.09,53.94 111.83,54.67 111.83,60.11 115.36,63.64 116.04,63.64 129.55,77.16 129.55,92.17 132.93,95.55 132.93,99.8 132.36,100.37 132.36,104.46 135.54,107.65 136.25,107.65 136.76,108.16 136.76,113.81 136.03,114.54 136.03,115.4 135.04,116.39 133.36,116.39 132.91,116.83 132.91,117.56 131.61,118.86 131.33,118.86 v2(130.44,119.75) ; v2(211.08,50.28) 214.5,50.28 217.33,47.45 222.57,47.45 223.55,46.47 228.42,46.47 229.4,47.45 232.91,47.45 233.65,46.71 243.5,46.71 244.04,47.26 246.9,47.26 247.61,47.98 249.2,47.98 249.86,48.63 258.09,48.63 260.35,46.37 270.42,46.37 274.73,42.06 277.41,42.06 278.65,43.3 295.86,43.3 297.63,41.52 297.63,34.66 299.67,32.63 299.67,30.66 300.55,29.77 302.4,29.77 304.64,27.53 304.64,26.22 305.42,25.44 305.42,24.32 308.29,21.45 309.76,21.45 v2(310.65,20.56)
  IN6 w0.081: v2(116.93,37.61) 117.52,38.2 119.51,38.2 121.45,36.26 131.95,36.26 133.03,35.18 178.14,35.18 187.23,44.27 187.23,53.08 188.48,54.33 188.95,54.33 189.44,54.82 194.84,54.82 196.2,53.46 199.6,53.46 202.54,56.41 206.99,56.41 211.08,52.31 v2(211.08,50.28)
  BOTTOM w0.089: UC1.BT34 131.42,119.08 130.75,119.75 v2(130.44,119.75)
  BOTTOM w0.114: RH73.2 208.54,45.43 211.08,47.97 v2(211.08,50.28)
H_PM_DOWN: length 223.2
  TOP w0.089: RH14.1 206.32,40.3 v2(206.32,39.61)
  IN1 w0.081: v2(206.32,39.61) 206.39,39.54 206.57,39.54 207.84,40.82 207.84,43.68 205.21,46.31 203.42,46.31 201.08,48.65 201.08,49.95 198.56,52.47 v2(198.56,52.64)
  IN3 w0.127: v2(126.13,119.19) 126.55,118.76 126.55,116.69 125.87,116.01 125.87,115.46 123.77,113.36 123.77,102.26 121.34,99.83 121.34,96.96 118.75,94.36 118.75,91.39 117.45,90.09 117.45,74.84 107.34,64.74 107.34,62.2 106.17,61.02 105.18,61.02 104.28,60.12 104.28,55.98 103.31,55.02 103.31,42.9 105.67,40.54 v2(105.67,37.21)
  IN6 w0.081: v2(105.67,37.21) 116.67,37.21 116.74,37.15 117.12,37.15 117.19,37.21 117.24,37.21 117.77,37.74 119.23,37.74 121.19,35.78 131.78,35.78 132.57,34.99 132.84,34.72 178.33,34.72 187.69,44.08 187.69,49.98 188.24,50.53 188.24,52.96 189.63,54.36 194.65,54.36 196.01,53 198.21,53 v2(198.56,52.64)
  BOTTOM w0.089: UH1.AE2 205.65,40.5 206.02,40.13 206.02,39.69 206.15,39.57 206.27,39.57 v2(206.32,39.61)
  BOTTOM w0.114: v2(126.13,119.19) RH155.1
H_PM_SYNC: length 228.8
  IN1 w0.102: v2(203.92,57.8) 203.92,57.95 203.39,58.48 203.17,58.48 202.32,57.63 202.32,56.97 197.98,52.63 v2(197.98,52.6)
  IN3 w0.127: v2(131.23,119.78) 131.23,119.72 132.78,118.17 134.57,118.17 135.53,117.21 135.53,116.89 136.98,115.44 136.98,108.07 136.34,107.43 135.63,107.43 132.57,104.37 132.57,100.46 133.14,99.89 133.14,95.15 130.14,92.15 130.14,77 117.06,63.93 117.06,62.69 116.75,62.37 114.88,62.37 113.37,60.86 113.37,55.29 111.63,53.55 111.63,50.18 113.08,48.73 113.08,42.72 114.27,41.52 116.91,41.52 117.94,40.49 117.94,38.27 118.35,37.86 v2(118.35,36.88)
  IN6 w0.102: v2(118.35,36.88) 118.7,37.23 119.11,37.23 120.91,35.42 120.99,35.42 121.03,35.38 131.31,35.38 132.47,34.22 175.61,34.22 175.71,34.32 178.5,34.32 188.09,43.92 188.09,49.82 188.64,50.37 188.64,52.8 189.8,53.96 194.4,53.96 195.49,52.88 195.76,52.6 198,52.6 198,52.6 v2(197.98,52.6)
  BOTTOM w0.076: UC1.BM34 134.56,119.55 133.28,119.55 133.2,119.46 132.62,119.46 132.54,119.39 132.1,119.39 132.09,119.37 131.58,119.37 131.23,119.72 v2(131.23,119.78)
  BOTTOM w0.102: v2(203.92,57.8) 204.36,57.36 206.76,57.36 207.82,56.3 207.82,55.03 207.96,54.9 208.05,54.81 208.05,54.78 210.38,52.44 210.38,48.07 v1(208.65,46.34) RH15.2
H_PM_SYNC_R: length 7.5
  BOTTOM w0.089: 205.18,43.88 205.18,42.92 205.59,42.5 205.59,41.2 205.69,41.1 205.69,41.05 206.01,40.72 206.01,40.45 206.26,40.21 UH1.AF3
  BOTTOM w0.114: RH15.1 207.32,44.76 v1(205.66,44.76) 205.56,44.76 205.18,44.38 205.18,43.88
H_PROCHOT#: length 481.5
  TOP w0.114: v2(121.32,134.98) 121.45,135.11 PR513.2 ; QE2.1 308.7,8.39 307.89,8.39 307.15,7.64 v2(307.15,7.36) ; PR27.1 116.33,83.81 117.61,85.09 117.61,94.41 118.69,95.49 118.69,100.05 123.6,104.96 123.6,112.4 122.57,113.43 122.57,114.89 123.02,115.34 123.71,115.34 125.31,116.94 127.58,116.94 v2(128.27,117.63) ; PQ8.1 74.94,9.96 75.19,10.21 75.19,15.2 v1(74.7,15.69) v2(73.53,16.86) ; v2(52.21,24.69) PR724.1
  IN1 w0.081: v2(129.17,21.71) 129.93,22.47 129.96,22.47 135.47,28.06 153.4,28.06 155.36,26.09 171.73,26.09 185.01,12.82 185.49,12.82 187.11,11.2 193.21,11.2 193.47,10.93 198.41,10.93 198.66,10.68 215.57,10.68 216.94,12.05 238.79,12.05 240.69,13.95 251.28,13.95 252.35,15.03 255.44,15.03 257.26,13.21 271.47,13.21 272.04,13.78 278.48,13.78 279.26,14.56 280.68,14.56 283.47,17.34 290.65,17.34 293.01,14.98 296.62,14.98 298.71,12.88 298.71,11.42 300.11,10.02 305.33,10.02 307.15,8.21 v2(307.15,7.36)
  IN3 w0.127: v2(121.32,134.98) 121.32,134.97 122.38,133.91 122.89,133.91 127.71,129.09 127.71,118.2 128.27,117.64 v2(128.27,117.63) 128.64,117.63 129.93,116.34 129.93,106.1 127.06,103.23 127.06,102.29 125.76,100.99 125.76,95.88 125.95,95.69 125.95,89.74 121.67,85.46 121.67,75.96 110.33,64.61 110.33,63.07 107.38,60.11 107.38,58.73 105.91,57.27 105.91,42.89 108.29,40.5 108.29,30.34 v2(106.37,28.43)
  IN6 w0.081: v2(129.17,21.71) 113.97,21.71 111.47,19.21 101.04,19.21 100.28,19.97 100.28,21.14 ; 100.28,21.14 106.43,21.14 108.66,23.36 108.66,25.39 106.89,27.15 106.84,27.15 106.37,27.62 v2(106.37,28.43) ; 100.28,21.14 99.77,21.64 84.27,21.64 81.14,18.51 75.18,18.51 v2(73.53,16.86) 71.87,15.19 64.56,15.19 63.38,16.38 63.38,19.49 63.13,19.74 59.76,19.74 57.92,21.58 55.95,21.58 52.83,24.69 v2(52.21,24.69)
  BOTTOM w0.114: RH158.1 128.38,118.16 128.27,118.05 v2(128.27,117.63) RH165.2 ; v2(121.32,134.98) 121.45,135.11 PR513.2
H_THERMTRIP#: length 114.2
  TOP w0.254: RH163.2 167.02,117.22 v2(167.6,117.8)
  IN6 w0.081: 175.71,92.9 175.71,91.86 177.95,89.62 177.95,81.48 179.2,80.22 179.2,77.62 177.7,76.12 177.7,67.69 180.77,64.62 181.52,64.62 182.15,63.99 187.66,63.99 187.9,64.23 188.94,64.23 190.96,62.21 193.58,62.21 193.7,62.28 194.55,62.85 196.09,64.4 196.09,65.37 196.18,65.46 199.34,65.46 201.56,63.24 v2(201.56,62.73)
  IN6 w0.097: 175.71,92.9 175.71,93.79 172.41,97.09 172.41,104.99 172.18,105.21 169.27,105.21 167.71,106.77 167.71,117.69 v2(167.6,117.8)
  BOTTOM w0.076: UC1.J31 167.93,117.46 v2(167.6,117.8)
  BOTTOM w0.114: v2(201.56,62.73) 201.49,62.67 201.49,61.59 202.46,60.62 202.46,57.94 203.59,56.8 206.52,56.8 207.26,56.06 207.26,54.8 207.49,54.57 207.49,54.21 209.69,52.01 209.69,48.58 208.89,47.79 208.89,47.58 206.7,45.39 205.23,45.39 RH79.2
H_THERMTRIP#_R: length 4.1
  BOTTOM w0.089: UH1.AD3 205.07,40.32 205.37,40.62 205.37,42.41 204.8,42.98 v1(204.8,42.99) 204.8,43.79 204.71,43.88
  BOTTOM w0.114: 204.71,43.88 RH79.1
H_VCCST_PWRGD: length 249.7
  TOP w0.114: v2(305.74,22.01) UE5.123 ; Q7.3 319.89,46.46 319.34,45.91 319.34,42.21 318.46,41.33 318.46,39.92 318.81,39.57 v3(318.81,38.45) 318.58,38.22 318.58,37.19 316.16,34.78 316.16,33.28 317.7,31.74 317.7,28.38 317.01,27.69 314.51,27.69 v2(314.33,27.5) ; CH193.1 173.55,102.28 173.8,102.53 RH154.1 RH164.2 174.71,101.66 174.82,101.55 174.82,100.19 175.84,99.18 177.11,99.18 v2(177.61,98.67)
  IN1 w0.081: v2(314.33,27.5) 313.42,26.59 313.42,23.9 313.43,23.89 313.43,23.23 312.89,22.69 310.2,22.69 309.53,22.01 v2(305.74,22.01)
  IN3 w0.127: v2(208.5,64.52) 209.48,64.52 212.52,61.48 212.52,55.25 210.66,53.39 210.66,50.11 211.25,49.52 214.54,49.52 217.12,46.95 222.36,46.95 224.68,44.62 226.88,44.62 227.34,45.08 227.34,45.52 227.78,45.96 228.63,45.96 229.61,46.95 232.7,46.95 233.53,46.12 238.62,46.12 238.86,45.88 243.38,45.88 244.26,46.75 249.45,46.75 250.82,48.12 257.88,48.12 260.14,45.86 270.21,45.86 274.52,41.55 277.62,41.55 278.86,42.79 291.35,42.79 292.08,42.06 292.08,34.04 294.84,31.28 294.84,28.31 295.12,28.03 297.42,28.03 297.68,28.3 300.69,28.3 301.4,27.59 302.37,27.59 302.92,27.04 302.92,26.07 304.1,24.89 304.1,23.66 v2(305.74,22.01)
  IN6 w0.081: v2(177.61,98.67) 177.61,91.78 179.23,90.16 179.23,81.98 180.47,80.75 180.47,75.8 180.36,75.69 180.36,75.01 178.8,73.45 178.8,69.22 182.45,65.57 188.31,65.57 188.55,65.33 189.39,65.33 190.45,64.27 191.9,64.27 192.06,64.11 193,64.11 193.3,63.81 193.95,63.81 194,63.85 194.99,64.85 194.99,65.83 195.76,66.59 199.75,66.59 201.74,64.61 208.42,64.61 v2(208.5,64.52)
HDA_BIT_CLK: length 7.5
  TOP w0.089: v2(218.39,36.97) 218.39,35.68 v1(218.67,35.39) 219.08,34.98 v2(219.15,34.98)
  BOTTOM w0.089: UH1.BD11 214.81,36.07 214.94,35.94 215.32,35.94 215.33,35.95 215.52,35.95 ; 219.18,34.98 v2(219.15,34.98)
  BOTTOM w0.114: 219.18,34.98 219.46,34.98 219.54,35.05 RP2.5
  BOTTOM w0.122: 215.52,35.95 216.6,35.95 216.92,36.27 217.64,36.27 218.35,36.97 v2(218.39,36.97)
HDA_BIT_CLK_R: length 236.5
  TOP w0.089: v2(218.22,17.64) 218.25,17.64 218.62,17.27 218.62,17.22 218.64,17.2 218.64,16.96
  TOP w0.114: v2(220.29,11.23) 220.29,11.36 218.89,12.75 218.89,15.63 218.7,15.82 218.7,16.44 218.64,16.5 218.64,16.96
  IN3 w0.127: v2(220.29,11.23) 220.27,11.25 220.27,11.28 219.86,11.69 219.36,11.69 218.85,12.2 217.93,12.2 216.4,10.66 202.77,10.66 202.14,10.02 198.26,10.02 197.37,10.91 196.63,10.91 196.39,11.15 193.61,11.15 193.15,11.61 191.02,11.61 190.01,12.62 188.66,12.62 186.98,14.3 186.98,14.53 184.4,17.11 180.36,17.11 179.86,17.61 169.94,17.61 168.82,18.74 137.49,18.74 136.69,17.94 115.3,17.94 110.75,13.39 105.48,13.39 104.49,14.38 56.21,14.38 54.15,16.44 47.17,16.44 44.73,18.88 44.65,18.88 40.43,23.09 40.43,28.15 38.69,29.89 37.38,29.89 37.13,29.64 36.79,29.64 36.53,29.9 35.89,29.9 35.29,29.3 v2(35.29,29.26)
  IN4 w0.127: v2(218.22,17.64) 218.22,20.44 219.15,21.36 219.15,21.96 220.52,23.33 221.84,23.33 221.97,23.46 221.97,24.15 222.66,24.85 222.66,25.16 223.27,25.77 223.27,26.79 221.8,28.26 v2(221.8,29.65)
  BOTTOM w0.114: v2(221.8,29.65) 221.91,29.75 221.91,30.36 222.08,30.76 222.12,30.81 222.12,31.4 222.64,31.92 222.64,32.38 222.52,32.5 222.52,34.36 221.83,35.05 RP2.4 ; RA2.1 CA258.1 37.48,29.45 36.99,29.45 36.38,30.05 36.27,30.05 36.22,30.11 UA1.13 35.27,30.11 35.06,29.9 35.06,29.39 35.19,29.26 v2(35.29,29.26)
HDA_RST#: length 6.5
  TOP w0.089: v2(217.18,37.02) 217.24,37.02 v1(217.73,36.53) 218,36.25 v2(218,35.42)
  BOTTOM w0.089: v2(218,35.42) 218.14,35.55 219.18,35.55
  BOTTOM w0.114: RP2.6 219.18,35.55
  BOTTOM w0.122: v2(217.18,37.02) 216.85,36.69 216.75,36.69 216.47,36.42 216.3,36.42 215.95,36.77 215.42,36.77 215.34,36.68 UH1.BE10
HDA_RST#_D: length 4.8
  BOTTOM w0.114: RA17.2 38.77,28.05 36.53,28.05 36.18,28.39 35.45,28.39 35.45,28.39 35.19,28.39 35.15,28.35 34.91,28.35 34.82,28.44 UA1.15
HDA_RST#_R: length 226.6
  TOP w0.114: v2(219.68,11.23) 219.68,11.27 218.39,12.56 218.39,15.42 218.3,15.51 218.3,17.03 v2(218.26,17.07)
  IN3 w0.127: v2(38.81,25.79) 39.42,25.18 39.42,22.67 43.7,18.39 43.7,17.97 46.25,15.42 53.73,15.42 55.78,13.37 104.07,13.37 105.06,12.37 111.18,12.37 115.72,16.92 139.96,16.92 140.76,17.72 168.4,17.72 169.81,16.31 174.19,16.31 175.97,14.53 183.84,14.53 187.46,10.91 188.48,10.91 189.94,9.45 193.81,9.45 194.26,9.01 202.13,9.01 202.56,9.01 203.19,9.64 218.64,9.64 219.68,10.68 v2(219.68,11.23)
  IN4 w0.127: v2(218.26,17.07) 218.6,17.42 218.6,18.94 219.83,20.17 219.93,20.17 221.88,22.12 221.88,22.47 223.17,23.76 223.17,24.03 223.85,24.7 223.85,26.58 223.78,26.65 223.78,27.36 222.92,28.22 222.92,29.28 222.49,29.71 v2(222.47,29.71)
  BOTTOM w0.114: v2(38.81,25.79) 39.22,26.2 39.22,27.02 RA17.1 ; RP2.3 221.92,35.55 221.93,35.55 222.03,35.55 223.01,34.57 223.01,32.7 223.21,32.51 223.21,31.79 222.71,31.29 222.61,31.19 222.61,30.66 222.77,30.51 222.77,30 v2(222.47,29.71)
HDA_SDIN: length 254.3
  IN1 w0.081: v2(219.91,37.51) 219.82,37.6 219.82,42.19 221.07,43.44 221.07,45.57 219.01,47.63 v2(218.51,48.82)
  IN3 w0.127: v2(43.03,18.29) 43.03,18.7 38.81,22.92 38.81,24.73 38.3,25.24 38.3,25.9 38.74,26.34 v2(38.74,26.37)
  IN6 w0.081: v2(179.08,23.23) 163.08,23.23 160.28,20.44 127.43,20.44 125.15,18.15 93.61,18.15 91.27,20.5 86.43,20.5 81.84,15.9 75.06,15.9 73.11,13.96 61.93,13.96 61.92,13.96 57.73,13.96 54.86,16.83 50.23,16.83 48.97,18.09 43.22,18.09 43.03,18.28 v2(43.03,18.29) ; v2(218.51,48.82) 217.12,50.22 216.52,50.22 216.24,50.5 213.9,50.5 213.58,50.83 213.56,50.83 210.29,54.1 210.29,54.11 210.29,54.12 210.29,55.83 208.51,57.61 205.02,57.61 204.42,58.22 203.86,58.22 203.85,58.22 201.03,58.22 199.03,60.21 197.33,60.21 197.3,60.2 197.05,60.1 197.05,60.1 196.54,59.89 196.08,59.58 195.69,59.19 195.38,58.73 195.17,58.22 195.11,57.93 193.31,56.13 188.9,56.13 188.41,55.64 187.93,55.64 185.23,52.94 185.23,44.38 180.85,40 175.66,40 174.95,39.3 v2(174.95,38.97)
  BOTTOM w0.114: v2(179.08,23.23) 179.21,23.36 179.21,27.74 175.4,31.55 175.4,37.84 174.95,38.28 v2(174.95,38.97) ; v2(38.74,26.37) 38.74,26.85 38.43,27.16 38.27,27.16 38.27,27.16 RA18.1 ; v2(219.91,37.51) 219.75,37.35 218.88,37.35
  BOTTOM w0.122: UH1.BE11 216.51,36.16 216.83,36.48 217.18,36.48 218.05,37.35 218.88,37.35
HDA_SDIN_R: length 4.1
  BOTTOM w0.114: UA1.16 34.42,28.41 34.74,28.09 35.23,28.09 35.29,28.15 36.09,28.15 36.23,28.01 v1(36.23,27.51) 36.23,27.28 36.35,27.16 RA18.2
HDA_SDOUT: length 6.1
  BOTTOM w0.114: 219.13,36.55 RP2.8 220.03,37 220.66,37.62 RH16.2
  BOTTOM w0.122: 219.13,36.55 v1(218.69,36.55) 218.56,36.55 218.07,36.06 217.01,36.06 216.69,35.74 215.96,35.74 UH1.BF12
HDA_SDOUT_R: length 240.3
  TOP w0.114: v2(222.39,23.98) 222.39,24.19 221.81,24.76 221.81,25.35 222.39,25.92 222.39,26.77 222.34,26.83 222.34,28.01 222.91,28.58 222.91,30.73 222.63,31.01 222.63,35.88 222.32,36.19 v2(222.32,36.31) ; v2(218.51,11.22) 218.51,11.99 217.08,13.42 v2(214.99,13.42)
  IN3 w0.127: v2(218.51,11.22) 218.51,11.22 217.19,9.9 203.09,9.9 202.45,9.26 202.24,9.26 196.48,9.26 195.63,10.11 194.34,10.11 193.94,9.71 191.27,9.71 190.66,10.32 189.55,10.32 187.04,12.82 186.03,12.82 184.06,14.79 176.07,14.79 174.29,16.57 169.91,16.57 168.5,17.97 140.66,17.97 139.86,17.18 115.62,17.18 111.07,12.63 105.17,12.63 104.17,13.62 55.89,13.62 53.84,15.68 46.35,15.68 43.95,18.08 43.95,18.49 39.67,22.77 39.67,26.33 38.26,27.74 35.74,27.74 v2(35.72,27.72)
  BOTTOM w0.114: v2(35.72,27.72) 35.6,27.84 34.58,27.84 34.02,28.41 UA1.17 ; v2(214.99,13.42) 215.33,13.42 215.41,13.5 217.21,13.5 217.42,13.71 219.91,13.71 220.47,14.27 221.79,14.27 222.36,14.84 224.09,14.84 224.35,15.1 224.35,16.95 222.49,18.81 222.49,19.47 222.49,19.48 222.49,19.84 221.88,20.46 221.88,22.38 222.39,22.88 v1(222.39,23.26) v2(222.39,23.98) ; RP2.1 221.95,36.55 222.2,36.31 v2(222.32,36.31)
HDA_SPKR: length 273
  TOP w0.089: RH600.1 214.58,25.57 214.33,25.82 214.33,26.45 213.61,27.17 v2(213.61,27.4)
  TOP w0.114: v2(36.2,52.38) 36.38,52.55 36.38,52.55 36.75,52.92 39.54,52.92 39.79,52.66 39.79,51.02 36.41,47.64 36.41,46.82 36.03,46.43 36.03,45 35.7,44.67 35.7,43.53 35.83,43.4 35.83,42.66 36.41,42.07 36.41,41.32 39.55,38.18 39.55,36.19 41.38,34.36 41.38,32.66 41.49,32.55 41.49,28.39 41.29,28.19 DA1.3
  IN1 w0.081: v2(205.34,55.97) 205.34,55.67 209.77,51.24 209.77,45.75 210.66,44.85 210.66,43.58 210.89,43.35 ; 210.89,40.5 210.89,40.38 210.9,40.37 210.9,38.67 210.45,38.22 210.45,37.8 212.77,35.47 214.78,35.47 215.27,34.98 215.27,31.16 215.78,30.65 215.78,27.93 215.57,27.71
  IN1 w0.089: 215.57,27.71 214.79,26.94 213.94,26.94 213.61,27.27 v2(213.61,27.4) ; 210.89,43.35 210.89,40.5
  IN6 w0.081: v2(205.34,55.97) 205.34,55.63 205.26,55.55 202.88,55.55 199.94,52.61 199.94,52.01 199.36,51.43 195.23,51.43 194.95,51.71 192.32,51.71 191.73,52.3 191,52.3 190.96,52.34 190.6,52.34 190.24,51.98 190.24,51.97 189.81,51.54 189.81,43.98 187.09,41.27 187.09,38.85 187.09,38.53 186.14,37.58 185.24,37.58 184.54,36.88 183.11,36.88 178.9,32.67 132.07,32.67 130.97,33.77 108.99,33.77 107.03,35.74 106.38,35.74 105.19,36.93 105.19,42.29 98.68,48.79 97.7,48.79 96.85,49.65 96.85,50.09 96.13,50.8 87.8,50.8 87.12,51.48 81.66,51.48 81.3,51.12 67.55,51.12 67.28,51.38 47.59,51.38 45.97,53.01 45.86,53.01 45.79,53.08 36.9,53.08 v2(36.2,52.38)
  BOTTOM w0.122: UH1.AW29 212.79,27.49 213.51,27.49 v2(213.61,27.4)
HDA_SYNC: length 3.9
  BOTTOM w0.114: RP2.7 219.16,36.05
  BOTTOM w0.122: 219.16,36.05 219.15,36.06 218.64,36.06 218.43,35.85 217.09,35.85 216.73,35.49 216.4,35.49 UH1.BG13
HDA_SYNC_R: length 233.9
  TOP w0.114: v2(219.14,16.81) 219.13,16.81 219.13,16.71 219.2,16.64 219.2,16.02 219.39,15.83 219.39,12.96 220.8,11.55 220.8,11.05 220.57,10.82 219.24,10.82 219.1,10.96 v2(219.1,11.22)
  IN3 w0.127: v2(219.1,11.22) 219.1,11.23 218.64,11.69 218.14,11.69 216.61,10.15 202.98,10.15 202.35,9.52 198.05,9.52 197.16,10.4 196.42,10.4 196.23,10.6 192.86,10.6 192.66,10.8 190.61,10.8 189.29,12.11 188.11,12.11 187.02,13.2 186.01,13.2 184.16,15.04 176.18,15.04 174.4,16.82 170.02,16.82 168.61,18.23 140.55,18.23 139.75,17.43 115.51,17.43 110.96,12.88 105.27,12.88 104.28,13.87 56,13.87 53.94,15.93 46.46,15.93 44.2,18.18 44.2,18.6 39.92,22.88 39.92,26.69 37.47,29.14 36.36,29.14 36.25,29.24 v2(36.25,29.24)
  IN4 w0.127: v2(219.14,16.81) 219.14,16.82 219.36,17.03 219.36,18.3 219.43,18.37 219.43,19.31 219.84,19.72 222.27,22.15 223.25,22.15 223.42,22.33 223.42,23.92 224.54,25.04 224.54,25.56 224.74,25.75 224.74,28.12 223.17,29.68 223.17,30.23 223.39,30.45 v2(223.68,30.45)
  BOTTOM w0.114: RP2.2 221.87,36.05 223.26,34.67 223.26,32.8 223.45,32.61 223.45,31.69 222.86,31.09 222.86,30.76 223.17,30.45 v2(223.68,30.45) ; v2(36.25,29.24) 36.25,29.59 36.14,29.71 UA1.14
HDMI_C_CLKN: length 4.6
  TOP w0.089: v2(218.28,166.61) 218.12,166.45 218.12,165.7 218.66,165.16 218.66,164.89 218.66,164.43 RX33.1
  BOTTOM w0.089: CV1057.1 218.14,166.18 218.14,166.36 218.14,166.48 v2(218.28,166.61) 218.09,166.79 218.09,166.96 218.22,167.08 LV3.1 218.38,167.62 RV641.1
HDMI_C_CLKP: length 4.7
  TOP w0.089: v2(217.69,166.61) 217.88,166.42 217.88,165.6 v4(218.22,165.26) 218.42,165.06 218.42,164.89 218.42,164.43 RX34.1
  BOTTOM w0.089: CV1058.1 217.9,166.19 217.9,166.36 217.9,166.4 v2(217.69,166.61) 217.85,166.77 217.85,166.93 217.72,167.07 LV3.4 217.55,167.62 RV640.1
HDMI_C_TX_N0: length 4.7
  TOP w0.089: v2(213.51,166.64) 213.36,166.49 213.36,165.43 214.11,164.68 214.11,164.43 RX31.1
  BOTTOM w0.089: RV643.1 213.58,167.62 LV4.1 213.42,167.12 213.31,167.01 213.31,166.84 v2(213.51,166.64) 213.32,166.45 213.32,166.23 CV1060.1
HDMI_C_TX_N1: length 4.7
  TOP w0.089: v2(215.85,166.63) 215.68,166.46 215.68,165.46 216.4,164.74 216.4,164.45 RX35.1
  BOTTOM w0.089: RV642.1 216,167.62 LV5.1 215.83,167.08 215.71,166.96 215.71,166.77 v2(215.85,166.63) 215.72,166.5 215.72,166.22 CV1062.1
HDMI_C_TX_N2: length 4.4
  TOP w0.089: v2(211.06,166.64) 210.88,166.46 210.88,165.03 211.06,164.85 211.06,164.48 RX37.1
  BOTTOM w0.089: CV1064.1 210.91,166.28 210.91,166.48 v2(211.06,166.64) 210.9,166.8 210.9,166.96 211.03,167.09 LV6.1 211.2,167.62 RV645.1
HDMI_C_TX_P0: length 4.7
  TOP w0.089: RX32.1 213.86,164.43 213.86,164.58 213.11,165.33 v4(213.11,166.08) 213.11,166.45 v2(212.92,166.64)
  BOTTOM w0.089: RV646.1 212.75,167.62 LV4.4 212.92,167.13 213.06,166.98 213.06,166.78 v2(212.92,166.64) 213.08,166.49 213.08,166.23 CV1059.1
HDMI_C_TX_P1: length 4.7
  TOP w0.089: RX36.1 216.16,164.45 216.16,164.64 215.44,165.36 v4(215.44,165.89) 215.44,166.45 v2(215.26,166.63)
  BOTTOM w0.089: CV1061.1 215.48,166.18 215.48,166.41 v2(215.26,166.63) 215.45,166.82 215.45,166.97 215.33,167.09 LV5.4 215.16,167.62 RV639.1
HDMI_C_TX_P2: length 4.4
  TOP w0.089: v2(210.47,166.64) 210.64,166.47 v4(210.64,165.98) 210.64,164.93 210.82,164.75 210.82,164.43 RX38.1
  BOTTOM w0.089: RV638.1 210.36,167.62 LV6.4 210.53,167.09 210.66,166.96 210.66,166.82 v2(210.47,166.64) 210.66,166.45 210.66,166.22 CV1063.1
HDMI_CLKN: length 3.7
  BOTTOM w0.089: JHDMI.12 217.24,174.17 217.24,173.31 218.07,172.47 218.07,171.8 RV673.2
HDMI_CLKP: length 3.7
  BOTTOM w0.089: RV674.2 217.83,171.8 217.83,172.37 216.99,173.22 216.99,174.18 JHDMI.10
HDMI_CTRL_CLK: length 16.4
  IN1 w0.076: 220.35,166.5 220.35,172.08 221.2,172.92 221.2,174.79 220.86,175.13 220.09,175.13 JHDMI.15
  IN1 w0.102: 220.35,166.5 220.99,165.87 220.99,163.67 v2(220.46,163.13)
  BOTTOM w0.089: RV651.1 v2(220.46,163.13)
HDMI_CTRL_CLK_R: length 4.1
  BOTTOM w0.114: RV651.2 218.05,163.36 QV96.3 217.16,163.2 216.54,162.59 RV649.1
HDMI_CTRL_DAT: length 16.4
  IN1 w0.076: v2(220.23,162.55) 219.97,162.81 219.97,163.39 ; 219.9,166.31 219.9,172.81 219.97,172.89 220.52,172.89 220.6,172.97 220.6,173.12 220.52,173.2 219.97,173.2 219.9,173.27 219.9,173.42 219.97,173.5 220.53,173.5 220.61,173.58 220.61,173.73 220.53,173.81 219.97,173.81 219.9,173.88 219.9,174.27 JHDMI.16
  IN1 w0.102: 219.9,166.31 220.53,165.68 220.53,163.95 219.97,163.39
  BOTTOM w0.089: RV650.1 219.69,162.26 219.98,162.55 v2(220.23,162.55)
