# Allegro board LAF551PR10-0221.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCGT on IN4 (solid shape): outline of 4040 points within 132.6,103.11 151.76,126.17
+VCCGT on IN6 (solid shape): outline of 2492 points within 132.91,104.83 149.65,126.03
+VCCGT on IN5: 132.9,103.15 132.9,130.99 140.02,138.11 140.32,138.42 147.39,138.42 147.39,134.89 149.61,132.66 149.61,123.35 148.09,121.83 148.09,118.12 146.36,116.39 146.36,109.38 145.32,108.34 145.32,103.15
+VCCIO on TOP (solid shape): 168.3,112.14 168.4,112.09 168.42,111.98 168.44,111.77 168.57,111.61 168.63,111.5 168.58,111.39 168.45,110.99 168.83,110.8 168.87,110.8 169.14,110.53 169.12,110.49 169.09,110.26 169.21,110.07 169.65,109.64 169.65,109.21 169.6,109.11 169.49,109.08 169.08,108.76 169.49,108.44 169.6,108.42 169.65,108.32 169.65,107.93 169.05,107.33 169.05,106.86 169.02,106.83 169.02,106.3 168.83,106.11 167.25,106.11 167.04,106.32 167.04,107.1 167.08,107.19 167.18,107.22 167.33,107.24 167.46,107.33 167.7,107.57 168.6,107.57 168.6,108.41 167.51,108.41 167.51,108.38 167.26,108.13 167.12,108.1 167.04,108.22 167.04,111.92 167.26,112.14
+VCCIO on BOTTOM (solid shape): 122.72,102.7 123.48,102.7 123.48,103.25 123.92,103.25 123.92,102.7 124.68,102.7 124.68,103.25 125.99,103.25 126.39,102.85 126.39,101.68 125.46,100.75 122.6,100.75 121.94,101.41 121.94,103.11 122.09,103.25 122.72,103.25
+VCCIO on BOTTOM (solid shape): outline of 145 points within 166.23,104.99 169.7,114.93
+VCCIO on IN2 (solid shape): outline of 13622 points within 123.34,85.24 171.61,103.43
+VCCIO on IN3 (solid shape): outline of 6075 points within 153.27,88.8 171.28,114.54
+VCCIO on IN5: 130.54,90.16 123.39,97.31 123.39,100.53 125.5,102.64 140.22,102.64 140.38,102.48 140.79,102.48 140.92,102.61 140.92,102.64 153.48,102.64 167.18,102.58 167.6,102.58 167.97,102.95 167.97,103.94 166.81,105.1 166.81,110.92 165.24,112.49 165.24,116.7 165.55,116.39 167.75,116.39 168.46,117.09 168.46,118.48 169.2,119.22 175.78,119.22 175.78,95.16 170.78,90.16
+VCCIOP on BOTTOM (solid shape): 127.57,110.22 127.57,108.8 126.96,108.2 125.6,108.2 125.24,107.83 125.24,105.93 125.13,105.82 125.13,105.5 125.24,105.38 125.24,103.4 124.51,103.4 124.51,102.84 124.09,102.84 124.09,103.4 123.32,103.4 123.32,102.84 122.88,102.84 122.88,103.4 122.15,103.4 122.15,108.63 123.98,110.45 127.34,110.45
+VCCSA on TOP (solid shape): outline of 1147 points within 164.35,109.87 185.2,132.96
+VCCSA on BOTTOM (solid shape): 185.28,134.53 185.28,134.52 185.28,131.02 183.45,129.19 183.45,128.78 183.7,128.53 184.01,128.53 184.31,128.22 184.31,125.25 183.85,124.79 181.01,124.79 180.22,125.58 180.22,132.59 180.39,132.9 180.22,133.2 180.22,134.42 180.55,134.75 182.1,134.75 182.11,134.74 182.65,134.74 182.79,134.6 182.79,133.63 182.86,133.56 183.57,133.56 183.63,133.61 183.63,134.62 183.85,134.85 184.96,134.85
+VCCSA on BOTTOM (solid shape): outline of 400 points within 165.1,115.5 168.02,124.78
+VCCSA on IN1 (solid shape): outline of 1152 points within 165.36,110.54 186.74,131.34
+VCCSA on IN2 (solid shape): outline of 973 points within 165.63,116.67 174.96,125.06
+VCCSA on IN5: 165.76,116.89 165.29,117.37 165.29,124.38 166.03,125.12 178.78,125.12 180.35,126.69 180.35,134.42 185.96,134.42 187.65,132.73 187.65,125.05 182.33,119.73 168.99,119.73 167.95,118.69 167.95,117.3 167.54,116.89
+VCCST on TOP (solid shape): 169.74,116.91 169.74,116.45 169.46,116.16 169.43,116.16 169.35,116.16 169.27,116.13 168.91,116.13 168.9,116.13 168.8,116.15 168.7,116.13 168.66,116.13 168.52,116 168.47,115.81 168.47,115.79 168.18,115.49 168.18,113.84 168.15,113.81 167.66,113.81 167.62,113.86 167.62,114.49 167.43,114.68 167.07,114.68 166.96,114.79 166.96,115.59 167.24,115.87 167.63,115.87 167.8,116.04 167.8,116.55 167.91,116.66 168.27,116.66 168.57,116.96 169.69,116.96
+VCCST on TOP (solid shape): 174.63,100.96 174.63,99.43 175.02,99.05 175.03,99 175,98.94 174.94,98.96 174.93,98.97 174.42,98.62 175.04,98.7 175.09,98.77 175.19,98.77 175.25,98.75 175.31,98.74 175.33,98.74 175.92,98.15 175.92,97.18 175.88,97.11 175.81,97.08 175.68,97.06 175.57,97 175.5,96.97 175.22,97.08 175.01,97 174.94,96.97 174.87,97 174.31,96.76 174.87,96.53 174.94,96.55 175.01,96.53 175.22,96.44 175.5,96.55 175.57,96.53 175.68,96.46 175.81,96.44 175.88,96.42 175.92,96.34 175.92,95.16 175.92,89.83 178.69,87.06 178.69,83.7 178.82,83.56 178.82,82.86 178.63,82.67 176.41,82.67 175,84.08 175,86.41 172.67,88.74 172.67,95.64 172.71,95.72 172.81,95.73 173.22,96.04 172.81,96.34 172.71,96.35 172.67,96.44 172.67,97.66 173.11,98.1 173.11,100.13 174,101.02 174.57,101.02
+VCCST on IN2 (solid shape): outline of 4795 points within 167.91,92.14 176.59,118.93
+VCCSTG on TOP (solid shape): 178.89,100.32 178.89,99.5 178.82,99.43 176.48,99.43 176.35,99.56 176.35,100.26 176.54,100.45 178.76,100.45
+VCCSTG on TOP (solid shape): 182.87,86.24 182.87,85.42 182.87,85.27 182.3,84.7 182.06,84.7 181.87,84.51 181.87,83.62 182.03,83.47 182.97,83.47 183.13,83.3 183.13,82.9 182.94,82.7 180.53,82.7 180.39,82.85 180.39,86.18 180.64,86.44 182.67,86.44
+VCCSTG on BOTTOM (solid shape): 128.4,116.03 129.22,116.03 129.29,115.96 129.29,114.45 129.22,114.37 127.39,114.37 127.25,114.51 127.25,115.94 127.34,116.03 128.4,116.03
+VCCSTG on IN1 (solid shape): outline of 1605 points within 167.52,99.04 180.41,118.23
+VDD09 on TOP (solid shape): 21.6,57.78 21.6,56.51 21.73,56.38 22.36,56.38 22.42,56.44 23.44,56.44 23.5,56.38 23.5,55.87 23.44,55.81 22.49,55.81 22.04,55.36 21.79,55.36 21.66,55.24 20.84,55.24 20.77,55.3 20.77,55.74 20.87,55.84 20.87,57.87 20.9,57.9 21.47,57.9
+VDD09 on BOTTOM (solid shape): 15.82,49.58 15.82,48.5 15.69,48.38 14.8,48.38 14.61,48.57 14.61,49.65 14.68,49.71 15.69,49.71
+VDD09 on BOTTOM (solid shape): 23.44,56.25 23.44,55.36 23.31,55.24 22.3,55.24 21.66,54.6 21.66,52.95 21.6,52.89 20.77,52.89 20.46,53.2 20.46,56.06 20.71,56.32 23.38,56.32
+VDD09 on IN1 (solid shape): 22.3,56.25 22.3,55.3 22.11,55.11 20.2,55.11 20.14,55.17 18.41,55.17 18.17,55.26 17.93,55.17 16.84,55.17 16.07,54.41 16.07,53.88 16.05,53.74 16.07,53.61 16.07,53.6 16.07,52.69 16.05,52.54 16.07,52.42 16.07,52.41 16.07,48.63 15.76,48.31 14.74,48.31 14.55,48.5 14.55,50.27 14.67,50.54 14.55,50.8 14.55,51.11 14.65,51.36 14.55,51.61 14.55,51.81 14.63,51.93 14.65,52.07 14.65,52.09 14.87,52.3 14.87,52.4 14.88,52.42 14.88,52.9 14.87,52.91 14.87,53.01 14.88,53.02 14.88,53.51 14.87,53.52 14.87,54.29 14.89,54.31 14.89,54.8 14.87,54.82 14.87,55.3 15.63,56.06 20.33,56.06 20.65,56.38 22.17,56.38
+VDD18 on TOP (solid shape): 31.95,51.17 32.65,51.17 32.77,51.04 32.77,49.84 32.65,49.71 32.07,49.71 32.06,49.71 31.95,49.73 31.85,49.71 31.82,49.71 31.8,49.7 31.62,49.5 31.63,49.23 31.63,49.22 31.63,49.08 31.5,48.95 31,48.95 30.68,49.27 30.68,49.74 30.62,49.74 30.62,49.82 30.62,49.83 30.65,50.04 30.55,50.23 30.55,51.55 30.74,51.74 31.38,51.74
+VDD18 on BOTTOM (solid shape): 23.31,52.56 23.31,51.74 23.25,51.68 22.61,51.68 22.55,51.74 22.55,52.12 22.36,52.31 21.98,52.31 21.85,52.44 21.85,52.7 21.92,52.76 23.11,52.76
+VDD18 on BOTTOM (solid shape): 17.37,58.07 17.59,57.97 17.8,58.07 18.12,58.07 18.49,57.7 18.49,56.99 17.18,55.68 16.26,55.68 15.95,55.36 15.95,53.71 16.09,53.57 16.14,53.5 16.2,53.44 16.2,52.89 15.9,52.58 14.75,52.58 14.68,52.61 14.65,52.68 14.5,52.95 14.2,53 14.17,52.99 14.11,53.05 14.11,53.39 14.49,53.78 14.51,53.78 14.69,53.94 14.68,54.19 14.68,54.2 14.68,55.51 15.15,55.98 15.15,55.99 15.27,56.06 15.35,56.18 15.35,56.19 15.38,56.21 15.38,56.42 15.4,56.44 15.4,56.75 15.96,57.31 15.99,57.32 16.03,57.31 16.25,57.23 16.54,57.33 16.61,57.31 16.67,57.27 16.75,57.24 16.81,57.2 16.82,57.12 17.36,56.76 17.26,57.41 17.2,57.45 17.19,57.52 17.02,57.89 16.61,57.86 16.54,57.84 16.48,57.86 16.44,57.89 16.44,57.97 16.44,57.97 16.44,58.07
+VDD18 on IN1 (solid shape): outline of 328 points within 16.46,48.57 32.84,53.08
+VDD18 on IN4 (solid shape): 18.49,57.08 18.49,55.87 16.63,54.01 16.13,53.97 16.17,53.47 16.17,52.81 16.05,52.54 16.17,52.28 16.17,51.33 17.03,50.47 17.03,49.14 16.84,48.95 15.82,48.95 14.55,50.22 14.55,50.27 14.56,50.29 14.66,50.55 14.55,50.8 14.55,51.11 14.65,51.36 14.55,51.61 14.55,51.81 14.65,52.05 14.56,52.3 14.55,52.31 14.55,52.41 14.56,52.42 14.61,52.82 14.26,53.01 14.24,53.01 14.04,53.2 14.04,53.42 14.08,53.43 14.31,53.65 14.28,53.96 14.26,53.99 17.01,56.74 17.04,56.73 17.38,56.78 17.52,57.09 17.55,57.17 17.63,57.2 18.36,57.2
+VDD_TOUCH on TOP (solid shape): 168.29,183.79 168.29,183.21 167.79,182.71 167.79,181.56 167.73,181.49 167.53,181.49 167.48,181.54 167.48,183.82 167.67,184.01 168.07,184.01
+VDD_TOUCH on BOTTOM (solid shape): 167.47,174.03 167.47,173.78 167.72,173.52 167.98,173.52 168.02,173.48 168.02,172.61 167.86,172.45 166.75,172.45 166.7,172.49 166.7,174.01 166.75,174.06 167.45,174.06
+VDD_TOUCH on IN6 (solid shape): outline of 438 points within 165.36,171.99 169.53,184.13
+VDDCT_L on TOP (solid shape): 257.01,159.67 257.01,158.22 257.19,158.04 258.64,158.04 258.83,157.85 258.83,156.96 258.52,156.65 255.34,156.65 254.64,157.34 251.6,157.34 250.9,156.65 247.21,156.65 246.71,157.15 246.71,157.92 246.83,158.04 248.17,158.04 248.37,158.24 248.37,159.54 248.48,159.65 249.33,159.65 249.49,159.49 249.49,158.13 249.58,158.04 256.17,158.04 256.29,158.16 256.29,159.69 256.39,159.78 256.9,159.78
+VDDCT_L on BOTTOM (solid shape): 250.1,158.95 250.1,156.49 249.75,156.14 247.84,156.14 247.71,156.28 247.71,158.75 248.58,159.62 249.43,159.62
+VDDCT_L on BOTTOM (solid shape): 257.14,159.3 257.56,159.3 257.78,159.08 257.78,156.54 257.44,156.2 255.75,156.2 255.52,156.43 255.52,158.79 256.41,159.67 256.76,159.67
GND on TOP (solid shape): 146.26,105.91 146.26,104.57 146.19,104.51 145.3,104.51 145.24,104.57 145.24,105.91 145.37,106.03 146.13,106.03
GND on TOP (solid shape): 148.67,105.91 148.67,104.57 148.61,104.51 147.72,104.51 147.65,104.57 147.65,105.97 147.78,106.1 148.48,106.1
GND on TOP (solid shape): 154.07,77.14 154.07,74.41 153.81,74.16 150.77,74.16 150.51,74.41 150.51,77.2 150.83,77.52 153.69,77.52
GND on TOP (solid shape): 171.24,81.74 171.24,78.86 170.91,78.52 169.55,78.52 169.4,78.66 169.4,81.74 169.47,81.81 171.18,81.81
GND on TOP (solid shape): 209.77,168.66 209.77,166.42 209.63,166.28 208.72,166.28 208.56,166.45 208.56,168.56 208.76,168.76 209.66,168.76
GND on TOP (solid shape): 209.78,171.73 209.78,170.19 209.71,170.12 207.34,170.12 207.19,170.27 207.19,171.66 207.34,171.8 209.7,171.8
GND on TOP (solid shape): 238.31,138.21 238.31,134.31 238.16,134.17 236.14,134.17 235.96,134.35 235.96,138.34 236.09,138.47 238.04,138.47
GND on TOP (solid shape): 238.89,171.43 238.89,169.64 238.84,169.59 237.14,169.59 237,169.73 237,171.12 237.41,171.53 238.79,171.53
GND on TOP (solid shape): 277.84,142.34 277.84,138.36 277.53,138.05 273.71,138.05 273.45,138.31 273.45,142.49 273.71,142.74 277.43,142.74
GND on TOP (solid shape): 294.61,65.45 294.61,63.29 294.43,63.11 292.15,63.11 292.07,63.19 292.07,65.95 292.25,66.13 293.92,66.13
GND on TOP (solid shape): 335.8,33.84 335.8,31.3 335.67,31.17 334.46,31.17 334.4,31.23 334.4,33.84 334.53,33.96 335.67,33.96
GND on TOP (solid shape): 149.68,81.46 149.68,78.45 149.49,78.26 148.43,78.26 148.28,78.41 148.28,81.52 148.41,81.65 149.49,81.65
GND on TOP (solid shape): 82.5,22.28 82.5,20.82 82.37,20.69 80.52,20.69 80.4,20.81 80.4,22.22 80.65,22.47 82.3,22.47
GND on TOP (solid shape): 152.35,81.63 152.35,78.35 152.29,78.28 150.87,78.28 150.58,78.58 150.58,81.58 150.77,81.78 152.21,81.78
GND on TOP (solid shape): 154.58,117.21 154.58,117.08 154.38,116.89 154.38,115.39 154.24,115.24 153.99,115.24 153.81,115.42 153.81,117.21 153.94,117.34 154.45,117.34
GND on TOP (solid shape): 158.28,111 158.28,110.16 158.2,110.09 157.29,110.09 157.2,110.18 157.2,110.61 157.13,110.67 157.13,110.98 157.25,111.09 158.19,111.09
GND on TOP (solid shape): 220.96,105.62 220.96,104.71 220.84,104.59 218.42,104.59 218.36,104.65 218.36,105.15 219,105.79 220.79,105.79
GND on TOP (solid shape): 221.52,172.37 221.52,171.69 221.28,171.45 221.28,169.66 221.16,169.54 220.09,169.54 219.98,169.66 219.98,171.87 220.63,172.52 221.37,172.52
GND on TOP (solid shape): 229.29,138.23 229.29,134.44 228.96,134.11 226.82,134.11 226.66,134.27 226.66,138.28 226.87,138.49 229.03,138.49
GND on TOP (solid shape): 256.18,7 256.18,6.34 255.95,6.11 249.8,6.11 249.69,6.21 249.69,7.1 249.82,7.23 255.95,7.23
GND on TOP (solid shape): 292.52,47.01 292.52,45.17 292.3,44.95 292.3,39.3 291.92,38.92 290.78,38.92 290.33,39.36 290.33,47.43 290.58,47.68 291.85,47.68
GND on TOP (solid shape): 141.31,106.18 141.31,105.98 141.24,105.91 141.24,104.91 141.09,104.75 140.3,104.75 140.22,104.83 140.22,106.13 140.39,106.3 141.18,106.3
GND on TOP (solid shape): 220.95,109 220.95,107.08 220.75,106.87 218.88,106.87 218.47,107.28 218.47,109.19 218.72,109.44 220.51,109.44
GND on TOP (solid shape): 284.96,66.41 284.96,63.33 284.76,63.12 282.44,63.12 282.01,63.55 282.01,66.41 282.27,66.67 284.7,66.67
GND on TOP (solid shape): 8.14,66.79 8.14,66.09 7.82,65.78 7.06,65.78 6.49,65.21 6.49,64.95 6.36,64.82 5.79,64.82 5.6,65.01 5.6,66.48 6.1,66.98 7.95,66.98
GND on TOP (solid shape): 156.65,106.4 156.65,105.95 157.03,105.57 157.03,105.36 156.8,105.13 156.8,104.5 156.73,104.42 156.12,104.42 155.99,104.55 155.99,106.45 156.02,106.48 156.57,106.48
GND on TOP (solid shape): 165.74,165.74 165.74,165.33 166.07,165 166.07,164.62 165.69,164.24 164.8,164.24 164.75,164.29 164.75,164.87 164.98,165.1 164.98,165.64 165.16,165.81 165.67,165.81
GND on TOP (solid shape): 169.68,107.29 169.68,105.46 169.12,104.91 166.96,104.91 166.91,104.96 166.91,105.79 167.06,105.95 169.07,105.95 169.17,106.05 169.17,107.29 169.3,107.42 169.55,107.42
GND on TOP (solid shape): 171.59,77.52 171.59,74.73 171.28,74.41 168.18,74.41 168.04,74.56 168.04,77.52 168.29,77.78 171.34,77.78
GND on TOP (solid shape): 176.03,66.13 176.03,64.38 176.41,64 176.41,63.11 176.09,62.79 174.95,62.79 174.7,63.05 174.7,66.12 174.84,66.25 175.91,66.25
GND on TOP (solid shape): 179.21,41.96 179.21,41.33 179.46,41.08 179.46,37.71 179.27,37.52 177.94,37.52 177.68,37.77 177.68,38.73 178.19,39.23 178.19,41.84 178.44,42.09 179.08,42.09
GND on TOP (solid shape): 222.45,136.64 222.45,135.82 222.2,135.57 220.67,135.57 220.31,135.21 220.31,134.1 219.96,133.74 218.16,133.74 217.73,134.18 217.73,136.62 218,136.9 222.2,136.9
GND on TOP (solid shape): 146.57,128.63 146.57,125.94 145.93,125.3 143.87,125.3 143.77,125.39 143.77,125.83 144.01,126.06 144.01,128.66 144.1,128.76 146.44,128.76
GND on TOP (solid shape): 151.08,105.97 151.08,103.55 150.81,103.28 150.45,103.28 150.13,103.6 150.13,104.51 150.07,104.57 150.07,105.97 150.19,106.1 150.96,106.1
GND on TOP (solid shape): 159.34,106.4 159.34,105.65 159.46,105.53 159.46,104.21 159.39,104.14 158.53,104.14 158.43,104.24 158.43,105.59 158.66,105.82 158.66,106.4 158.73,106.48 159.27,106.48
GND on TOP (solid shape): 172.14,149.1 172.14,148.31 172.13,148.29 172.13,147.79 171.84,147.5 169.45,147.5 168.97,147.98 168.36,147.98 168.21,148.14 168.21,149.13 168.44,149.36 171.89,149.36
GND on TOP (solid shape): 200.43,185.4 200.75,185.25 201.1,185.2 205.22,185.2 205.22,178.5 199.22,178.5 199.22,185.4
GND on TOP (solid shape): 179.02,130.99 179.02,128.83 179.5,128.35 179.51,128.34 179.51,125.95 179.13,125.58 175.69,125.58 175.2,126.07 175.2,129.29 176.07,130.16 176.41,130.16 177.49,131.25 178.76,131.25
GND on TOP (solid shape): 274.76,165.72 274.76,160.31 274.5,160.06 270.74,160.06 270.73,160.06 269.66,160.06 269.34,160.38 269.34,165.64 269.53,165.84 274.65,165.84
GND on TOP (solid shape): 188.86,160.82 190.06,160.82 190.45,160.42 190.45,159.92 190.41,159.88 190.41,159.06 190.05,158.71 188.35,158.71 188.18,158.88 188.18,159.18 188.18,161.03 188.28,161.13 188.56,161.13
GND on TOP (solid shape): 198.03,186.36 198.03,179.43 197.7,179.1 196.69,179.1 195.86,179.93 195.86,181.13 196.27,181.53 196.7,181.53 197.07,181.9 197.07,182.69 197.07,182.69 197.07,182.87 196.87,183.06 195.92,183.06 195.7,183.28 195.7,186.24 196.02,186.55 197.84,186.55
GND on TOP (solid shape): 259.51,21.35 259.51,20.91 258.77,20.17 258.77,17.08 258.63,16.95 258.63,16.32 258.43,16.12 256.29,16.12 256.1,16.31 256.1,19.23 256.27,19.39 257.41,19.39 257.63,19.61 257.63,21.07 258,21.44 259.42,21.44
GND on TOP (solid shape): 161.88,106.35 161.88,104.83 161.81,104.76 160.86,104.76 160.8,104.83 160.8,105.37 160.81,105.46 160.8,105.55 160.8,105.65 160.61,105.84 160.42,105.84 160.35,105.91 160.35,106.45 160.36,106.45 161.78,106.45
GND on TOP (solid shape): 206.05,105.85 206.05,105.35 205.67,104.96 203.31,104.96 203.08,104.73 201.57,104.73 201.46,104.84 201.46,105.4 201.6,105.54 202.31,105.54 202.45,105.68 202.45,105.97 202.69,106.21 205.68,106.21
GND on TOP (solid shape): 214.83,172.17 214.83,167.32 214.64,167.14 213.29,167.14 213.11,167.31 213.11,168.46 212.73,168.84 212.05,168.84 211.82,169.08 211.82,169.85 212.51,170.53 212.51,171.53 212.68,171.71 213.53,171.71 213.8,171.97 213.8,172.23 213.93,172.36 214.64,172.36
GND on TOP (solid shape): 159.21,117.75 159.21,115.45 159.03,115.27 158.33,115.27 158.13,115.47 158.14,115.56 158.13,115.65 158.13,116.89 157.94,117.08 157.94,117.27 158.07,117.4 158.48,117.4 158.58,117.51 158.58,117.81 158.84,118.07 158.89,118.07
GND on TOP (solid shape): 177.68,54.28 177.68,53.71 177.62,53.65 176.98,53.65 176.44,53.11 176.44,52.22 177.11,51.55 177.49,51.55 177.81,51.24 177.81,49.39 177.3,48.89 177.3,48.31 176.92,47.93 176.92,47.43 176.73,47.23 175.52,47.23 175.01,47.74 175.01,53.46 175.9,54.35 177.62,54.35
GND on TOP (solid shape): 179.78,149.29 179.78,148.26 179.65,148.14 178.19,148.14 178.02,147.96 178.02,147.33 177.87,147.18 175.92,147.18 175.81,147.3 175.81,147.32 175.79,147.49 175.7,147.63 175.7,148.9 176.18,149.38 179.69,149.38
GND on TOP (solid shape): 203.15,163.25 203.46,163.25 203.53,163.19 203.53,162.3 203.46,162.23 201.62,162.23 201.3,162.55 201.3,162.73 201.31,162.74 201.33,162.83 201.33,162.93 201.32,162.95 201.68,163.31 201.68,163.57 201.81,163.69 202.7,163.69
GND on TOP (solid shape): 28.46,49.39 28.46,48.63 28.27,48.44 28.27,46.73 28.2,46.66 27.95,46.66 27.69,46.41 27.69,45.71 27.63,45.65 27.12,45.65 27.06,45.71 27.06,46.41 26.81,46.66 25.73,46.66 25.47,46.92 25.47,47.81 25.09,48.19 25.09,48.76 25.85,49.52 28.33,49.52
GND on TOP (solid shape): 156.16,150.99 156.16,150.17 156.09,150.1 155.58,150.1 155.46,150.23 155.46,150.8 155.2,151.06 153.11,151.06 152.73,150.68 152.73,149.6 152.54,149.41 151.77,149.41 151.65,149.53 151.65,150.19 151.52,150.31 151.21,150.31 151.08,150.45 151.08,151.37 151.33,151.63 155.52,151.63
GND on TOP (solid shape): 188.16,132.59 188.17,132.59 188.73,132.03 188.73,125.67 188.45,125.39 184.82,125.39 184.55,125.66 184.55,127.21 183.55,128.2 183.55,128.96 184.21,129.62 185.38,129.62 185.53,129.77 185.53,132.68 185.75,132.9 187.85,132.9
GND on TOP (solid shape): 64.84,28.31 67.89,28.31 68.3,27.9 68.3,26.76 68.14,26.6 65.86,26.6 65.35,26.09 65.35,23.93 65.29,23.87 64.4,23.87 63.95,23.42 63.45,23.42 63.32,23.55 63.32,25.45 62.94,25.84 62.05,25.84 61.6,26.28 61.35,26.28 61.16,26.47 61.16,28.31 61.29,28.44 64.72,28.44
GND on TOP (solid shape): 296.17,61.65 296.17,59.27 296.16,59.18 296.17,59.1 296.17,52.44 297.9,50.71 297.9,48.49 297.7,48.29 293.98,48.29 291.79,50.47 291.79,52.31 289.96,54.14 289.96,61.31 291.5,62.84 294.98,62.84
GND on TOP (solid shape): 301.32,37.52 301.32,37.25 301.32,36.88 301.44,36.76 301.76,36.76 301.89,36.63 301.89,36.31 301.82,36.25 301.44,36.25 301.32,36.12 301.32,33.69 301.26,33.63 299.94,33.63 299.86,33.72 299.86,37.65 299.98,37.77 301.06,37.77
GND on TOP (solid shape): 9.57,68.1 1.27,68.1 1.27,73.9 1.51,74.46 2.07,74.7 9.57,74.7
GND on TOP (solid shape): 154.25,134.17 154.25,131.25 153.78,130.77 153.75,130.76 153.71,130.77 153.67,130.79 153.63,130.8 151.11,130.8 151.11,133.69 151.08,133.77 151.01,133.82 151.01,134.1 151.46,134.55 153.87,134.55
GND on TOP (solid shape): 139.91,116.38 139.91,110.67 139.78,110.54 139.34,110.54 139.08,110.8 139.08,111.53 139.09,111.62 139.08,111.71 139.08,113.53 138.83,113.78 138.83,115.02 138.84,115.11 138.83,115.21 138.83,116.38 138.89,116.45 139.84,116.45
GND on TOP (solid shape): 156.83,117.3 156.83,115.45 156.68,115.29 155.87,115.29 155.72,115.45 155.73,115.56 155.72,115.65 155.72,116.76 155.78,116.83 155.87,116.83 156.16,116.83 156.35,117.02 156.35,117.27 156.48,117.4 156.73,117.4
GND on TOP (solid shape): 149.81,115.93 149.81,113.4 149.24,112.83 149.24,109.46 149.13,109.35 148.73,109.35 148.61,109.47 148.61,111.53 148.62,111.62 148.61,111.71 148.61,113.59 148.73,113.72 148.73,114.15 149.03,114.45 149.03,115.33 148.73,115.62 148.73,116.01 148.83,116.11 149.63,116.11
GND on TOP (solid shape): 180.55,185.4 180.87,185.25 181.22,185.2 183.56,185.2 184.34,185.2 184.69,185.25 185.01,185.4 186.22,185.4 186.22,178.5 180.22,178.5 180.22,185.4
GND on TOP (solid shape): 144.86,116.38 144.86,113.78 144.48,113.4 144.48,110.61 144.35,110.48 143.91,110.48 143.72,110.67 143.72,111.53 143.73,111.62 143.72,111.71 143.72,113.53 143.78,113.59 143.78,115.02 143.79,115.11 143.78,115.2 144.13,115.54 144.13,116.4 144.18,116.45 144.8,116.45
GND on TOP (solid shape): 147.34,116.38 147.34,113.84 147.33,113.84 147.33,113.79 147.27,113.72 147.27,112.58 147.07,112.39 147.07,112.26 147.03,112.21 147.03,111.41 146.92,111.31 146.74,111.31 146.59,111.15 146.59,109.71 146.57,109.68 146.01,109.68 145.83,109.86 145.83,111 146.2,111.37 146.2,111.49 146.22,111.51 146.22,113.74 146.26,113.78 146.26,116.38 146.38,116.51 147.21,116.51
GND on TOP (solid shape): 154.7,107.24 154.7,105.55 154.69,105.46 154.7,105.37 154.7,104.1 154.73,104.1 155.08,103.75 155.08,103.37 155.02,103.3 154.13,103.3 154,103.43 154,103.79 153.65,104.14 153.65,104.47 153.78,104.6 153.83,104.6 154,104.78 154,107.18 154.13,107.3 154.64,107.3
GND on TOP (solid shape): 157.29,129.97 157.29,125.95 156.93,125.59 154.81,125.59 154.5,125.76 154.2,125.59 153.99,125.59 153.99,128.41 155.76,130.18 157.08,130.18
GND on TOP (solid shape): 33.73,54.16 33.73,52.25 34.04,51.93 34.04,50.54 33.92,50.41 33.22,50.41 33.09,50.54 33.09,51.62 32.97,51.74 32.08,51.74 32.01,51.81 32.01,52.06 32.14,52.19 32.77,52.19 33.03,52.44 33.03,53.27 32.84,53.46 32.33,53.46 32.2,53.58 32.2,54 32.26,54.13 32.31,54.26 32.46,54.41 33.47,54.41
GND on TOP (solid shape): 152.23,116.38 152.23,114.99 152.48,114.73 152.48,113.15 152.35,113.02 152.35,109.4 152.23,109.27 151.16,109.27 151.02,109.42 151.02,112.89 151.15,113.02 151.15,113.43 151.16,113.53 151.15,113.62 151.15,116.38 151.21,116.45 152.16,116.45
GND on TOP (solid shape): 95.26,37.82 95.26,36.76 95.13,36.63 95.13,35.23 95.26,35.11 96.02,35.11 96.08,35.17 96.08,36.44 96.15,36.5 96.53,36.5 96.66,36.38 96.66,33.55 94.5,31.39 90.46,31.39 90.24,31.61 90.24,33.07 90.37,33.2 93.48,33.2 93.73,33.46 93.73,34.6 93.35,34.98 93.35,37.75 93.51,37.9 95.18,37.9
GND on TOP (solid shape): 142.38,116.38 142.38,113.72 142.19,113.53 142.19,110.67 142.13,110.61 141.56,110.61 141.3,110.86 141.3,111.41 141.38,111.62 141.3,111.83 141.3,115.02 141.32,115.11 141.3,115.21 141.3,116.38 141.37,116.45 142.32,116.45
GND on TOP (solid shape): 285.45,47.98 285.45,42.88 285.57,42.77 285.57,41.99 285.59,41.99 285.59,41.11 285.66,41.11 285.66,39.46 285.44,39.25 285.44,39.09 285.43,38.98 285.44,38.88 285.44,38.01 285.33,37.89 284.84,37.89 284.63,38.11 284.63,39.79 284.15,40.28 284.15,44.53 283.41,45.27 283.41,48.06 283.6,48.25 285.19,48.25
GND on TOP (solid shape): 148.45,150.98 148.45,150.17 148.59,150.03 149.12,150.03 149.21,149.94 149.21,149.43 149.16,149.38 148.47,149.38 147.68,150.17 146.19,150.17 146.06,150.3 146.06,150.55 145.87,150.74 144.22,150.74 144.09,150.61 144.09,149.15 144.03,149.09 143.33,149.09 143.24,149.18 143.24,150.68 143.2,150.71 143.2,151.06 143.38,151.23 148.19,151.23
GND on TOP (solid shape): 143.01,149.53 143.01,147.88 143.21,147.68 145.93,147.68 146.43,147.18 147.94,147.18 148.66,146.46 148.66,140.96 148.09,140.39 146.37,140.39 146.12,140.65 146.12,143.82 146.12,143.82 146.12,144.32 145.96,144.48 145.37,144.48 145.35,144.46 141.1,144.46 140.91,144.65 140.91,146.82 141.13,147.04 141.13,147.4 141.49,147.76 142.1,147.76 142.24,147.89 142.24,149.52 142.38,149.66 142.88,149.66
GND on TOP (solid shape): 241.97,36.96 242.19,36.96 242.59,36.57 242.59,36.44 242.42,36.27 242.18,36.27 241.96,36.49 241.96,36.64 241.19,36.64 241.19,36.63 241.13,36.63 241.01,36.52 241.01,33.29 240.9,33.18 240.37,33.18 240.28,33.27 240.28,33.87 240.09,34.06 239.78,34.06 239.65,34.19 239.65,34.41 239.8,34.55 240.07,34.55 240.25,34.73 240.25,36.49 240.26,36.49 240.26,36.85 240.39,36.98 241.96,36.98
GND on TOP (solid shape): 162.4,148.39 162.4,148.32 162.35,148.28 162.35,147.45 162.32,147.41 162.29,147.37 162.11,147.2 162.11,147.04 161.93,146.87 161.17,146.87 161.11,146.92 160.02,146.92 159.83,147.12 159.2,147.12 159.2,147.13 159.18,147.13 159.13,147.18 159.03,147.18 158.92,147.29 158.93,147.32 158.94,147.44 158.92,147.56 158.91,147.57 158.91,148.26 159.36,148.71 162.07,148.71
GND on TOP (solid shape): 268.22,11.8 270.69,10.77 271.72,8.3 271.72,5 258.57,5 258.57,11.8
GND on TOP (solid shape): 167.53,116.57 167.53,116.07 167.47,116 166.96,116 166.77,115.81 166.77,111.56 166.89,111.43 166.89,108.16 166.86,108.13 166.86,107.55 166.81,107.5 166.46,107.5 166.38,107.57 166.38,107.88 166.01,108.26 166.01,108.72 165.9,108.82 165.46,108.82 165.36,108.92 165.36,110.32 165.49,110.44 165.79,110.44 166.01,110.65 166.01,111.49 166.2,111.68 166.2,114.66 166.07,114.79 166.05,114.79 166.02,114.81 165.77,114.81 165.64,114.94 165.64,115.12 166.2,115.67 166.2,116.57 166.32,116.7 167.4,116.7
GND on TOP (solid shape): 322.89,25.97 322.89,25.79 322.89,25.78 322.89,24.06 322.7,23.77 322.84,23.46 322.88,23.42 322.83,23.37 322.82,23.36 322.72,23.29 322.64,23.19 322.64,23.18 321.24,23.18 321.14,23.28 321.14,23.9 320.91,24.13 319.73,24.13 319.56,24.3 319.56,24.8 319.66,24.9 320.29,24.9 320.73,25.34 320.73,25.97 321.05,26.29 322.56,26.29
GND on TOP (solid shape): 33.17,15.58 33.17,14.06 33.3,13.93 34.38,13.93 34.5,14.06 34.5,15.52 34.57,15.58 35.08,15.58 35.14,15.52 35.14,14.06 35.27,13.93 36.35,13.93 36.35,9.29 36.09,9.29 35.96,9.17 35.96,7.68 35.89,7.6 35.42,7.6 35.33,7.69 35.33,9.17 35.2,9.29 32.98,9.29 32.79,9.1 32.79,7.68 32.69,7.58 32.22,7.58 32.14,7.65 32.14,8.9 31.73,9.31 31.73,11.87 31.5,12.11 30.1,12.11 30.05,12.16 30.05,12.66 30.12,12.73 31.59,12.73 31.77,12.91 31.77,13.93 32.79,13.93 32.92,14.06 32.92,15.58 32.98,15.64 33.11,15.64
GND on TOP (solid shape): 151.84,108.54 151.84,108.22 151.78,108.16 151.46,108.16 151.34,108.03 151.34,108.02 151.32,108.01 151.26,107.81 151.32,107.61 151.34,107.6 151.34,107.59 151.46,107.46 151.72,107.46 151.84,107.33 151.84,106.95 151.78,106.89 151.46,106.89 151.34,106.76 151.34,106.75 151.32,106.74 151.26,106.55 151.31,106.36 151.34,106.32 151.27,106.26 150.77,106.26 150.7,106.32 150.7,108.67 150.77,108.73 151.65,108.73
GND on TOP (solid shape): 313.32,45.19 313.32,41.87 313.15,41.71 312.47,41.71 312.15,42.03 311.67,42.03 311.44,42.26 311.44,43.04 311.29,43.19 311.29,44.85 311.93,44.87 311.5,45.35 311.54,45.39 313.11,45.39
GND on TOP (solid shape): 140.35,108.51 140.35,108.19 140.29,108.13 140.25,108.13 140.16,108.14 140.07,108.13 139.97,108.13 139.84,108 139.84,107.9 139.83,107.81 139.84,107.72 139.84,107.56 139.97,107.43 140.22,107.43 140.35,107.3 140.35,106.92 140.29,106.86 140.25,106.86 140.16,106.87 140.07,106.86 139.97,106.86 139.84,106.73 139.84,106.63 139.83,106.54 139.84,106.45 139.84,106.29 139.78,106.22 139.27,106.22 139.21,106.29 139.21,108.64 139.27,108.7 140.16,108.7
GND on TOP (solid shape): 165.48,107.7 165.49,107.64 165.5,107.59 165.5,106.38 165.49,106.33 165.48,106.27 165.31,106.1 164.8,106.1 164.46,105.76 164.45,105.75 164.37,105.7 164.31,105.61 164.23,105.53 164.23,104.26 164.16,104.19 163.85,104.19 163.78,104.26 163.75,104.33 163.72,104.39 163.72,104.51 163.59,104.64 163.4,104.64 163.21,104.83 163.21,105.53 163.34,105.65 163.66,105.65 163.91,105.91 163.91,107.68 164.1,107.87 165.31,107.87
GND on TOP (solid shape): 147.21,108.54 147.21,108.22 147.16,108.18 147.12,108.19 146.99,108.2 146.87,108.17 146.85,108.16 146.83,108.16 146.7,108.03 146.7,107.97 146.69,107.87 146.7,107.78 146.7,107.59 146.83,107.46 147.08,107.46 147.21,107.33 147.21,106.95 147.16,106.91 147.12,106.92 146.99,106.93 146.87,106.9 146.85,106.89 146.83,106.89 146.7,106.76 146.7,106.7 146.69,106.6 146.7,106.51 146.7,106.32 146.64,106.26 146.13,106.26 146.07,106.32 146.07,108.67 146.13,108.73 147.02,108.73
GND on TOP (solid shape): 149.56,108.54 149.56,108.22 149.51,108.18 149.47,108.19 149.34,108.2 149.21,108.17 149.2,108.16 149.18,108.16 149.05,108.03 149.05,107.97 149.04,107.87 149.05,107.78 149.05,107.59 149.18,107.46 149.43,107.46 149.56,107.33 149.56,106.95 149.51,106.91 149.47,106.92 149.34,106.93 149.21,106.9 149.2,106.89 149.18,106.89 149.05,106.76 149.05,106.7 149.04,106.6 149.05,106.51 149.05,106.32 148.99,106.26 148.48,106.26 148.42,106.32 148.42,108.67 148.48,108.73 149.37,108.73
GND on TOP (solid shape): 16.58,33.77 16.58,32.38 14.75,30.54 1.27,30.54 1.27,31.9 1.51,32.46 2.07,32.7 11.68,32.7 12.45,32.2 13.05,32.9 13.05,33.65 13.37,33.96 16.39,33.96
GND on TOP (solid shape): 144.24,108.62 144.24,108.3 144.17,108.24 144.15,108.24 143.74,108.17 143.72,107.75 143.73,107.74 143.73,107.67 143.86,107.54 144.11,107.54 144.24,107.41 144.24,107.03 144.17,106.97 144.15,106.97 143.78,106.94 143.67,106.59 143.67,104.72 143.62,104.68 142.81,104.68 142.66,104.83 142.66,106.28 142.96,106.58 142.96,108.61 143.16,108.81 144.05,108.81
GND on TOP (solid shape): 222.94,45.45 222.94,43.44 223.15,43.23 224.68,43.23 224.89,43.03 224.89,42.21 224.77,42.09 224.34,42.09 224.22,42.21 221.04,42.21 220.25,43 220.25,44.06 220.31,44.06 220.32,44.01 220.33,43.95 220.35,43.9 220.38,43.86 220.41,43.82 220.45,43.78 220.49,43.75 220.54,43.73 220.59,43.71 220.64,43.7 220.7,43.7 220.75,43.71 220.8,43.73 220.85,43.75 220.89,43.78 220.93,43.82 220.97,43.86 220.99,43.9 221.01,43.95 221.02,44.01 221.03,44.06 221.02,44.11 221.01,44.16 220.99,44.21 220.97,44.26 220.93,44.3 220.89,44.34 220.85,44.37 220.8,44.39 220.75,44.41 220.7,44.42 220.64,44.42 220.59,44.41 220.54,44.39 220.49,44.37 220.45,44.34 220.41,44.3 220.38,44.26 220.35,44.21 220.33,44.16 220.32,44.11 220.31,44.06 220.25,44.06 220.25,45.46 220.53,45.74 222.66,45.74
GND on TOP (solid shape): 234.2,117.15 234.2,114.61 234.32,114.48 234.32,113.02 234.13,112.83 233.18,112.83 233.05,112.96 233.05,113.8 233.59,113.8 233.59,113.74 233.6,113.69 233.62,113.64 233.65,113.59 233.68,113.55 233.72,113.52 233.76,113.49 233.81,113.46 233.86,113.45 233.92,113.44 233.97,113.44 234.02,113.45 234.07,113.46 234.12,113.49 234.17,113.52 234.2,113.55 234.24,113.59 234.26,113.64 234.28,113.69 234.3,113.74 234.3,113.8 234.3,113.85 234.28,113.9 234.26,113.95 234.24,114 234.2,114.04 234.17,114.07 234.12,114.1 234.07,114.13 234.02,114.14 233.97,114.15 233.92,114.15 233.86,114.14 233.81,114.13 233.76,114.1 233.72,114.07 233.68,114.04 233.65,114 233.62,113.95 233.6,113.9 233.59,113.85 233.59,113.8 233.05,113.8 233.19,113.93 233.19,113.94 233.19,117.22 233.35,117.38 233.97,117.38
GND on TOP (solid shape): 161.69,117.15 161.69,116.92 161.69,116.89 161.62,116.83 161.62,115.12 161.83,114.91 162.7,114.91 162.96,115.17 162.96,115.47 162.97,115.56 162.96,115.65 162.96,116.8 162.7,117.06 162.7,117.27 162.77,117.34 162.77,117.34 162.83,117.39 163.76,117.39 163.91,117.25 163.91,117.05 164.14,116.82 164.14,116.29 164.48,115.95 164.48,114.42 164.23,114.16 164.23,110.35 163.97,110.1 163.27,110.1 163.21,110.16 163.21,110.2 163.22,110.28 163.21,110.38 163.21,111.02 163.03,111.2 162.31,111.2 162.04,111.48 160.75,111.48 160.54,111.69 160.54,115.47 160.56,115.56 160.54,115.65 160.54,116.83 160.48,116.89 160.48,116.92 160.45,116.92 160.29,117.08 160.29,117.27 160.42,117.4 161.43,117.4
GND on TOP (solid shape): 221.92,122.44 221.92,120.13 221.86,120.06 221.17,120.06 220.97,120.26 218.04,120.26 217.97,120.33 217.98,120.36 217.99,120.41 217.99,120.47 217.99,120.52 217.97,120.58 217.95,120.63 217.92,120.67 217.88,120.71 217.84,120.75 217.81,120.76 217.81,122.11 220.37,122.11 220.37,122.06 220.38,122.01 220.4,121.96 220.43,121.91 220.46,121.87 220.5,121.83 220.54,121.8 220.59,121.78 220.64,121.77 220.7,121.76 220.75,121.76 220.8,121.77 220.85,121.78 220.9,121.8 220.94,121.83 220.98,121.87 221.02,121.91 221.04,121.96 221.06,122.01 221.08,122.06 221.08,122.11 221.08,122.17 221.06,122.22 221.04,122.27 221.02,122.31 220.98,122.36 220.94,122.39 220.9,122.42 220.85,122.45 220.8,122.46 220.75,122.47 220.7,122.47 220.64,122.46 220.59,122.45 220.54,122.42 220.5,122.39 220.46,122.36 220.43,122.31 220.4,122.27 220.38,122.22 220.37,122.17 220.37,122.11 217.81,122.11 217.81,122.39 218.01,122.59 221.77,122.59
GND on TOP (solid shape): 228.21,106.51 228.35,106.44 228.49,106.44 228.58,106.42 228.62,106.34 228.62,105.76 228.58,105.68 228.49,105.66 228.1,105.35 228.49,105.04 228.58,105.02 228.62,104.94 228.62,104.4 228.22,104.4 228.02,104.2 228.02,103.75 228.22,103.55 228.62,103.55 228.62,103.1 228.52,103 227.45,103 226.7,103.75 226.7,104.38 226.77,104.45 227.47,104.45 227.72,104.7 227.72,106 228.04,106 228.04,106.37 228.18,106.51
GND on TOP (solid shape): 51.7,39.87 51.7,38.47 51.15,37.93 51.15,34.97 51.05,34.86 50.82,34.86 50.24,34.28 50.22,34.28 49.54,33.59 49.54,33.33 49.03,32.82 47.33,32.82 47.23,32.91 47.23,33.85 47.04,34.05 46.44,34.05 46.42,34.03 46.4,34.03 45.79,33.42 45.79,33.4 45.62,33.23 45.62,32.36 45.62,32.36 45.62,32.21 45.55,32.13 44.8,32.13 44.71,32.22 44.71,34.34 45.28,34.92 46.49,34.92 46.66,35.08 46.66,36.64 46.75,36.74 47.97,36.74 48.12,36.88 48.71,36.88 48.87,37.04 48.9,37.04 49.18,37.31 48.93,37.6 48.87,37.64 48.84,37.7 48.84,38.09 48.59,38.34 47.63,38.34 47.57,38.41 47.57,39.23 47.76,39.42 50.62,39.42 51.13,39.93 51.63,39.93
GND on TOP (solid shape): 253.8,115.44 253.8,115.04 254.88,113.97 255.63,113.97 255.84,113.76 255.84,111.5 255.53,111.19 255.09,111.19 254.88,111.4 254.02,111.4 253.92,111.5 253.93,111.53 253.92,111.59 253.92,111.64 253.9,111.69 253.87,111.74 253.84,111.78 253.8,111.82 253.76,111.85 253.71,111.88 253.66,111.9 253.61,111.91 253.55,111.91 253.52,111.9 253.35,112.08 254.53,112.08 254.53,112.03 254.54,111.98 254.56,111.93 254.58,111.88 254.61,111.84 254.64,111.81 254.68,111.78 254.73,111.76 254.78,111.74 254.82,111.73 254.87,111.73 254.92,111.74 254.97,111.76 255.02,111.78 255.06,111.81 255.09,111.84 255.12,111.88 255.14,111.93 255.16,111.98 255.17,112.03 255.17,112.08 255.16,112.12 255.14,112.17 255.12,112.22 255.09,112.26 255.06,112.29 255.02,112.32 254.97,112.34 254.92,112.36 254.87,112.37 254.82,112.37 254.78,112.36 254.73,112.34 254.68,112.32 254.64,112.29 254.61,112.26 254.58,112.22 254.56,112.17 254.54,112.12 254.53,112.08 253.35,112.08 252.7,112.73 252.7,115.39 252.83,115.52 253.72,115.52
GND on TOP (solid shape): 9.57,49.3 1.31,49.3 1.6,49.7 2.07,49.85 2.27,49.85 3.12,50.2 3.47,51.05 3.47,53.55 3.12,54.4 2.27,54.75 2.07,54.75 1.51,54.99 1.27,55.55 1.27,56.1 9.57,56.1
GND on TOP (solid shape): outline of 81 points within 149.82,137.19 163.66,150.14
GND on TOP (solid shape): 179.52,176.71 179.52,175.76 179.88,175.4 179.9,175.37 179.93,175.33 179.96,175.3 180,175.27 180.03,175.25 180.29,175 180.29,173.49 180.29,173.48 180.29,173.25 180.58,172.96 180.58,172.21 180.36,171.99 178.9,171.99 178.85,172.03 178.85,172.75 178.87,172.79 178.88,172.84 178.88,172.89 178.87,172.91 178.87,173 179.14,173.27 179.14,173.28 179.33,173.47 179.33,174.11 179.21,174.23 178.19,174.23 178.13,174.3 178.13,174.45 179.36,174.45 179.36,174.4 179.37,174.35 179.38,174.29 179.41,174.25 179.44,174.2 179.47,174.16 179.51,174.13 179.56,174.1 179.61,174.08 179.66,174.07 179.71,174.07 179.77,174.07 179.82,174.08 179.87,174.1 179.91,174.13 179.96,174.16 179.99,174.2 180.02,174.25 180.05,174.29 180.06,174.35 180.07,174.4 180.07,174.45 180.06,174.5 180.05,174.56 180.02,174.6 179.99,174.65 179.96,174.69 179.91,174.72 179.87,174.75 179.82,174.77 179.77,174.78 179.71,174.78 179.66,174.78 179.61,174.77 179.56,174.75 179.51,174.72 179.47,174.69 179.44,174.65 179.41,174.6 179.38,174.56 179.37,174.5 179.36,174.45 178.13,174.45 178.13,175.06 178.38,175.31 178.38,176.76 178.46,176.84 179.39,176.84
GND on TOP (solid shape): 158.07,109.96 158.11,109.96 160.03,109.96 160.16,109.83 160.16,109.68 159.95,109.48 159.77,109.48 159.7,109.4 159.7,109.38 159.68,109.37 159.6,109.08 159.79,108.85 159.89,108.83 159.96,108.83 159.99,108.83 160.11,108.72 160.11,108.33 160.03,108.26 159.7,108.26 159.6,108.16 159.6,108 159.59,107.94 159.6,107.88 159.6,107.01 159.39,106.81 158.05,106.81 157.95,106.91 157.95,108.08 157.79,108.23 157.68,108.23 157.67,108.24 157.58,108.26 157.48,108.25 157.46,108.24 157.31,108.39 157.31,108.66 157.41,108.77 157.72,108.77 157.87,108.92 157.87,109.08 157.88,109.14 157.87,109.3 157.74,109.43 157.71,109.43 157.7,109.43 157.61,109.46 157.51,109.46 157.49,109.45 157.36,109.58 157.29,109.58 157.29,109.83 157.41,109.96 157.48,109.96 158.02,109.96
GND on TOP (solid shape): 135.52,115.94 135.52,110.48 135.45,110.42 135.35,110.42 135.27,110.43 135.19,110.42 134.74,110.42 134.68,110.42 134.57,110.42 134.37,110.61 134.37,112.85 134.42,112.93 134.51,112.95 134.96,113.25 134.51,113.56 134.42,113.57 134.37,113.66 134.37,114.44 134.42,114.52 134.51,114.53 134.95,114.81 134.55,115.14 134.52,115.13 134.37,115.27 134.37,115.94 134.57,116.13 135.33,116.13
GND on TOP (solid shape): outline of 104 points within 241.93,117.86 246.14,123.66
GND on TOP (solid shape): 242.4,110.6 242.52,110.58 242.64,110.6 242.65,110.61 243.59,110.61 243.6,110.6 243.72,110.58 243.84,110.6 243.85,110.61 244.04,110.61 244.1,110.54 244.1,109.15 243.51,108.55 242.4,108.55 242.33,108.63 238.02,108.63 237.91,108.74 237.18,108.74 237.07,108.63 234.63,108.63 234.55,108.55 230.87,108.55 228.42,108.55 228.28,108.41 228.27,108.41 228.19,108.35 228.14,108.27 228.12,108.25 228.12,108.22 228.1,108.13 228.12,108.03 228.12,108 228.14,107.98 228.19,107.9 228.27,107.84 228.28,107.84 228.62,107.5 228.62,107.16 228.58,107.08 228.49,107.06 228.35,107.06 228.21,106.99 227.98,106.99 227.72,106.73 227.4,107.05 227.4,108.9 226.86,109.45 226.86,109.97 226.92,110.04 229.62,110.04 229.69,109.97 229.69,109.34 229.82,109.21 231.53,109.21 231.72,109.4 231.72,109.97 231.78,110.04 233.12,110.04 233.18,109.97 233.18,109.46 233.37,109.27 234.18,109.27 234.65,109.74 234.71,109.74 234.72,109.74 239.39,109.74 239.47,109.82 239.93,109.82 240.04,109.71 240.04,109.23 240.26,109.02 241.94,109.02 242.01,109.08 242.01,110.48 242.13,110.61 242.39,110.61
GND on TOP (solid shape): 181.3,163.88 181.4,163.88 181.42,163.85 181.47,163.82 181.54,163.73 181.6,163.7 181.62,163.64 181.66,163.51 181.74,163.41 181.77,163.33 181.74,163.25 181.65,162.87 182,162.68 182.03,162.67 182.05,162.64 182.06,162.6 182.08,162.57 182.09,162.53 182.08,162.49 182.08,161.96 182,161.88 181.83,161.88 181.77,161.94 181.77,162.14 181.78,162.15 181.78,162.42 181.65,162.5 181.5,162.54 181.43,162.57 181.41,162.65 181.39,162.82 181.3,162.97 181.29,163.01 181.3,163.04 181.41,163.34 181.29,163.64 181.12,163.8 181.23,163.88
GND on TOP (solid shape): outline of 107 points within 174,171.01 176.53,177.67
GND on TOP (solid shape): 181.27,163.88 181.3,163.88 181.4,163.88 181.54,163.73 181.6,163.7 181.62,163.64 181.66,163.51 181.74,163.41 181.77,163.33 181.74,163.25 181.65,162.88 181.98,162.68 182,162.68 182.05,162.64 182.08,162.57 182.09,162.5 182.04,162.44 182.01,162.41 181.97,162.38 181.9,162.35 181.83,162.38 181.68,162.49 181.5,162.54 181.43,162.57 181.41,162.65 181.39,162.82 181.31,162.97 181.3,162.97 181.29,163.01 181.3,163.04 181.31,163.05 181.41,163.35 181.29,163.64 181.16,163.76 181.15,163.8 181.17,163.84 181.22,163.87
GND on TOP (solid shape): outline of 133 points within 250.2,22.63 262.71,31.17
GND on TOP (solid shape): 235.08,122.31 235.05,122.28 234.99,122.01 235.16,121.79 235.21,121.71 235.18,121.62 235.19,121.11 235.67,121.27 235.75,121.34 235.84,121.32 235.91,121.25 235.91,116.51 235.88,116.48 235.88,116.44 235.75,116.32 235.25,116.32 235.15,116.42 235.15,117.95 234.64,118.45 234.64,119.82 234.45,120.01 234.45,120.7 234.07,121.09 233.89,121.09 233.87,121.11 233.6,121.29 233.31,121.13 233.3,121.1 233.26,121.1 233.19,121.13 233.16,121.21 232.67,121.46 232.76,120.92 232.8,120.91 232.8,119.56 232.74,119.5 230.95,119.5 230.6,119.15 229.85,119.15 229.76,119.24 229.76,121.6 229.52,121.84 228.08,121.84 227.93,121.99 227.93,123.02 228.05,123.14 234.25,123.14
GND on TOP (solid shape): 228.16,93.02 228.16,92.84 228.1,92.65 228.16,92.46 228.16,92.3 228.23,92.24 230.54,92.24 230.73,92.05 231.72,92.05 232.12,92.05 233.12,92.05 233.52,92.05 234.26,92.05 234.32,92.05 234.53,92.26 235.71,92.26 235.9,92.07 236.39,92.07 236.58,92.26 244.36,92.26 244.37,92.25 245.22,92.25 245.22,92.25 245.51,92.25 246.93,90.82 246.93,90.8 246.31,90.17 246.24,90.17 245.31,91.1 243.61,91.1 243.53,91.13 243.51,91.21 243.42,91.44 243.2,91.55 243.18,91.55 243.06,91.66 242.82,91.66 242.82,91.79 242.08,91.79 242.08,91.1 240.73,91.1 240.65,91.14 240.63,91.22 240.32,91.61 240.01,91.22 239.99,91.14 239.91,91.1 233.74,91.1 233.66,91.13 233.64,91.21 233.32,91.57 233,91.21 232.98,91.13 232.9,91.1 230.47,91.1 230.42,91.15 228.37,91.15 227.42,90.2 227.42,90.19 227.3,90.07 227.26,90.07 226.67,90.66 226.67,92.08 226.83,92.24 227.34,92.24 227.4,92.3 227.4,93.02 227.53,93.15 228.04,93.15
GND on TOP (solid shape): outline of 184 points within 199.2,11.6 204.12,19.49
GND on TOP (solid shape): outline of 119 points within 163.86,135.66 188.25,146.66
GND on TOP (solid shape): 176.75,168.66 176.82,168.63 176.85,168.56 176.89,168.41 177.01,168.31 177.04,168.3 177.04,168.11 177.01,168.1 176.85,167.88 177.01,167.66 177.04,167.65 177.04,167.46 177.01,167.45 176.85,167.23 177.01,167.01 177.04,167 177.04,166.81 177.01,166.8 176.85,166.58 177.01,166.36 177.04,166.35 177.04,166.16 177.01,166.15 176.85,165.93 177.01,165.71 177.04,165.7 177.04,165.51 177.01,165.5 176.85,165.28 177.01,165.06 177.04,165.05 177.04,164.86 177.01,164.85 176.91,164.78 176.86,164.68 176.85,164.63 176.82,164.56 176.75,164.54 176.34,164.54 176.28,164.6 176.28,164.89 176.37,164.97 176.39,164.97 176.61,165.21 176.37,165.43 176.31,165.46 176.28,165.53 176.28,165.81 176.37,165.89 176.39,165.89 176.61,166.13 176.37,166.35 176.31,166.38 176.28,166.45 176.28,166.73 176.37,166.81 176.39,166.81 176.61,167.05 176.37,167.27 176.31,167.3 176.28,167.37 176.28,167.65 176.37,167.73 176.39,167.73 176.61,167.97 176.37,168.19 176.31,168.22 176.28,168.29 176.28,168.55 176.39,168.65 176.42,168.65 176.45,168.66
GND on TOP (solid shape): 227.67,185.75 228.23,185.51 228.47,184.95 228.47,184.45 228.82,183.6 229.67,183.25 230.47,183.25 230.47,177.49 231.07,176.79 231.85,177.29 238.3,177.29 239.08,176.79 239.68,177.49 239.68,183.25 240.47,183.25 241.24,183.52 241.65,184.22 241.67,184.22 241.67,184.42 241.91,184.97 242.47,185.2 244.71,185.2 244.71,177.38 244.55,177.22 244.23,177.22 241.53,174.52 241.53,172.87 240.99,172.33 240.29,172.33 239.98,172.65 239.98,174.17 240.23,174.43 240.23,176.08 239.76,176.54 239.64,176.54 238.77,176.35 238.02,176.83 232.13,176.83 231.54,176.39 230.8,176.39 230.13,176.39 229.75,176.01 229.75,174.62 230.2,174.17 230.2,172.39 229.82,172.01 228.29,172.01 227.08,173.22 223.47,173.22 223.08,173.6 223.08,173.92 223.11,173.94 223.11,176.23 223,176.33 222.92,176.44 222.04,176.44 222.04,176.9 223.2,176.9 223.97,176.4 224.57,177.1 224.57,185.75
GND on TOP (solid shape): outline of 572 points within 209.5,140.71 264.3,156.6
GND on TOP (solid shape): outline of 179 points within 16.02,0.2 338.22,185.2
GND on TOP (solid shape): outline of 263 points within 0.2,36 211.24,187.35
GND on TOP (solid shape): outline of 1423 points within 177.59,161.84 186.2,171.35
GND on BOTTOM (solid shape): 30.55,50.92 30.55,49.9 30.43,49.77 29.66,49.77 29.54,49.9 29.54,50.85 29.73,51.04 30.43,51.04
GND on BOTTOM (solid shape): 39.7,52.51 39.7,50.5 39.57,50.38 38.59,50.38 38.36,50.6 38.36,52.57 38.55,52.76 39.44,52.76
GND on BOTTOM (solid shape): 67.38,7.42 67.38,6.09 67.26,5.97 64.71,5.97 64.59,6.09 64.59,7.42 64.78,7.61 67.19,7.61
GND on BOTTOM (solid shape): 148.45,151.64 148.45,150.3 148.32,150.17 147.13,150.17 146.57,150.73 146.57,151.43 146.82,151.68 148.41,151.68
GND on BOTTOM (solid shape): 171.85,129.32 171.85,125.91 171.66,125.72 169.16,125.72 169.01,125.87 169.01,129.41 169.26,129.66 171.52,129.66
GND on BOTTOM (solid shape): 230.61,130.83 230.61,129.88 230.55,129.82 229.47,129.82 229.29,129.99 229.29,130.78 229.4,130.9 230.55,130.9
GND on BOTTOM (solid shape): 231.2,9.31 231.2,7.14 230.87,6.81 229.97,6.81 229.55,7.23 229.55,9.17 229.88,9.5 231.01,9.5
GND on BOTTOM (solid shape): 232.42,130.74 232.42,129.91 232.32,129.82 231.18,129.82 231.12,129.88 231.12,130.83 231.18,130.9 232.26,130.9
GND on BOTTOM (solid shape): 235.56,130.77 235.56,129.82 235.5,129.75 234.42,129.75 234.26,129.91 234.26,130.74 234.36,130.83 235.5,130.83
GND on BOTTOM (solid shape): 237.37,130.67 237.37,129.85 237.28,129.75 236.13,129.75 236.07,129.82 236.07,130.77 236.13,130.83 237.21,130.83
GND on BOTTOM (solid shape): 240.8,130.74 240.8,129.78 240.74,129.72 239.66,129.72 239.47,129.91 239.47,130.67 239.59,130.8 240.74,130.8
GND on BOTTOM (solid shape): 253.18,47.3 253.18,44.19 252.87,43.87 250.24,43.87 249.82,44.29 249.82,47.13 250.3,47.62 252.87,47.62
GND on BOTTOM (solid shape): 256.14,126.07 256.14,121.64 255.8,121.3 254.42,121.3 254.2,121.53 254.2,125.86 254.69,126.35 255.85,126.35
GND on BOTTOM (solid shape): 261.26,125.97 261.26,120.03 261.12,119.89 259.17,119.89 258.87,120.19 258.87,126.19 258.92,126.24 260.99,126.24
GND on BOTTOM (solid shape): 264.59,161.49 264.59,160.01 264.34,159.76 261.57,159.76 261.47,159.87 261.47,161.63 261.61,161.78 264.29,161.78
GND on BOTTOM (solid shape): 266.92,130.57 266.92,122.05 266.56,121.69 263.34,121.69 263.11,121.92 263.11,130.99 263.27,131.15 266.33,131.15
GND on BOTTOM (solid shape): 270.77,59.93 270.77,56.32 270.33,55.87 267.41,55.87 267.09,56.19 267.09,59.81 267.47,60.19 270.52,60.19
GND on BOTTOM (solid shape): 296.36,70.35 296.36,67.34 296.14,67.12 293.44,67.12 293.19,67.36 293.19,70.29 293.57,70.67 296.05,70.67
GND on BOTTOM (solid shape): 187.16,164.85 188.67,164.85 188.67,164.05 186.67,164.05 186.67,164.62 186.29,165 186.29,165.28 186.37,165.36 186.65,165.36
GND on BOTTOM (solid shape): 241.09,50.21 241.09,49.01 240.92,48.83 236.27,48.83 236.09,49.01 236.09,50.31 236.23,50.45 240.85,50.45
GND on BOTTOM (solid shape): 265.57,9.82 265.07,9.33 265.07,7.36 265.57,6.87 265.57,5 258.57,5 258.57,11.8 265.57,11.8
GND on BOTTOM (solid shape): 90.18,51.81 90.18,48.57 89.99,48.38 88.15,48.38 87.83,48.7 87.83,51.68 88.08,51.93 90.05,51.93
GND on BOTTOM (solid shape): 127.22,100.87 127.22,100.02 127,99.8 126.16,99.8 125.85,100.11 125.85,100.81 126.44,101.4 126.69,101.4
GND on BOTTOM (solid shape): 148.73,16.29 148.73,8.45 148.58,8.3 147.17,8.3 147.01,8.46 147.01,16.29 147.12,16.4 148.62,16.4
GND on BOTTOM (solid shape): 151.27,129.4 151.27,126.61 150.31,125.66 149.23,125.66 148.92,125.97 148.91,125.97 148.28,126.6 148.28,129.4 148.98,130.1 150.57,130.1
GND on BOTTOM (solid shape): 171.31,149.33 171.31,148.62 170.98,148.29 169.66,148.29 169.5,148.44 169.5,149.28 169.54,149.32 169.55,149.32 169.74,149.51 171.13,149.51
GND on BOTTOM (solid shape): 173.99,177.62 173.99,176.2 173.55,175.76 170.59,175.76 170.45,175.9 170.45,176.8 170.55,176.9 171.05,176.9 171.92,177.77 173.85,177.77
GND on BOTTOM (solid shape): 236.52,16.97 236.52,15.56 236.69,15.39 236.69,13.38 235.85,12.54 233.97,12.54 233.82,12.68 233.82,16.3 235.21,17.7 235.8,17.7
GND on BOTTOM (solid shape): 129.28,111.53 129.28,106.85 129.19,106.76 127.9,106.76 127.6,107.06 127.6,107.89 128.56,108.85 128.56,111.53 128.63,111.61 129.21,111.61
GND on BOTTOM (solid shape): 29.47,43.17 29.47,42.73 29.35,42.6 28.27,42.6 28.14,42.47 28.14,42.15 28.08,42.09 27.38,42.09 27.25,42.22 27.25,43.3 27.31,43.36 29.28,43.36
GND on BOTTOM (solid shape): 43.44,32.5 43.44,28.25 43.19,27.99 41.41,27.99 41.22,28.18 41.22,29.65 40.9,29.96 40.52,29.96 40.33,30.15 40.33,32.57 40.59,32.82 43.13,32.82
GND on BOTTOM (solid shape): 118,121.25 118,118.03 118.27,117.76 118.85,117.76 118.95,117.66 118.95,117.19 118.81,117.05 117.5,117.05 117.42,117.13 117.42,121.28 117.47,121.33 117.92,121.33
GND on BOTTOM (solid shape): 163.39,148.89 163.39,148.49 163.29,148.39 162.51,148.39 162.37,148.25 162.37,147.6 162.21,147.45 161.98,147.45 161.88,147.55 161.88,148.75 162.29,149.15 163.13,149.15
GND on BOTTOM (solid shape): 174.89,169.6 174.89,167.74 174.89,167.69 174.81,167.62 173.83,167.62 173.52,167.94 173.52,168.86 173.41,168.97 173.41,169.47 173.62,169.68 174.81,169.68
GND on BOTTOM (solid shape): 185.94,129.54 185.94,125.61 185.53,125.2 184.84,125.2 184.57,125.48 184.57,128.37 184.24,128.71 183.75,128.71 183.6,128.86 183.6,129.04 184.26,129.7 185.78,129.7
GND on BOTTOM (solid shape): 292.37,72.53 292.37,71.47 292.14,71.24 290.3,71.24 290.2,71.33 290.2,72.67 290.28,72.74 292.16,72.74
GND on BOTTOM (solid shape): 57.37,12.93 57.37,12.92 57.45,12.84 57.45,11.2 57.26,11.01 56.04,11.01 55.92,11.13 55.92,12.87 56.14,13.09 57.2,13.09
GND on BOTTOM (solid shape): 76.02,52.38 76.02,49.66 75.76,49.41 75.76,42.41 75.75,42.4 68.88,42.4 68.3,42.4 67.38,42.4 67.37,42.41 67.37,52.23 67.71,52.57 75.83,52.57
GND on BOTTOM (solid shape): 33.98,54.16 33.98,51.43 33.6,51.04 32.9,51.04 32.77,50.92 32.77,50.41 32.71,50.35 32.14,50.35 32.01,50.47 32.01,52.95 32.36,53.3 32.36,54.12 32.65,54.41 33.73,54.41
GND on BOTTOM (solid shape): 250.28,154.9 250.28,153.03 249.96,152.71 246.45,152.71 246.13,153.03 244.86,153.03 243.39,154.5 243.39,154.9 243.5,155.01 245.74,155.01 246.05,155.31 249.87,155.31
GND on BOTTOM (solid shape): 99.31,46.42 99.31,44.89 98.81,44.39 98.81,43.51 99.18,43.14 99.18,42.35 99.3,42.24 99.99,42.24 100.08,42.15 100.08,41.14 99.98,41.03 99.17,41.03 98.12,42.08 98.12,46.35 98.39,46.62 99.11,46.62
GND on BOTTOM (solid shape): 156.84,117.22 156.84,117.03 156.46,116.65 156.46,116.02 156.8,115.68 156.8,115.43 156.67,115.3 155.91,115.3 155.78,115.43 155.78,115.72 156.02,115.95 156.02,116.78 156.4,117.16 156.4,117.22 156.53,117.35 156.72,117.35
