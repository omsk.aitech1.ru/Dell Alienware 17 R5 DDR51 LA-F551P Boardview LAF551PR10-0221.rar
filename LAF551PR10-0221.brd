# Allegro board LAF551PR10-0221.brd (continued)
## Nets (continued)
CHR_USB20_P1_R: DU1.3 JUSB1.3 LU3.3
CLK_PCI_LPC: RE89.2 RH89.1 UE5.12
CLK_PCIE_DGPU#_C: CM99.2 JCDRA.34
CLK_PCIE_DGPU_C: CM98.2 JCDRA.33
CLK_PCIE_N1: JSSD1.53 UH1.AH9
CLK_PCIE_N2: JSSD2.53 UH1.AE14
CLK_PCIE_N3: UH1.AE6 UT1.T19
CLK_PCIE_N4: UH1.AC2 UL1.32
CLK_PCIE_N5: JWLAN.41 UH1.AB2
CLK_PCIE_N7: JSSD3.53 UH1.W7
CLK_PCIE_P1: JSSD1.55 UH1.AH10
CLK_PCIE_P2: JSSD2.55 UH1.AE15
CLK_PCIE_P3: UH1.AE7 UT1.V19
CLK_PCIE_P4: UH1.AC3 UL1.33
CLK_PCIE_P5: JWLAN.39 UH1.AB3
CLK_PCIE_P7: JSSD3.55 UH1.W6
CLK_PEG_N0: UG9.BM27 UH1.AJ6
CLK_PEG_N6: UH1.W4 UM4.3
CLK_PEG_P0: UG9.BM26 UH1.AJ7
CLK_PEG_P6: UH1.W3 UM4.2
CLK_SMB: PBATT1.5 PR19.1
CLKDET#: RH558.1 UH1.BF35
CLKREQ_PCIE#1: JSSD1.52 RP3.6 UH1.BE31
CLKREQ_PCIE#2: JSSD2.52 RP3.7 UH1.AR32
CLKREQ_PCIE#3: RT2.2 RT24.1 UH1.BB30
CLKREQ_PCIE#3_R: RT2.1 RT20.2 UT1.AC5
CLKREQ_PCIE#4: RP3.8 UH1.BA30 UL1.4
CLKREQ_PCIE#5: JWLAN.45 RP5.6 UH1.AN29
CLKREQ_PCIE#7: JSSD3.52 R366.1 UH1.AC48
CLKREQ_PEG#0: QG510.1 RP3.5 UH1.BF31
CLKREQ_PEG#0_R: QG510.3 RG2.1 UG9.BL26
CLKREQ_PEG#6: RP5.5 UE5.19 UH1.AE47 UM4.17
CLKRUN#: RH85.1 UH1.AV32
CMSRC_CHG: PR706.2 PU700.3
CNV_BRI_PRX_DTX: RH181.2 UH1.AY2
CNV_BRI_PTX_DRX: RH603.2 UH1.AV4
CNV_RGI_PRX_DTX: RH182.2 UH1.AV3
CNV_RGI_PTX_DRX: RH168.1 RH595.1 UH1.BA4
CNV_WT_RCOMP: RH213.1 UH1.BA1
CODEC_MUTE#: DA3.1 JIO.19 RA70.2 UA4.15
COMP: PC6007.2 PR6017.1 PU6000.30
COMP_1PH: PC509.1 PC510.2 PU500.50
COMP_2PH: PC519.2 PC521.2 PU500.33
COMP_4PH: PC515.1 PR535.1 PU500.6
CORE_SW1: PL501.1 PR555.1 PR601.1 PU502.11 PU502.12
CORE_SW2: PL502.1 PR565.1 PR602.1 PU503.11 PU503.12
CORE_SW3: PL503.1 PR575.1 PR603.1 PU504.11 PU504.12
CORE_SW4: PL506.1 PR593.1 PR604.1 PU510.11 PU510.12
CPU_24MHZ_N: UC1.D31 UH1.C6
CPU_24MHZ_P: UC1.E31 UH1.D7
CPU_B+: PC539.1 PC542.1 PC543.1 PC544.1 PC545.1 PC546.1 PC547.1 PC551.1 PC552.1 PC553.1 PC554.1 PC555.1 PC559.1 PC560.1 PC561.1 PC562.1 PC563.1 PC565.1 PC568.1 PC569.1 PC571.1 PC572.1 PC575.1 PC576.1 PC577.1 PC578.1 PC579.1 PC581.1 PC582.1 PC583.1 PC584.1 PC585.1 PC5013.1 PC5014.1 PC5015.1 PC5016.1 PC5017.1 PC5018.1 PC5019.1 PC5020.1 PC5021.1 PC5022.1 PC5023.1 PC5024.1 PL500.2 PR571.1 PU502.8 PU502.9 PU503.8 PU503.9 PU504.8 PU504.9 PU507.8 PU507.9 PU510.8 PU510.9 PU511.8 PU511.9
CPU_DDC1CLK: RH604.2 RT128.1 UH1.AL13
CPU_DDC1CLK_R: RPT1.3 RT128.2 UT1.Y5
CPU_DDC1DATA: RH605.2 RT129.1 UH1.AR8
CPU_DDC1DATA_R: RPT1.4 RT129.2 UT1.R4
CPU_DDC2CLK: RH607.2 RT126.1 UH1.AN13
CPU_DDC2CLK_R: RPT1.1 RT126.2 UT1.Y8
CPU_DDC2DATA: RH606.2 RT127.1 UH1.AL10
CPU_DDC2DATA_R: RPT1.2 RT127.2 UT1.N4
CPU_DISPA_BCLK: RH38.1 UC1.G27
CPU_DISPA_BCLK_R: RH38.2 UH1.AM3
CPU_DISPA_SDI: RC66.2 UH1.AN3
CPU_DISPA_SDI_R: RC66.1 UC1.G29
CPU_DISPA_SDO: RH39.1 UC1.G25
CPU_DISPA_SDO_R: RH39.2 UH1.AM2
CPU_DP1_AUXN: CT26.1 UC1.E27
CPU_DP1_AUXN_C: CT26.2 RT76.1 UT1.W11
CPU_DP1_AUXP: CT25.1 UC1.D27
CPU_DP1_AUXP_C: CT25.2 RT78.1 UT1.Y11
CPU_DP1_HPD: RT38.1 UH1.AT6 UT1.AA2
CPU_DP1_N0: CT7.1 UC1.K37
CPU_DP1_N0_C: CT7.2 UT1.AC7
CPU_DP1_N1: CT9.1 UC1.J34
CPU_DP1_N1_C: CT9.2 UT1.AC9
CPU_DP1_N2: CT23.1 UC1.H36
CPU_DP1_N2_C: CT23.2 UT1.AC11
CPU_DP1_N3: CT24.1 UC1.J38
CPU_DP1_N3_C: CT24.2 UT1.AC13
CPU_DP1_P0: CT6.1 UC1.K36
CPU_DP1_P0_C: CT6.2 UT1.AB7
CPU_DP1_P1: CT8.1 UC1.J35
CPU_DP1_P1_C: CT8.2 UT1.AB9
CPU_DP1_P2: CT10.1 UC1.H37
CPU_DP1_P2_C: CT10.2 UT1.AB11
CPU_DP1_P3: CT11.1 UC1.J37
CPU_DP1_P3_C: CT11.2 UT1.AB13
CPU_DP2_AUXN: CT36.1 UC1.E26
CPU_DP2_AUXN_C: CT36.2 RT77.1 UT1.W12
CPU_DP2_AUXP: CT35.1 UC1.F26
CPU_DP2_AUXP_C: CT35.2 RT79.1 UT1.Y12
CPU_DP2_HPD: RT39.1 UH1.AN10 UT1.Y6
CPU_DP2_N0: CT28.1 UC1.H33
CPU_DP2_N0_C: CT28.2 UT1.AC15
CPU_DP2_N1: CT30.1 UC1.G38
CPU_DP2_N1_C: CT30.2 UT1.AC17
CPU_DP2_N2: CT32.1 UC1.F35
CPU_DP2_N2_C: CT32.2 UT1.AC19
CPU_DP2_N3: CT34.1 UC1.E36
CPU_DP2_N3_C: CT34.2 UT1.AC21
CPU_DP2_P0: CT27.1 UC1.H34
CPU_DP2_P0_C: CT27.2 UT1.AB15
CPU_DP2_P1: CT29.1 UC1.F37
CPU_DP2_P1_C: CT29.2 UT1.AB17
CPU_DP2_P2: CT31.1 UC1.F34
CPU_DP2_P2_C: CT31.2 UT1.AB19
CPU_DP2_P3: CT33.1 UC1.E37
CPU_DP2_P3_C: CT33.2 UT1.AB21
CPU_FAN_FB: DF1.2 RF1.1 UE5.28
CPU_FAN_PWM: JFAN1.2 RF2.1 UE5.26
CPU_TRIGGER: RH192.1 UH1.AK2
CPU_VCCIO_PWR_GATE#: RH180.2 UH1.AY3
CPU_XDP_TRST#: JPCMC.28 RH497.2 UC1.BP30 UH1.AM4
CS1: PR106.2 PU100.1
CS2: PR105.2 PU100.5
CS_1.2V: PR201.2 PU201.13
CSCOMP_2PH: PC526.1 PC528.1 PH502.1 PR542.2 PR544.1 PU500.31
CSCOMP_4PH: PC523.1 PC524.2 PH501.1 PR541.1 PR543.1 PU500.8
CSN_1PH: PH500.1 PL508.3 PR503.1
CSN_1PH_R: PC501.1 PC504.1 PC505.1 PR503.2 PU500.48
CSNSUM: PR6020.2 PU6000.21
CSON_1: PC717.2 PC721.1 PR712.3 PR723.2
CSOP_1: PC716.2 PC717.1 PR712.2 PR722.2
CSP1_2PH: PC534.2 PR595.1 PU500.28
CSP1_4PH: PC533.2 PR557.2 PR596.2 PU500.11
CSP2_4PH: PC535.2 PR587.2 PR598.2 PU500.12
CSP3_4PH: PC536.2 PR581.2 PR599.2 PU500.13
CSP4_4PH: PC537.2 PR582.2 PR600.2 PU500.26
CSP_1PH: PC501.2 PC505.2 PR501.2 PR502.1 PU500.47
CSPSUM: PC6003.1 PC6004.1 PC6006.1 PR6001.2 PR6002.2 PR6003.2 PR6004.2 PR6008.1 PR6012.1 PU6000.22
CSREF_2PH: PC527.1 PC534.1 PR588.2 PU500.29
CSREF_4PH: PC525.2 PC533.1 PC535.1 PC536.1 PC537.1 PR559.2 PR569.2 PR579.2 PR596.1 PR597.2 PR598.1 PR599.1 PR600.1 PU500.10
CSSN_1: PR702.3 PR704.1
CSSN_2: PC708.2 PC709.1 PR704.2 PU700.1
CSSN_B+: PR6100.3 RG59.1
CSSN_NVVDD: PR6101.3 RG64.1
CSSN_NVVDDS: PR6401.3 RG138.1
CSSP_1: PR702.2 PR703.1
CSSP_2: PC707.2 PC708.1 PR703.2 PU700.2
CSSP_B+: PR6100.2 RG62.1
CSSP_NVVDD: PR6101.2 RG66.1
CSSP_NVVDDS: PR6401.2 RG137.1
CSSUM_2PH: PC526.2 PC528.2 PR548.2 PR549.1 PU500.30
CSSUM_4PH: PC523.2 PC524.1 PR546.2 PR547.2 PR550.2 PR551.2 PR572.2 PU500.9
CTL1: UE6.7 UU1.6
CTL2: UE6.8 UU1.7
DAT_SMB: PBATT1.6 PR21.1
DDR_A_ACT#: JDIMM1.114 UC1.AU3
DDR_A_ALERT#: JDIMM1.116 UC1.AU5
DDR_A_BA0: JDIMM1.150 UC1.AH5
DDR_A_BA1: JDIMM1.145 UC1.AH1
DDR_A_BG0: JDIMM1.115 UC1.AU1
DDR_A_BG1: JDIMM1.113 UC1.AU2
DDR_A_CKE0: JDIMM1.109 UC1.AT1
DDR_A_CKE1: JDIMM1.110 UC1.AT2
DDR_A_CLK0: JDIMM1.137 UC1.AG1
DDR_A_CLK1: JDIMM1.138 UC1.AK2
DDR_A_CLK#0: JDIMM1.139 UC1.AG2
DDR_A_CLK#1: JDIMM1.140 UC1.AK1
DDR_A_CS#0: JDIMM1.149 UC1.AD5
DDR_A_CS#1: JDIMM1.157 UC1.AE2
DDR_A_D0: JDIMM1.4 UC1.BR6
DDR_A_D1: JDIMM1.3 UC1.BT6
DDR_A_D2: JDIMM1.20 UC1.BP3
DDR_A_D3: JDIMM1.17 UC1.BR3
DDR_A_D4: JDIMM1.8 UC1.BN5
DDR_A_D5: JDIMM1.7 UC1.BP6
DDR_A_D6: JDIMM1.16 UC1.BP2
DDR_A_D7: JDIMM1.21 UC1.BN3
DDR_A_D8: JDIMM1.29 UC1.BL4
DDR_A_D9: JDIMM1.25 UC1.BL5
DDR_A_D10: JDIMM1.41 UC1.BL2
DDR_A_D11: JDIMM1.42 UC1.BM1
DDR_A_D12: JDIMM1.24 UC1.BK4
DDR_A_D13: JDIMM1.28 UC1.BK5
DDR_A_D14: JDIMM1.38 UC1.BK1
DDR_A_D15: JDIMM1.37 UC1.BK2
DDR_A_D16: JDIMM1.45 UC1.BG4
DDR_A_D17: JDIMM1.49 UC1.BG5
DDR_A_D18: JDIMM1.63 UC1.BF4
DDR_A_D19: JDIMM1.59 UC1.BF5
DDR_A_D20: JDIMM1.50 UC1.BG2
DDR_A_D21: JDIMM1.46 UC1.BG1
DDR_A_D22: JDIMM1.62 UC1.BF1
DDR_A_D23: JDIMM1.58 UC1.BF2
DDR_A_D24: JDIMM1.67 UC1.BD2
DDR_A_D25: JDIMM1.70 UC1.BD1
DDR_A_D26: JDIMM1.79 UC1.BC4
DDR_A_D27: JDIMM1.83 UC1.BC5
DDR_A_D28: JDIMM1.66 UC1.BD5
DDR_A_D29: JDIMM1.71 UC1.BD4
DDR_A_D30: JDIMM1.80 UC1.BC1
DDR_A_D31: JDIMM1.84 UC1.BC2
DDR_A_D32: JDIMM1.174 UC1.AB1
DDR_A_D33: JDIMM1.169 UC1.AB2
DDR_A_D34: JDIMM1.186 UC1.AA4
DDR_A_D35: JDIMM1.182 UC1.AA5
DDR_A_D36: JDIMM1.170 UC1.AB5
DDR_A_D37: JDIMM1.173 UC1.AB4
DDR_A_D38: JDIMM1.183 UC1.AA2
DDR_A_D39: JDIMM1.187 UC1.AA1
DDR_A_D40: JDIMM1.190 UC1.V5
DDR_A_D41: JDIMM1.195 UC1.V2
DDR_A_D42: JDIMM1.207 UC1.U1
DDR_A_D43: JDIMM1.203 UC1.U2
DDR_A_D44: JDIMM1.191 UC1.V1
DDR_A_D45: JDIMM1.194 UC1.V4
DDR_A_D46: JDIMM1.208 UC1.U5
DDR_A_D47: JDIMM1.204 UC1.U4
DDR_A_D48: JDIMM1.211 UC1.R2
DDR_A_D49: JDIMM1.228 UC1.P5
DDR_A_D50: JDIMM1.212 UC1.R4
DDR_A_D51: JDIMM1.224 UC1.P4
DDR_A_D52: JDIMM1.216 UC1.R5
DDR_A_D53: JDIMM1.225 UC1.P2
DDR_A_D54: JDIMM1.215 UC1.R1
DDR_A_D55: JDIMM1.229 UC1.P1
DDR_A_D56: JDIMM1.233 UC1.M4
DDR_A_D57: JDIMM1.236 UC1.M1
DDR_A_D58: JDIMM1.245 UC1.L4
DDR_A_D59: JDIMM1.246 UC1.L2
DDR_A_D60: JDIMM1.237 UC1.M5
DDR_A_D61: JDIMM1.232 UC1.M2
DDR_A_D62: JDIMM1.249 UC1.L5
DDR_A_D63: JDIMM1.250 UC1.L1
DDR_A_DQS0: JDIMM1.13 UC1.BP5
DDR_A_DQS1: JDIMM1.34 UC1.BK3
DDR_A_DQS2: JDIMM1.55 UC1.BF3
DDR_A_DQS3: JDIMM1.76 UC1.BC3
DDR_A_DQS4: JDIMM1.179 UC1.AB3
DDR_A_DQS5: JDIMM1.200 UC1.V3
DDR_A_DQS6: JDIMM1.221 UC1.R3
DDR_A_DQS7: JDIMM1.242 UC1.M3
DDR_A_DQS#0: JDIMM1.11 UC1.BR5
DDR_A_DQS#1: JDIMM1.32 UC1.BL3
DDR_A_DQS#2: JDIMM1.53 UC1.BG3
DDR_A_DQS#3: JDIMM1.74 UC1.BD3
DDR_A_DQS#4: JDIMM1.177 UC1.AA3
DDR_A_DQS#5: JDIMM1.198 UC1.U3
DDR_A_DQS#6: JDIMM1.219 UC1.P3
DDR_A_DQS#7: JDIMM1.240 UC1.L3
DDR_A_MA0: JDIMM1.144 UC1.AH3
DDR_A_MA1: JDIMM1.133 UC1.AP4
DDR_A_MA2: JDIMM1.132 UC1.AN4
DDR_A_MA3: JDIMM1.131 UC1.AP5
DDR_A_MA4: JDIMM1.128 UC1.AP2
DDR_A_MA5: JDIMM1.126 UC1.AP1
DDR_A_MA6: JDIMM1.127 UC1.AP3
DDR_A_MA7: JDIMM1.122 UC1.AN1
DDR_A_MA8: JDIMM1.125 UC1.AN3
DDR_A_MA9: JDIMM1.121 UC1.AT4
DDR_A_MA10: JDIMM1.146 UC1.AH2
DDR_A_MA11: JDIMM1.120 UC1.AN2
DDR_A_MA12: JDIMM1.119 UC1.AU4
DDR_A_MA13: JDIMM1.158 UC1.AE3
DDR_A_MA14_WE#: JDIMM1.151 UC1.AG4
DDR_A_MA15_CAS#: JDIMM1.156 UC1.AD1
DDR_A_MA16_RAS#: JDIMM1.152 UC1.AH4
DDR_A_ODT0: JDIMM1.155 UC1.AD3
DDR_A_ODT1: JDIMM1.161 UC1.AE4
DDR_A_PAR: JDIMM1.143 UC1.AG3
DDR_B_ACT#: JDIMM2.114 UC1.AT9
DDR_B_ALERT#: JDIMM2.116 UC1.AR8
DDR_B_BA0: JDIMM2.150 UC1.AH8
DDR_B_BA1: JDIMM2.145 UC1.AH9
DDR_B_BG0: JDIMM2.115 UC1.AR9
DDR_B_BG1: JDIMM2.113 UC1.AR7
DDR_B_CKE0: JDIMM2.109 UC1.AT8
DDR_B_CKE1: JDIMM2.110 UC1.AT10
DDR_B_CLK0: JDIMM2.137 UC1.AM9
DDR_B_CLK1: JDIMM2.138 UC1.AM7
DDR_B_CLK#0: JDIMM2.139 UC1.AN9
DDR_B_CLK#1: JDIMM2.140 UC1.AM8
DDR_B_CS#0: JDIMM2.149 UC1.AF11
DDR_B_CS#1: JDIMM2.157 UC1.AE7
DDR_B_D0: JDIMM2.3 UC1.BT11
DDR_B_D1: JDIMM2.8 UC1.BR11
DDR_B_D2: JDIMM2.16 UC1.BT9
DDR_B_D3: JDIMM2.21 UC1.BR8
DDR_B_D4: JDIMM2.7 UC1.BP11
DDR_B_D5: JDIMM2.4 UC1.BN11
DDR_B_D6: JDIMM2.17 UC1.BP8
DDR_B_D7: JDIMM2.20 UC1.BN8
DDR_B_D8: JDIMM2.24 UC1.BL12
DDR_B_D9: JDIMM2.28 UC1.BL11
DDR_B_D10: JDIMM2.25 UC1.BL8
DDR_B_D11: JDIMM2.42 UC1.BJ8
DDR_B_D12: JDIMM2.37 UC1.BJ11
DDR_B_D13: JDIMM2.41 UC1.BJ10
DDR_B_D14: JDIMM2.29 UC1.BL7
DDR_B_D15: JDIMM2.38 UC1.BJ7
DDR_B_D16: JDIMM2.45 UC1.BG11
DDR_B_D17: JDIMM2.49 UC1.BG10
DDR_B_D18: JDIMM2.50 UC1.BG8
DDR_B_D19: JDIMM2.59 UC1.BF8
DDR_B_D20: JDIMM2.62 UC1.BF11
DDR_B_D21: JDIMM2.58 UC1.BF10
DDR_B_D22: JDIMM2.46 UC1.BG7
DDR_B_D23: JDIMM2.63 UC1.BF7
DDR_B_D24: JDIMM2.84 UC1.BB11
DDR_B_D25: JDIMM2.67 UC1.BC11
DDR_B_D26: JDIMM2.79 UC1.BB8
DDR_B_D27: JDIMM2.66 UC1.BC8
DDR_B_D28: JDIMM2.71 UC1.BC10
DDR_B_D29: JDIMM2.80 UC1.BB10
DDR_B_D30: JDIMM2.70 UC1.BC7
DDR_B_D31: JDIMM2.83 UC1.BB7
DDR_B_D32: JDIMM2.187 UC1.AA11
DDR_B_D33: JDIMM2.183 UC1.AA10
DDR_B_D34: JDIMM2.174 UC1.AC11
DDR_B_D35: JDIMM2.170 UC1.AC10
DDR_B_D36: JDIMM2.182 UC1.AA7
DDR_B_D37: JDIMM2.186 UC1.AA8
DDR_B_D38: JDIMM2.169 UC1.AC8
DDR_B_D39: JDIMM2.173 UC1.AC7
DDR_B_D40: JDIMM2.191 UC1.W8
DDR_B_D41: JDIMM2.195 UC1.W7
DDR_B_D42: JDIMM2.203 UC1.V10
DDR_B_D43: JDIMM2.207 UC1.V11
DDR_B_D44: JDIMM2.190 UC1.W11
DDR_B_D45: JDIMM2.194 UC1.W10
DDR_B_D46: JDIMM2.208 UC1.V7
DDR_B_D47: JDIMM2.204 UC1.V8
DDR_B_D48: JDIMM2.216 UC1.R11
DDR_B_D49: JDIMM2.228 UC1.P11
DDR_B_D50: JDIMM2.225 UC1.P7
DDR_B_D51: JDIMM2.215 UC1.R8
DDR_B_D52: JDIMM2.211 UC1.R10
DDR_B_D53: JDIMM2.224 UC1.P10
DDR_B_D54: JDIMM2.212 UC1.R7
DDR_B_D55: JDIMM2.229 UC1.P8
DDR_B_D56: JDIMM2.245 UC1.L11
DDR_B_D57: JDIMM2.236 UC1.M11
DDR_B_D58: JDIMM2.250 UC1.L7
DDR_B_D59: JDIMM2.232 UC1.M8
DDR_B_D60: JDIMM2.249 UC1.L10
DDR_B_D61: JDIMM2.233 UC1.M10
DDR_B_D62: JDIMM2.237 UC1.M7
DDR_B_D63: JDIMM2.246 UC1.L8
DDR_B_DQS0: JDIMM2.13 UC1.BP9
DDR_B_DQS1: JDIMM2.34 UC1.BJ9
DDR_B_DQS2: JDIMM2.55 UC1.BF9
DDR_B_DQS3: JDIMM2.76 UC1.BB9
DDR_B_DQS4: JDIMM2.179 UC1.AA9
DDR_B_DQS5: JDIMM2.200 UC1.V9
DDR_B_DQS6: JDIMM2.221 UC1.P9
DDR_B_DQS7: JDIMM2.242 UC1.L9
DDR_B_DQS#0: JDIMM2.11 UC1.BN9
DDR_B_DQS#1: JDIMM2.32 UC1.BL9
DDR_B_DQS#2: JDIMM2.53 UC1.BG9
DDR_B_DQS#3: JDIMM2.74 UC1.BC9
DDR_B_DQS#4: JDIMM2.177 UC1.AC9
DDR_B_DQS#5: JDIMM2.198 UC1.W9
DDR_B_DQS#6: JDIMM2.219 UC1.R9
DDR_B_DQS#7: JDIMM2.240 UC1.M9
DDR_B_MA0: JDIMM2.144 UC1.AJ9
DDR_B_MA1: JDIMM2.133 UC1.AK6
DDR_B_MA2: JDIMM2.132 UC1.AK5
DDR_B_MA3: JDIMM2.131 UC1.AL5
DDR_B_MA4: JDIMM2.128 UC1.AL6
DDR_B_MA5: JDIMM2.126 UC1.AM6
DDR_B_MA6: JDIMM2.127 UC1.AN7
DDR_B_MA7: JDIMM2.122 UC1.AN10
DDR_B_MA8: JDIMM2.125 UC1.AN8
DDR_B_MA9: JDIMM2.121 UC1.AR11
DDR_B_MA10: JDIMM2.146 UC1.AH7
DDR_B_MA11: JDIMM2.120 UC1.AN11
DDR_B_MA12: JDIMM2.119 UC1.AR10
DDR_B_MA13: JDIMM2.158 UC1.AF9
DDR_B_MA14_WE#: JDIMM2.151 UC1.AH11
DDR_B_MA15_CAS#: JDIMM2.156 UC1.AF8
DDR_B_MA16_RAS#: JDIMM2.152 UC1.AH10
DDR_B_ODT0: JDIMM2.155 UC1.AF7
DDR_B_ODT1: JDIMM2.161 UC1.AE8
DDR_B_PAR: JDIMM2.143 UC1.AJ7
DDR_DRAMRST#: CD69.1 CD91.1 CD92.1 JDIMM1.108 JDIMM2.108 RD31.1
DDR_RCOMP0: RH148.2 UC1.G1
DDR_RCOMP1: RH149.2 UC1.H1
DDR_RCOMP2: RH150.2 UC1.J2
DDR_VTT_PG_CTRL: UC1.BT13 UC2.2
DEBUG_CTL1: RT66.2 UT4.E4
DEBUG_CTL2: RT67.2 UT4.D5
DEMB0: RM75.2 RM79.2 UM8.53
DEMB1: RM62.2 RM86.2 UM8.54
DEPOP#_EC: DA2.3 UE6.2
DET: RH584.1 RV675.1 UH1.T46
DEVSLP0: JHDD.13 UH1.AL48
DEVSLP1: JSSD3.38 UH1.AH35
DEVSLP3: JSSD2.38 UH1.AP48
DEVSLP4: JSSD1.38 UH1.AR47
DGPU_HOLD_RST#: RG3.2 RG13.1 UG10.1 UG31.9 UH1.BB20
DGPU_PEX_RST#: CG489.1 QG6.2 QG6.5 QG7.2 QG7.5 QG501.2 QG501.5 QV96.2 QV96.5 RG4.1 RG7.2 RG25.1 RG568.1 RG581.2 UG22.1 UG31.10 UX1.2 UX2.2
DGPU_PEX_RST#_R: RG4.2 UG9.BK26
DGPU_PRSNT#: RH135.2 UH1.BD38
DGPU_PWR_EN: RG551.1 RG570.2 RG573.1 RH537.1 UE6.9 UH1.AN18
DGPU_PWROK: RH516.2 UE6.19 UH1.BE14
DGPU_ROM_CS#: RG74.2 RG579.1 UG13.1 UG16.11
DGPU_ROM_SCLK: RG75.1 UG13.6
DGPU_ROM_SI: RG77.1 UG13.5
DGPU_ROM_SO: RG76.1 RG580.1 UG16.8
DGPU_ROM_SO_R: RG76.2 UG13.2
DH_1.2V: PQ200.4 PU201.17
DH_CHG: PQ704.4 PU700.26
DIFFOUT_2PH: PR537.1 PR539.2 PU500.35
DIFFOUT_4PH: PC516.2 PR536.2 PU500.4
DIMM_CHA_SA0: JDIMM1.256 RD1.2 RD28.1
DIMM_CHA_SA1: JDIMM1.260 RD2.2 RD29.1
DIMM_CHA_SA2: JDIMM1.166 RD3.2 RD30.1
DIMM_CHB_SA0: JDIMM2.256 RD4.2 RD38.1
DIMM_CHB_SA1: JDIMM2.260 RD5.2 RD39.1
DIMM_CHB_SA2: JDIMM2.166 RD6.2 RD40.1
DISP_CEC: JDP.6 RV18.2
DISP_CLK_AUXP_CONN: JDP.16 RV15.2 UV3.4
DISP_DAT_AUXN_CONN: JDP.18 RV16.2 UV3.7
DISPOFF#: DV1.1 JEDP.35 RV1.1
DL_1.2V: PQ201.4 PU201.15
DL_CHG: PQ706.4 PU700.23
DMI_CRX_PTX_N0: UC1.E8 UH1.C33
DMI_CRX_PTX_N1: UC1.F6 UH1.C32
DMI_CRX_PTX_N2: UC1.E5 UH1.C31
DMI_CRX_PTX_N3: UC1.J9 UH1.C29
DMI_CRX_PTX_P0: UC1.D8 UH1.B33
DMI_CRX_PTX_P1: UC1.E6 UH1.B32
DMI_CRX_PTX_P2: UC1.D5 UH1.B31
DMI_CRX_PTX_P3: UC1.J8 UH1.B29
DMI_CTX_PRX_N0: UC1.A8 UH1.K34
DMI_CTX_PRX_N1: UC1.B6 UH1.G33
DMI_CTX_PRX_N2: UC1.A5 UH1.K32
DMI_CTX_PRX_N3: UC1.B4 UH1.G30
DMI_CTX_PRX_P0: UC1.B8 UH1.J35
DMI_CTX_PRX_P1: UC1.C6 UH1.F34
DMI_CTX_PRX_P2: UC1.B5 UH1.J32
DMI_CTX_PRX_P3: UC1.D4 UH1.F30
DMIC_CLK1_R: LA6.2 UA1.53
DMIC_DATA1_R: RA19.2 UA1.54
DP_CBL_DET: JDP.4 QG500.2 RV17.1 UV3.1
DP_CBL_DET#: RG540.1 UG9.BD5
DP_HPD_PCH: QX2.3 RX4.1 UH1.AW24 UX1.1
DPSNK_RBIAS: RT19.1 UT1.Y18
DPSRC_RBIAS: RT5.1 UT1.N6
DRVON: PR556.1 PR566.1 PR576.1 PR585.1 PR594.1 PR5006.1 PU500.17
EAP: PR6018.2 PU6000.29
EAPD#: DA3.2 RA21.2 RA22.1 UA1.52
EC_AC_BAT#: RG16.1 UE5.1 UG9.BE6
EC_CLK1: RE668.1 RE670.1 UE5.83
EC_DAT1: RE669.1 RE671.1 UE5.84
EC_ENBKL: RG566.2 RG569.1 UE5.76 UG30.6
EC_ESB_CLK: RE642.2 UE5.17 UE6.1 UE10.1
EC_ESB_DAT: RE643.2 UE5.18 UE6.4 UE10.4
EC_MUTE#: DA3.3 UE10.11
EC_ON: PD100.2 UE5.112
EC_RSMRST#: DE2.2 RC355.2 RH88.2 UE5.100 UH1.BA47
EC_RTCRST: QE5.2 RE650.1 UE5.34
EC_RX: JWLAN.32 UE5.31
EC_SCI#: RH521.2 UE5.20 UH1.AU26
EC_SMB_CK1: PD2.2 PR19.2 PR721.1 RE90.4 UE5.77
EC_SMB_CK2: DK2.2 JPK.16 QG6.3 QH5.1 RE90.2 RT60.1 U2407.10 UE5.79 UM8.50 UU2.29
EC_SMB_DA1: PD2.3 PR21.2 PR720.1 RE90.3 UE5.78
EC_SMB_DA2: DK2.3 JPK.17 QG6.6 QH5.4 RE90.1 RT59.1 U2407.9 UE5.80 UM8.49 UU2.31
EC_SRTCRST: QE5.5 RE658.1 UE10.20
EC_TX: JWLAN.30 RM31.1 UE5.30
ECAGND: CE33.2 CE35.1 LE2.2 PH1.2 UE5.69
EDP_AUXN: CV13.2 RV670.1 UG9.BF11
EDP_AUXN_C: CV13.1 JEDP.14
EDP_AUXP: CV12.2 RV669.1 UG9.BE11
EDP_AUXP_C: CV12.1 JEDP.13
EDP_HPD: QG500.3 RG500.2 UG9.BH1
EDP_HPD_CPU: RH9.1 UH1.AN6
EDP_HPD_R: JEDP.16 RG508.2
EDP_RCOMP: RC30.1 UC1.D37
EDP_TXN0: CV2.2 UG9.BM17
EDP_TXN0_C: CV2.1 JEDP.2
EDP_TXN1: CV4.2 UG9.BK17
EDP_TXN1_C: CV4.1 JEDP.5
EDP_TXN2: CV6.2 UG9.BL15
EDP_TXN2_C: CV6.1 JEDP.8
EDP_TXN3: CV11.2 UG9.BM14
EDP_TXN3_C: CV11.1 JEDP.11
EDP_TXP0: CV1.2 UG9.BM18
EDP_TXP0_C: CV1.1 JEDP.1
EDP_TXP1: CV3.2 UG9.BL17
EDP_TXP1_C: CV3.1 JEDP.4
EDP_TXP2: CV8.2 UG9.BK15
EDP_TXP2_C: CV8.1 JEDP.7
EDP_TXP3: CV7.2 UG9.BM15
EDP_TXP3_C: CV7.1 JEDP.10
ELC_BOOT_MODE: RE5.1 RE657.2 UE1.44 UH1.BD29
ELC_EC#: QE13.5 QE21.5 QE22.5 UE10.6
ELC_RESET: CE8.1 JELC1.4 JELC2.10 RE4.1 UE1.7 UH1.BD30
EN_0.6VSP: PC214.1 PR209.1 PR211.1 PU201.7
EN_1.2V: PC213.1 PR208.2 PU201.8
EN_+1VALWP: PC300.1 PR300.2 PU300.3
EN_INVPWR: QV2.2 UE5.68
EN_TPLED: C2509.1 Q2409.3 Q2410.1 R179.1 R180.1
EN_VCCIO: PC590.1 PR5007.2 PR5008.1 PU509.11
EN_WOL#: CL42.1 RE79.2 UE10.14 UL2.4
ENBKL: RG501.1 UG9.BB1 UG30.5
ENVDD: QG506.2 RG151.1 UG9.BH3 UV17.4
EQA0: RM81.2 RM84.2 UM8.20
EQA1: RM70.2 RM76.2 UM8.19
EQB0: RM82.2 RM85.2 UM8.46
EQB1: RM23.2 RM26.2 UM8.47
FB_1.0VS_VGAP: PC809.2 PR804.2 PR805.1 PU800.14
FB_1.2V: PR205.1 PR207.1 PR213.1 PR215.1 PU201.6
FB_2PH: PC518.2 PC519.1 PR539.1 PR540.1 PU500.34
FB_3V: PR101.2 PR103.2 PU100.4
FB_4PH: PC515.2 PC517.2 PR533.1 PR536.1 PU500.5
FB_5V: PR102.1 PR104.1 PU100.2
FB_+1.8VGS: PC819.2 PR810.2 PR811.1 PU802.14
FB_+1VALWP: PR307.1 PR308.1 PU300.4
FB_A_CLK0: RG102.1 UG1.J12 UG9.AG45
FB_A_CLK1: RG103.1 UG2.J12 UG9.AK46
FB_A_CLK#0: RG523.1 UG1.J11 UG9.AG46
FB_A_CLK#1: RG524.1 UG2.J11 UG9.AK45
FB_A_CMD0: UG1.G3 UG9.Y51
FB_A_CMD1: RG47.2 UG1.J3 UG9.Y52
FB_A_CMD2: RG54.1 UG1.J2 UG9.Y49
FB_A_CMD3: UG1.L3 UG9.AA52
FB_A_CMD4: UG1.K5 UG9.AA51
FB_A_CMD5: UG1.K4 UG9.AA50
FB_A_CMD6: UG1.J5 UG9.AC50
FB_A_CMD7: UG1.J4 UG9.AC51
FB_A_CMD8: UG1.H5 UG9.AC52
FB_A_CMD9: UG1.H4 UG9.AC49
FB_A_CMD10: UG1.G12 UG9.AD52
FB_A_CMD11: UG1.H10 UG9.AD51
FB_A_CMD12: UG1.H11 UG9.AD50
FB_A_CMD13: UG1.K11 UG9.AF50
FB_A_CMD14: UG1.K10 UG9.AF51
FB_A_CMD15: UG1.L12 UG9.AF52
FB_A_CMD16: UG2.L3 UG9.AN50
FB_A_CMD17: RG48.2 UG2.J3 UG9.AN51
FB_A_CMD18: RG53.1 UG2.J2 UG9.AN52
FB_A_CMD19: UG2.G3 UG9.AM49
FB_A_CMD20: UG2.H5 UG9.AM52
FB_A_CMD21: UG2.H4 UG9.AM51
FB_A_CMD22: UG2.J5 UG9.AM50
FB_A_CMD23: UG2.J4 UG9.AK50
FB_A_CMD24: UG2.K5 UG9.AK51
FB_A_CMD25: UG2.K4 UG9.AK52
FB_A_CMD26: UG2.L12 UG9.AJ49
FB_A_CMD27: UG2.K10 UG9.AJ52
FB_A_CMD28: UG2.K11 UG9.AJ51
FB_A_CMD29: UG2.H11 UG9.AJ50
FB_A_CMD30: UG2.H10 UG9.AG50
FB_A_CMD31: UG2.G12 UG9.AG51
FB_A_D0: UG1.U4 UG9.U51
FB_A_D1: UG1.U2 UG9.U48
FB_A_D2: UG1.T4 UG9.U50
FB_A_D3: UG1.T2 UG9.U49
FB_A_D4: UG1.N4 UG9.R51
FB_A_D5: UG1.N2 UG9.R50
FB_A_D6: UG1.M4 UG9.R47
FB_A_D7: UG1.M2 UG9.U46
FB_A_D8: UG1.U11 UG9.V46
FB_A_D9: UG1.U13 UG9.Y45
FB_A_D10: UG1.T11 UG9.Y47
FB_A_D11: UG1.T13 UG9.Y46
FB_A_D12: UG1.N11 UG9.V50
FB_A_D13: UG1.N13 UG9.V47
FB_A_D14: UG1.M11 UG9.U52
FB_A_D15: UG1.M13 UG9.V51
FB_A_D16: UG1.A11 UG9.AJ44
FB_A_D17: UG1.A13 UG9.AG48
FB_A_D18: UG1.B11 UG9.AJ45
FB_A_D19: UG1.B13 UG9.AG49
FB_A_D20: UG1.E11 UG9.AF46
FB_A_D21: UG1.E13 UG9.AF47
FB_A_D22: UG1.F11 UG9.AF48
FB_A_D23: UG1.F13 UG9.AD47
FB_A_D24: UG1.A4 UG9.AD49
FB_A_D25: UG1.A2 UG9.AD48
FB_A_D26: UG1.B4 UG9.AC46
FB_A_D27: UG1.B2 UG9.AC47
FB_A_D28: UG1.E4 UG9.AA47
FB_A_D29: UG1.E2 UG9.AA46
FB_A_D30: UG1.F4 UG9.AA45
FB_A_D31: UG1.F2 UG9.Y44
FB_A_D32: UG2.A4 UG9.AW51
FB_A_D33: UG2.A2 UG9.BA52
FB_A_D34: UG2.B4 UG9.AW50
FB_A_D35: UG2.B2 UG9.BA51
FB_A_D36: UG2.E4 UG9.BA50
FB_A_D37: UG2.E2 UG9.BB50
FB_A_D38: UG2.F4 UG9.BA49
FB_A_D39: UG2.F2 UG9.AW49
FB_A_D40: UG2.A11 UG9.AV48
FB_A_D41: UG2.A13 UG9.AT49
FB_A_D42: UG2.B11 UG9.AT47
FB_A_D43: UG2.B13 UG9.AT48
FB_A_D44: UG2.E11 UG9.AT46
FB_A_D45: UG2.E13 UG9.AV51
FB_A_D46: UG2.F11 UG9.AV52
FB_A_D47: UG2.F13 UG9.AV49
FB_A_D48: UG2.U11 UG9.AJ48
FB_A_D49: UG2.U13 UG9.AJ46
FB_A_D50: UG2.T11 UG9.AJ47
FB_A_D51: UG2.T13 UG9.AK49
FB_A_D52: UG2.N11 UG9.AM47
FB_A_D53: UG2.N13 UG9.AM46
FB_A_D54: UG2.M11 UG9.AN48
FB_A_D55: UG2.M13 UG9.AN49
FB_A_D56: UG2.U4 UG9.AM44
FB_A_D57: UG2.U2 UG9.AM45
FB_A_D58: UG2.T4 UG9.AN45
FB_A_D59: UG2.T2 UG9.AN46
FB_A_D60: UG2.N4 UG9.AR48
FB_A_D61: UG2.N2 UG9.AN47
FB_A_D62: UG2.M4 UG9.AR47
FB_A_D63: UG2.M2 UG9.AR46
FB_A_DBI0: UG1.P2 UG9.U47
FB_A_DBI1: UG1.P13 UG9.Y48
FB_A_DBI2: UG1.D13 UG9.AG47
FB_A_DBI3: UG1.D2 UG9.AC48
FB_A_DBI4: UG2.D2 UG9.BB51
FB_A_DBI5: UG2.D13 UG9.AV50
FB_A_DBI6: UG2.P13 UG9.AM48
FB_A_DBI7: UG2.P2 UG9.AR49
FB_A_EDC0: UG1.R2 UG9.R48
FB_A_EDC1: UG1.R13 UG9.V48
FB_A_EDC2: UG1.C13 UG9.AF44
FB_A_EDC3: UG1.C2 UG9.AA48
FB_A_EDC4: UG2.C2 UG9.BB52
FB_A_EDC5: UG2.C13 UG9.AT50
FB_A_EDC6: UG2.R13 UG9.AK48
FB_A_EDC7: UG2.R2 UG9.AR51
FB_A_WCK01: UG1.P4 UG9.U45
FB_A_WCK23: UG1.D4 UG9.AC45
FB_A_WCK45: UG2.D4 UG9.AV47
FB_A_WCK67: UG2.P4 UG9.AR45
FB_A_WCK#01: UG1.P5 UG9.U44
FB_A_WCK#23: UG1.D5 UG9.AC44
FB_A_WCK#45: UG2.D5 UG9.AV46
FB_A_WCK#67: UG2.P5 UG9.AR44
FB_B_CLK0: RG113.1 UG3.J12 UG9.H42
FB_B_CLK1: RG114.1 UG4.J12 UG9.F47
FB_B_CLK#0: RG525.1 UG3.J11 UG9.G42
FB_B_CLK#1: RG526.1 UG4.J11 UG9.E47
FB_B_CMD0: UG3.G3 UG9.B35
FB_B_CMD1: RG49.2 UG3.J3 UG9.A35
FB_B_CMD2: RG56.1 UG3.J2 UG9.D35
FB_B_CMD3: UG3.L3 UG9.A36
FB_B_CMD4: UG3.K5 UG9.B36
FB_B_CMD5: UG3.K4 UG9.C36
FB_B_CMD6: UG3.J5 UG9.C38
FB_B_CMD7: UG3.J4 UG9.B38
FB_B_CMD8: UG3.H5 UG9.A38
FB_B_CMD9: UG3.H4 UG9.D38
FB_B_CMD10: UG3.G12 UG9.A39
FB_B_CMD11: UG3.H10 UG9.B39
FB_B_CMD12: UG3.H11 UG9.C39
FB_B_CMD13: UG3.K11 UG9.C41
FB_B_CMD14: UG3.K10 UG9.B41
FB_B_CMD15: UG3.L12 UG9.A41
FB_B_CMD16: UG4.L3 UG9.B49
FB_B_CMD17: RG50.2 UG4.J3 UG9.A49
FB_B_CMD18: RG55.1 UG4.J2 UG9.A48
FB_B_CMD19: UG4.G3 UG9.D47
FB_B_CMD20: UG4.H5 UG9.A47
FB_B_CMD21: UG4.H4 UG9.B47
FB_B_CMD22: UG4.J5 UG9.C47
FB_B_CMD23: UG4.J4 UG9.C45
FB_B_CMD24: UG4.K5 UG9.B45
FB_B_CMD25: UG4.K4 UG9.A45
FB_B_CMD26: UG4.L12 UG9.D44
FB_B_CMD27: UG4.K10 UG9.A44
FB_B_CMD28: UG4.K11 UG9.B44
FB_B_CMD29: UG4.H11 UG9.C44
FB_B_CMD30: UG4.H10 UG9.C42
FB_B_CMD31: UG4.G12 UG9.B42
FB_B_D0: UG3.U4 UG9.H32
FB_B_D1: UG3.U2 UG9.D32
FB_B_D2: UG3.T4 UG9.A33
FB_B_D3: UG3.T2 UG9.B32
FB_B_D4: UG3.N4 UG9.E32
FB_B_D5: UG3.N2 UG9.G32
FB_B_D6: UG3.M4 UG9.J30
FB_B_D7: UG3.M2 UG9.F32
FB_B_D8: UG3.U11 UG9.H36
FB_B_D9: UG3.U13 UG9.G36
FB_B_D10: UG3.T11 UG9.J36
FB_B_D11: UG3.T13 UG9.F36
FB_B_D12: UG3.N11 UG9.F33
FB_B_D13: UG3.N13 UG9.D33
FB_B_D14: UG3.M11 UG9.J32
FB_B_D15: UG3.M13 UG9.G33
FB_B_D16: UG3.A11 UG9.E45
FB_B_D17: UG3.A13 UG9.D45
FB_B_D18: UG3.B11 UG9.F45
FB_B_D19: UG3.B13 UG9.G45
FB_B_D20: UG3.E11 UG9.D42
FB_B_D21: UG3.E13 UG9.E42
FB_B_D22: UG3.F11 UG9.F42
FB_B_D23: UG3.F13 UG9.H41
FB_B_D24: UG3.A4 UG9.E41
FB_B_D25: UG3.A2 UG9.F39
FB_B_D26: UG3.B4 UG9.E39
FB_B_D27: UG3.B2 UG9.D39
FB_B_D28: UG3.E4 UG9.F38
FB_B_D29: UG3.E2 UG9.E38
FB_B_D30: UG3.F4 UG9.D36
FB_B_D31: UG3.F2 UG9.E36
FB_B_D32: UG4.A4 UG9.M50
FB_B_D33: UG4.A2 UG9.P48
FB_B_D34: UG4.B4 UG9.M51
FB_B_D35: UG4.B2 UG9.M49
FB_B_D36: UG4.E4 UG9.P47
FB_B_D37: UG4.E2 UG9.P52
FB_B_D38: UG4.F4 UG9.R46
FB_B_D39: UG4.F2 UG9.P46
FB_B_D40: UG4.A11 UG9.L50
FB_B_D41: UG4.A13 UG9.L51
FB_B_D42: UG4.B11 UG9.L52
FB_B_D43: UG4.B13 UG9.L49
FB_B_D44: UG4.E11 UG9.M46
FB_B_D45: UG4.E13 UG9.L47
FB_B_D46: UG4.F11 UG9.M48
FB_B_D47: UG4.F13 UG9.M47
FB_B_D48: UG4.U11 UG9.D48
FB_B_D49: UG4.U13 UG9.C50
FB_B_D50: UG4.T11 UG9.C48
FB_B_D51: UG4.T13 UG9.C49
FB_B_D52: UG4.N11 UG9.E49
FB_B_D53: UG4.N13 UG9.E50
FB_B_D54: UG4.M11 UG9.F49
FB_B_D55: UG4.M13 UG9.F48
FB_B_D56: UG4.U4 UG9.F50
FB_B_D57: UG4.U2 UG9.D52
FB_B_D58: UG4.T4 UG9.J50
FB_B_D59: UG4.T2 UG9.H48
FB_B_D60: UG4.N4 UG9.H51
FB_B_D61: UG4.N2 UG9.J51
FB_B_D62: UG4.M4 UG9.H49
FB_B_D63: UG4.M2 UG9.H52
FB_B_DBI0: UG3.P2 UG9.C32
FB_B_DBI1: UG3.P13 UG9.E33
FB_B_DBI2: UG3.D13 UG9.E44
FB_B_DBI3: UG3.D2 UG9.G39
FB_B_DBI4: UG4.D2 UG9.P49
FB_B_DBI5: UG4.D13 UG9.L48
FB_B_DBI6: UG4.P13 UG9.D50
FB_B_DBI7: UG4.P2 UG9.H50
FB_B_EDC0: UG3.R2 UG9.B33
FB_B_EDC1: UG3.R13 UG9.E35
FB_B_EDC2: UG3.C13 UG9.G44
FB_B_EDC3: UG3.C2 UG9.H38
FB_B_EDC4: UG4.C2 UG9.P50
FB_B_EDC5: UG4.C13 UG9.J48
FB_B_EDC6: UG4.R13 UG9.D51
FB_B_EDC7: UG4.R2 UG9.F51
FB_B_WCK01: UG3.P4 UG9.J33
FB_B_WCK23: UG3.D4 UG9.J39
FB_B_WCK45: UG4.D4 UG9.L46
FB_B_WCK67: UG4.P4 UG9.H47
FB_B_WCK#01: UG3.P5 UG9.H33
FB_B_WCK#23: UG3.D5 UG9.H39
FB_B_WCK#45: UG4.D5 UG9.L45
FB_B_WCK#67: UG4.P5 UG9.H46
FB_C_CLK0: RG124.1 UG5.J12 UG9.G15
FB_C_CLK1: RG125.1 UG6.J12 UG9.H21
FB_C_CLK#0: RG527.1 UG5.J11 UG9.F15
FB_C_CLK#1: RG528.1 UG6.J11 UG9.J21
FB_C_CMD0: UG5.G3 UG9.C11
FB_C_CMD1: RG51.2 UG5.J3 UG9.B11
FB_C_CMD2: RG58.1 UG5.J2 UG9.A11
FB_C_CMD3: UG5.L3 UG9.D11
FB_C_CMD4: UG5.K5 UG9.A12
FB_C_CMD5: UG5.K4 UG9.B12
FB_C_CMD6: UG5.J5 UG9.C12
FB_C_CMD7: UG5.J4 UG9.C14
FB_C_CMD8: UG5.H5 UG9.B14
FB_C_CMD9: UG5.H4 UG9.A14
FB_C_CMD10: UG5.G12 UG9.D14
FB_C_CMD11: UG5.H10 UG9.A15
FB_C_CMD12: UG5.H11 UG9.B15
FB_C_CMD13: UG5.K11 UG9.C15
FB_C_CMD14: UG5.K10 UG9.C17
FB_C_CMD15: UG5.L12 UG9.B17
FB_C_CMD16: UG6.L3 UG9.B24
FB_C_CMD17: RG52.2 UG6.J3 UG9.A24
FB_C_CMD18: RG57.1 UG6.J2 UG9.D23
FB_C_CMD19: UG6.G3 UG9.A23
FB_C_CMD20: UG6.H5 UG9.B23
FB_C_CMD21: UG6.H4 UG9.C23
FB_C_CMD22: UG6.J5 UG9.C21
FB_C_CMD23: UG6.J4 UG9.B21
FB_C_CMD24: UG6.K5 UG9.A21
FB_C_CMD25: UG6.K4 UG9.D20
FB_C_CMD26: UG6.L12 UG9.A20
FB_C_CMD27: UG6.K10 UG9.B20
FB_C_CMD28: UG6.K11 UG9.C20
FB_C_CMD29: UG6.H11 UG9.C18
FB_C_CMD30: UG6.H10 UG9.B18
FB_C_CMD31: UG6.G12 UG9.A18
FB_C_D0: UG5.U4 UG9.C6
FB_C_D1: UG5.U2 UG9.D6
FB_C_D2: UG5.T4 UG9.A6
FB_C_D3: UG5.T2 UG9.B6
FB_C_D4: UG5.N4 UG9.B4
FB_C_D5: UG5.N2 UG9.A4
FB_C_D6: UG5.M4 UG9.B3
FB_C_D7: UG5.M2 UG9.C4
FB_C_D8: UG5.U11 UG9.D9
FB_C_D9: UG5.U13 UG9.C9
FB_C_D10: UG5.T11 UG9.E9
FB_C_D11: UG5.T13 UG9.B9
FB_C_D12: UG5.N11 UG9.B8
FB_C_D13: UG5.N13 UG9.A8
FB_C_D14: UG5.M11 UG9.F6
FB_C_D15: UG5.M13 UG9.E6
FB_C_D16: UG5.A11 UG9.F18
FB_C_D17: UG5.A13 UG9.G18
FB_C_D18: UG5.B11 UG9.E18
FB_C_D19: UG5.B13 UG9.H18
FB_C_D20: UG5.E11 UG9.D15
FB_C_D21: UG5.E13 UG9.E15
FB_C_D22: UG5.F11 UG9.G17
FB_C_D23: UG5.F13 UG9.H17
FB_C_D24: UG5.A4 UG9.J15
FB_C_D25: UG5.A2 UG9.H15
FB_C_D26: UG5.B4 UG9.E14
FB_C_D27: UG5.B2 UG9.F14
FB_C_D28: UG5.E4 UG9.H11
FB_C_D29: UG5.E2 UG9.G11
FB_C_D30: UG5.F4 UG9.F11
FB_C_D31: UG5.F2 UG9.E11
FB_C_D32: UG6.A4 UG9.J29
FB_C_D33: UG6.A2 UG9.F30
FB_C_D34: UG6.B4 UG9.H29
FB_C_D35: UG6.B2 UG9.G30
FB_C_D36: UG6.E4 UG9.B30
FB_C_D37: UG6.E2 UG9.A30
FB_C_D38: UG6.F4 UG9.H30
FB_C_D39: UG6.F2 UG9.C30
FB_C_D40: UG6.A11 UG9.D27
FB_C_D41: UG6.A13 UG9.J26
FB_C_D42: UG6.B11 UG9.F27
FB_C_D43: UG6.B13 UG9.G27
FB_C_D44: UG6.E11 UG9.C27
FB_C_D45: UG6.E13 UG9.B27
FB_C_D46: UG6.F11 UG9.A27
FB_C_D47: UG6.F13 UG9.G29
FB_C_D48: UG6.U11 UG9.H20
FB_C_D49: UG6.U13 UG9.D18
FB_C_D50: UG6.T11 UG9.G20
FB_C_D51: UG6.T13 UG9.E20
FB_C_D52: UG6.N11 UG9.F23
FB_C_D53: UG6.N13 UG9.E21
FB_C_D54: UG6.M11 UG9.D21
FB_C_D55: UG6.M13 UG9.E23
FB_C_D56: UG6.U4 UG9.G24
FB_C_D57: UG6.U2 UG9.H26
FB_C_D58: UG6.T4 UG9.F24
FB_C_D59: UG6.T2 UG9.G26
FB_C_D60: UG6.N4 UG9.F26
FB_C_D61: UG6.N2 UG9.D26
FB_C_D62: UG6.M4 UG9.B26
FB_C_D63: UG6.M2 UG9.C26
FB_C_DBI0: UG5.P2 UG9.A5
FB_C_DBI1: UG5.P13 UG9.C8
FB_C_DBI2: UG5.D13 UG9.J18
FB_C_DBI3: UG5.D2 UG9.F12
FB_C_DBI4: UG6.D2 UG9.D29
FB_C_DBI5: UG6.D13 UG9.E27
FB_C_DBI6: UG6.P13 UG9.F20
FB_C_DBI7: UG6.P2 UG9.E26
FB_C_EDC0: UG5.R2 UG9.D5
FB_C_EDC1: UG5.R13 UG9.D8
FB_C_EDC2: UG5.C13 UG9.E17
FB_C_EDC3: UG5.C2 UG9.E12
FB_C_EDC4: UG6.C2 UG9.E30
FB_C_EDC5: UG6.C13 UG9.B29
FB_C_EDC6: UG6.R13 UG9.G21
FB_C_EDC7: UG6.R2 UG9.E24
FB_C_WCK01: UG5.P4 UG9.F8
FB_C_WCK23: UG5.D4 UG9.H12
FB_C_WCK45: UG6.D4 UG9.J27
FB_C_WCK67: UG6.P4 UG9.G23
FB_C_WCK#01: UG5.P5 UG9.G8
FB_C_WCK#23: UG5.D5 UG9.G12
FB_C_WCK#45: UG6.D5 UG9.H27
FB_C_WCK#67: UG6.P5 UG9.H23
FB_D_CLK0: RG160.1 UG7.J12 UG9.Y8
FB_D_CLK1: RG164.1 UG8.J12 UG9.R8
FB_D_CLK#0: RG531.1 UG7.J11 UG9.Y7
FB_D_CLK#1: RG532.1 UG8.J11 UG9.R7
FB_D_CMD0: UG7.G3 UG9.AD2
FB_D_CMD1: RG451.2 UG7.J3 UG9.AD1
FB_D_CMD2: RG453.1 UG7.J2 UG9.AD4
FB_D_CMD3: UG7.L3 UG9.AC1
FB_D_CMD4: UG7.K5 UG9.AC2
FB_D_CMD5: UG7.K4 UG9.AC3
FB_D_CMD6: UG7.J5 UG9.AA3
FB_D_CMD7: UG7.J4 UG9.AA2
FB_D_CMD8: UG7.H5 UG9.AA1
FB_D_CMD9: UG7.H4 UG9.AA4
FB_D_CMD10: UG7.G12 UG9.Y1
FB_D_CMD11: UG7.H10 UG9.Y2
FB_D_CMD12: UG7.H11 UG9.Y3
FB_D_CMD13: UG7.K11 UG9.V3
FB_D_CMD14: UG7.K10 UG9.V2
FB_D_CMD15: UG7.L12 UG9.V1
FB_D_CMD16: UG8.L3 UG9.L3
FB_D_CMD17: RG452.2 UG8.J3 UG9.L2
FB_D_CMD18: RG450.1 UG8.J2 UG9.L1
FB_D_CMD19: UG8.G3 UG9.M4
FB_D_CMD20: UG8.H5 UG9.M1
FB_D_CMD21: UG8.H4 UG9.M2
FB_D_CMD22: UG8.J5 UG9.M3
FB_D_CMD23: UG8.J4 UG9.P3
FB_D_CMD24: UG8.K5 UG9.P2
FB_D_CMD25: UG8.K4 UG9.P1
FB_D_CMD26: UG8.L12 UG9.R4
FB_D_CMD27: UG8.K10 UG9.R1
FB_D_CMD28: UG8.K11 UG9.R2
FB_D_CMD29: UG8.H11 UG9.R3
FB_D_CMD30: UG8.H10 UG9.U3
FB_D_CMD31: UG8.G12 UG9.U2
FB_D_D0: UG7.U4 UG9.AK8
FB_D_D1: UG7.U2 UG9.AK4
FB_D_D2: UG7.T4 UG9.AK2
FB_D_D3: UG7.T2 UG9.AK3
FB_D_D4: UG7.N4 UG9.AK5
FB_D_D5: UG7.N2 UG9.AK6
FB_D_D6: UG7.M4 UG9.AK9
FB_D_D7: UG7.M2 UG9.AK7
FB_D_D8: UG7.U11 UG9.AG4
FB_D_D9: UG7.U13 UG9.AF9
FB_D_D10: UG7.T11 UG9.AG6
FB_D_D11: UG7.T13 UG9.AG7
FB_D_D12: UG7.N11 UG9.AJ4
FB_D_D13: UG7.N13 UG9.AJ5
FB_D_D14: UG7.M11 UG9.AJ6
FB_D_D15: UG7.M13 UG9.AG5
FB_D_D16: UG7.A11 UG9.Y6
FB_D_D17: UG7.A13 UG9.Y5
FB_D_D18: UG7.B11 UG9.V5
FB_D_D19: UG7.B13 UG9.Y4
FB_D_D20: UG7.E11 UG9.AA6
FB_D_D21: UG7.E13 UG9.AA5
FB_D_D22: UG7.F11 UG9.AC5
FB_D_D23: UG7.F13 UG9.AC4
FB_D_D24: UG7.A4 UG9.AD7
FB_D_D25: UG7.A2 UG9.AC6
FB_D_D26: UG7.B4 UG9.AF6
FB_D_D27: UG7.B2 UG9.AD6
FB_D_D28: UG7.E4 UG9.AF7
FB_D_D29: UG7.E2 UG9.AF8
FB_D_D30: UG7.F4 UG9.AF2
FB_D_D31: UG7.F2 UG9.AF3
FB_D_D32: UG8.A4 UG9.F4
FB_D_D33: UG8.A2 UG9.E1
FB_D_D34: UG8.B4 UG9.F3
FB_D_D35: UG8.B2 UG9.F5
FB_D_D36: UG8.E4 UG9.D2
FB_D_D37: UG8.E2 UG9.D1
FB_D_D38: UG8.F4 UG9.C3
FB_D_D39: UG8.F2 UG9.C2
FB_D_D40: UG8.A11 UG9.J5
FB_D_D41: UG8.A13 UG9.J4
FB_D_D42: UG8.B11 UG9.L8
FB_D_D43: UG8.B13 UG9.J2
FB_D_D44: UG8.E11 UG9.F1
FB_D_D45: UG8.E13 UG9.F2
FB_D_D46: UG8.F11 UG9.H4
FB_D_D47: UG8.F13 UG9.H5
FB_D_D48: UG8.U11 UG9.V7
FB_D_D49: UG8.U13 UG9.V8
FB_D_D50: UG8.T11 UG9.V6
FB_D_D51: UG8.T13 UG9.V9
FB_D_D52: UG8.N11 UG9.U4
FB_D_D53: UG8.N13 UG9.R5
FB_D_D54: UG8.M11 UG9.R6
FB_D_D55: UG8.M13 UG9.U8
FB_D_D56: UG8.U4 UG9.P6
FB_D_D57: UG8.U2 UG9.R9
FB_D_D58: UG8.T4 UG9.P4
FB_D_D59: UG8.T2 UG9.P5
FB_D_D60: UG8.N4 UG9.L7
FB_D_D61: UG8.N2 UG9.L6
FB_D_D62: UG8.M4 UG9.L4
FB_D_D63: UG8.M2 UG9.L5
FB_D_DBI0: UG7.P2 UG9.AJ1
FB_D_DBI1: UG7.P13 UG9.AG1
FB_D_DBI2: UG7.D13 UG9.AA7
FB_D_DBI3: UG7.D2 UG9.AD5
FB_D_DBI4: UG8.D2 UG9.D3
FB_D_DBI5: UG8.D13 UG9.H3
FB_D_DBI6: UG8.P13 UG9.U5
FB_D_DBI7: UG8.P2 UG9.M9
FB_D_EDC0: UG7.R2 UG9.AJ3
FB_D_EDC1: UG7.R13 UG9.AG2
FB_D_EDC2: UG7.C13 UG9.AA9
FB_D_EDC3: UG7.C2 UG9.AF4
FB_D_EDC4: UG8.C2 UG9.E3
FB_D_EDC5: UG8.C13 UG9.H2
FB_D_EDC6: UG8.R13 UG9.U6
FB_D_EDC7: UG8.R2 UG9.M5
FB_D_WCK01: UG7.P4 UG9.AJ8
FB_D_WCK23: UG7.D4 UG9.AD8
FB_D_WCK45: UG8.D4 UG9.J6
FB_D_WCK67: UG8.P4 UG9.P8
FB_D_WCK#01: UG7.P5 UG9.AJ7
FB_D_WCK#23: UG7.D5 UG9.AD9
FB_D_WCK#45: UG8.D5 UG9.J7
FB_D_WCK#67: UG8.P5 UG9.P7
FB_VCCIO: PC818.2 PR5012.2 PR5015.1 PU509.14
FB_VDDQ_SENSE: PR8209.1 PU8200.12 UG9.E52
FBCAL_GND: RG68.1 UG9.P44
FBCAL_TERM: RG69.1 UG9.R45
FBCAL_VDDQ: RG67.1 UG9.R44
FBRTN: PC6002.1 PC6010.1 PC6012.2 PC6015.2 PR6025.1 PR6029.1 PR6061.2 PU6000.32
FBVDD/Q_EN: PR8216.1 RG557.1 UG27.4 UG31.19
FBVDD/Q_ENP: PC8211.1 PR8216.2 PU8200.3
FBVDD_PSI: PR8219.2 PU8200.4
FFS_INT1: RP5.8 UH1.BE18 US1.11
FFS_INT2: QS3.3 RP5.7 UH1.BF18 US1.9
FFS_INT2_CONN: DS1.2 JHDD.20 RS1.2
FLIP: QU2.1 RU27.2 UU2.32
FRAME_LOCK#: QG506.3 RG502.2 UG9.BG2
G-SYNC#: JEDP.21 QG506.1 RG517.2
GC6_EVENT#: DG2.1 UH1.BB26
GC6_EVENT#_D: DG2.2 RG8.1 UG9.BD1
GC6_FB_EN: QG511.1 RG561.2 UG31.7 UH1.BF29
GPD_7: RH11.1 RH594.2 UH1.BE41
GPIO4_1V8_MAIN_EN: RG571.1 RG574.1 RG582.1 UG9.BE1 UG31.13
GPIO8: RT124.2 RT125.1 UT4.H6
GPIO_1: DA2.2 UA1.2
GPP_H12: RH100.2 UH1.AB47
GPP_H15: RH99.1 UH1.AC47
GPP_J9: RH218.1 UH1.AU9
GPPJ_RCOMP_1P8: RH216.1 UH1.BD1 UH1.BE1 UH1.BE2
GPU_ALERT#: QG501.3 RE644.1 UE10.10
GPU_B+: PJP8200.2 PR6100.4 PR6101.1 PR6401.1
GPU_BUFRST#: T6.1(TP-1) UG9.BF9
GPU_DP_AUXN: RV618.1 RV665.1 UG9.BL8 UV3.6 UV3.13
GPU_DP_AUXN_C: CV25.1 UV3.5
GPU_DP_AUXN_R: CV25.2 RV618.2
GPU_DP_AUXP: RV619.1 RV664.1 UG9.BK8 UV3.3 UV3.10
GPU_DP_AUXP_C: CV24.1 UV3.2
GPU_DP_AUXP_R: CV24.2 RV619.2
GPU_DP_HPD#: QV97.3 RX5.2 UG9.BE3
GPU_DP_HPD_R: CX1.1 JDP.2 RX2.2
GPU_DP_N0: CV27.1 UG9.BG17
GPU_DP_N0_C: CV27.2 JDP.5
GPU_DP_N1: CV30.1 UG9.BF15
GPU_DP_N1_C: CV30.2 JDP.11
GPU_DP_N2: CV33.1 UG9.BF14
GPU_DP_N2_C: CV33.2 JDP.17
GPU_DP_N3: CV31.1 UG9.BG14
GPU_DP_N3_C: CV31.2 JDP.12
GPU_DP_P0: CV26.1 UG9.BH17
GPU_DP_P0_C: CV26.2 JDP.3
GPU_DP_P1: CV28.1 UG9.BG15
GPU_DP_P1_C: CV28.2 JDP.9
GPU_DP_P2: CV32.1 UG9.BE14
GPU_DP_P2_C: CV32.2 JDP.15
GPU_DP_P3: CV29.1 UG9.BH14
GPU_DP_P3_C: CV29.2 JDP.10
GPU_FAN_FB: DF2.2 RF4.1 UE5.29
GPU_FAN_PWM: JFAN2.2 RF5.1 UE5.27
GPU_GC6_FB_EN: QG511.3 RG22.1 RG553.1 UG9.BB5 UG27.1 UG31.6
GPU_HDMI_CLKN: CV1057.2 UG9.BF17
GPU_HDMI_CLKP: CV1058.2 UG9.BE17
GPU_HDMI_CTRL_CLK: QV96.4 RV648.2 UG9.BK9
GPU_HDMI_CTRL_DAT: QV96.1 RV652.2 UG9.BL9
GPU_HDMI_HPD#: QV97.6 RX7.2 UG9.BA4
GPU_HDMI_TX_N0: CV1060.2 UG9.BF18
GPU_HDMI_TX_N1: CV1062.2 UG9.BG20
GPU_HDMI_TX_N2: CV1064.2 UG9.BF20
GPU_HDMI_TX_P0: CV1059.2 UG9.BG18
GPU_HDMI_TX_P1: CV1061.2 UG9.BH20
GPU_HDMI_TX_P2: CV1063.2 UG9.BE20
GPU_INV_PWM: RG150.1 UG9.BD7 UG24.5
GPU_LPC: PR6052.1 PR6062.2 PU6000.35
GPU_OVERT#: DG3.1 QG501.6 QG502.3 RE102.1 RG534.2 UE6.21 UG23.6 UG31.4
GPU_PEX_RST_HOLD#: RG14.1 UG9.BG3
GPU_PH1: PL6100.1 PR6026.1 PR6108.1 PU6100.11 PU6100.12 PU6100.13 PU6100.14 PU6100.15 PU6100.16 PU6100.17 PU6100.18 PU6100.19 PU6100.20 PU6100.21
GPU_PH2: PL6101.1 PR6027.1 PR6115.1 PU6101.11 PU6101.12 PU6101.13 PU6101.14 PU6101.15 PU6101.16 PU6101.17 PU6101.18 PU6101.19 PU6101.20 PU6101.21
GPU_PH3: PL6200.1 PR6028.1 PR6206.1 PU6200.11 PU6200.12 PU6200.13 PU6200.14 PU6200.15 PU6200.16 PU6200.17 PU6200.18 PU6200.19 PU6200.20 PU6200.21
GPU_PH4: PL6201.1 PR6030.1 PR6213.1 PU6201.11 PU6201.12 PU6201.13 PU6201.14 PU6201.15 PU6201.16 PU6201.17 PU6201.18 PU6201.19 PU6201.20 PU6201.21
GPU_PROG1: PR6046.1 PR6056.2 PU6000.24
GPU_PROG2: PR6050.1 PR6057.2 PU6000.23
GPU_PROG3: PR6047.1 PR6058.2 PU6000.33
GPU_PROG4: PR6051.1 PR6059.2 PU6000.34
GPU_PROG5: PR6048.1 PR6060.2 PU6000.26
GPU_PROG6: PR6031.1 PU6000.3
GPU_PSI: PR6037.1 PR6039.1 PR6041.2 PU6000.37
GPU_PWM1: PR6043.1 PR6102.1 PR6105.2 PU6100.1
GPU_PWM2: PR6049.1 PR6109.1 PR6112.2 PU6101.1
GPU_PWM3: PR6054.1 PR6200.1 PR6203.2 PU6200.1
GPU_PWM4: PR6055.1 PR6207.1 PR6210.2 PU6201.1
GPU_PWR_EN: RG551.2 UG25.2 UG26.1 UG28.1
GPU_SNB1: PC6113.1 PR6108.2
GPU_SNB2: PC6127.1 PR6115.2
GPU_SNB3: PC6213.1 PR6206.2
GPU_SNB4: PC6227.1 PR6213.2
GPU_STRAP5_EC: QG512.2 RE672.1 UE5.71
GPU_VID: PR6044.2 PU6000.39
GSYNC_ID: RH29.1 RH30.1 UH1.BE17
GT_SW1: PL505.1 PR584.1 PR605.1 PU507.11 PU507.12
H_CPUPWRGD: CH194.1 UC1.BT31 UH1.AE3
H_DRAMRST#: RD31.2 RD35.2 UH1.BB46
H_PECI: RE76.2 RH73.2 UC1.BT34
H_PM_DOWN: RH14.1 RH155.1 UH1.AE2
H_PM_SYNC: RH15.2 UC1.BM34
H_PM_SYNC_R: RH15.1 UH1.AF3
H_PROCHOT#: PQ8.1 PR27.1 PR504.2 PR513.2 PR724.1 QE2.1 RH158.1 RH165.2
H_THERMTRIP#: RH79.2 RH163.2 UC1.J31
H_THERMTRIP#_R: RH79.1 UH1.AD3
H_VCCST_PWRGD: CH193.1 Q7.3 RH154.1 RH164.2 UE5.123
HDA_BIT_CLK: RP2.5 UH1.BD11
HDA_BIT_CLK_R: CA258.1 RA2.1 RP2.4 UA1.13
HDA_RST#: RP2.6 UH1.BE10
HDA_RST#_D: RA17.2 UA1.15
HDA_RST#_R: RA17.1 RP2.3
HDA_SDIN: RA18.1 UH1.BE11
HDA_SDIN_R: RA18.2 UA1.16
HDA_SDOUT: RH16.2 RP2.8 UH1.BF12
HDA_SDOUT_R: RP2.1 UA1.17
HDA_SPKR: DA1.3 RH600.1 UH1.AW29
HDA_SYNC: RP2.7 UH1.BG13
HDA_SYNC_R: RP2.2 UA1.14
HDMI_C_CLKN: CV1057.1 LV3.1 RV641.1 RX33.1
HDMI_C_CLKP: CV1058.1 LV3.4 RV640.1 RX34.1
HDMI_C_TX_N0: CV1060.1 LV4.1 RV643.1 RX31.1
HDMI_C_TX_N1: CV1062.1 LV5.1 RV642.1 RX35.1
HDMI_C_TX_N2: CV1064.1 LV6.1 RV645.1 RX37.1
HDMI_C_TX_P0: CV1059.1 LV4.4 RV646.1 RX32.1
HDMI_C_TX_P1: CV1061.1 LV5.4 RV639.1 RX36.1
HDMI_C_TX_P2: CV1063.1 LV6.4 RV638.1 RX38.1
HDMI_CLKN: JHDMI.12 RV673.2
HDMI_CLKP: JHDMI.10 RV674.2
HDMI_CTRL_CLK: JHDMI.15 RV651.1
HDMI_CTRL_CLK_R: QV96.3 RV649.1 RV651.2
HDMI_CTRL_DAT: JHDMI.16 RV650.1
HDMI_CTRL_DAT_R: QV96.6 RV650.2 RV653.1
HDMI_DOWN: LX1.2 LX2.2 LX3.2 LX4.2 LX5.2 LX6.2 LX7.2 LX8.2 QX1.1
HDMI_HPD: CX2.1 JHDMI.19 RX6.2
HDMI_HPD_PCH: QX3.3 RX8.1 UH1.BD21 UX2.1
HDMI_L_CLKN: LV3.2 RV500.2 RV641.2 RV673.1
HDMI_L_CLKP: LV3.3 RV500.1 RV640.2 RV674.1
HDMI_L_TX_N0: LV4.2 RV27.1 RV501.2 RV643.2
HDMI_L_TX_N1: LV5.2 RV29.1 RV502.2 RV642.2
HDMI_L_TX_N2: LV6.2 RV33.1 RV503.2 RV645.2
HDMI_L_TX_P0: LV4.3 RV28.1 RV501.1 RV646.2
HDMI_L_TX_P1: LV5.3 RV30.1 RV502.1 RV639.2
HDMI_L_TX_P2: LV6.3 RV34.1 RV503.1 RV638.2
HDMI_TX_N0: JHDMI.9 RV27.2
HDMI_TX_N1: JHDMI.6 RV29.2
HDMI_TX_N2: JHDMI.3 RV33.2
HDMI_TX_P0: JHDMI.7 RV28.2
HDMI_TX_P1: JHDMI.4 RV30.2
HDMI_TX_P2: JHDMI.1 RV34.2
HP2_D_L1_JK: CA50.1 DA6.3 JACK2.1 LA12.1
HP2_D_L_C: CA49.2 RA43.1
HP2_D_L_R: LA12.2 RA41.2 RA43.2 RA44.1 RA46.1
HP2_D_R1_JK: CA48.1 DA6.2 JACK2.2 LA11.1
HP2_D_R_C: CA47.2 RA42.1
HP2_D_R_R: LA11.2 RA40.2 RA42.2 RA45.1 RA47.1
HP_LINE1_JD: CA41.1 RA32.2 RA34.1 RA36.1 UA1.9
HP_MUTE#: DA2.1 RA13.2 UA2.B1 UA3.B1
HPOUT-L: RA35.1 UA1.32
HPOUT-R: RA37.1 UA1.33
HPOUT_JD: JACK1.6 RA34.2
I2C0_SCL_EC: JIO.12 RA56.1 RE668.2 UA1.12
I2C0_SCL_EC_R: RA50.2 RA56.2 UA4.8
I2C0_SDA_EC: JIO.11 RA55.1 RE669.2 UA1.11
I2C0_SDA_EC_R: RA53.2 RA55.2 UA4.7
I2C_0_SCL: RE71.1 RPC7.2 UH1.BC22
I2C_0_SCL_R: JTP.15 RE71.2 RE659.2
I2C_0_SDA: RE653.1 RPC7.1 UH1.BF23
I2C_0_SDA_R: JTP.16 RE653.2 RE660.2
I2C_CLK: RE2.2 RM1.2 UE1.42 UE3.25 UE4.25 UE8.25
I2C_DAT: RE1.2 RM2.2 UE1.43 UE3.26 UE4.26 UE8.26
I2C_INT: DK3.2 JPK.15 RE656.2 UE5.98
I2CC_SCL: QG7.3 RG60.2 UG11.6
I2CC_SCL_R: QG7.4 RG12.2 UG9.BG9
I2CC_SDA: QG7.6 RG61.2 UG11.7
I2CC_SDA_R: QG7.1 RG11.2 UG9.BH9
I2S_DATA_OUT: JIO.18 RA33.2 UA4.14
I2S_DATA_OUT_R: RA33.1 UA1.5
I2S_LRCK: JIO.16 RA30.2 UA4.11
I2S_LRCK_R: RA30.1 UA1.1
I2S_OUT: JIO.17 RA31.2 UA4.12
I2S_OUT_R: RA31.1 UA1.3
I_SYS: PR578.1 PR728.2 PU500.24 PU700.9
IADP_CHG: PC718.2 PR717.1 PU700.7
IDCHG_CHG: PC720.2 PU700.8
IFPAB_RSET: RG36.1 UG9.BD23
IFPCD_RSET: RG37.1 UG9.BD20
IFPEF_RSET: RG38.1 UG9.BD17
IGPU_ROM_CS#: RG147.2 UG15.1 UG16.2
IGPU_ROM_SCLK: RG148.1 UG15.6
IGPU_ROM_SI: RG149.1 UG15.5
IGPU_ROM_SO: RG146.1 UG16.5
IGPU_ROM_SO_R: RG146.2 UG15.2
ILIM_1.0VS_VGAP: PR812.1 PR813.2 PU800.13
ILIM_1PH: PC507.2 PR518.1 PU500.49
ILIM_2PH: PR542.1 PU500.32
ILIM_4PH: PR541.2 PU500.7
ILIM_+1.8VGS: PR814.1 PR815.2 PU802.13
ILIM_CHG: PQ705.3 PR709.1 PR711.1 PU700.21
ILIM_VCCIO: PR5033.1 PR5034.2 PU509.13
IMON_1PH: PC506.2 PR512.2 PU500.46
IMVP_VR_ON: CE38.1 PR524.2 Q7.6 UE5.121
INTRUDER#: RH531.1 UH1.BB44
INV_PWM: JEDP.36 RG536.2 RV8.1 UG24.6
ISEN1: PR6026.2 PU6000.20
ISEN2: PR6027.2 PU6000.19
ISEN3: PR6028.2 PU6000.18
ISEN4: PR6030.2 PR6070.2 PU6000.17
ISEN5: PR6032.2 PU6000.16
ISENSEP_L: RA58.2 RA77.1 UA4.25
ISENSEP_L_R: CA254.1 LA50.2 RA57.1 RA58.1
ISENSEP_R: RA63.2 RA80.1 UA4.28
ISENSEP_R_R: CA256.1 LA52.2 RA60.1 RA63.1
IVSENSE_L: RA59.2 RA78.1 UA4.26
IVSENSE_R: RA64.2 RA81.1 UA4.29
JKSI0: JKB.30 RE471.1
JKSI1: JKB.29 RE474.1
JKSI2: JKB.28 RE466.1
JKSI3: JKB.27 RE467.1
JKSI4: JKB.26 RE461.1
JKSI5: JKB.25 RE460.1
JKSI6: JKB.24 RE455.1
JKSI7: JKB.23 RE454.1
JKSI8: JKB.22 RE396.1
JKSI9: JKB.21 RE399.1
JKSI10: JKB.20 RE476.1
JKSI11: JKB.19 RE480.1
JKSI12: JKB.18 RE482.1
JKSI13: JKB.17 RE486.1
JKSI14: JKB.16 RE488.1
JKSI15: JKB.15 RE492.1
JKSI16: JKB.14 RE495.1
JKSI17: JKB.13 RE498.1
JKSI18: JKB.12 RE502.1
JKSI19: JKB.11 RE503.1
JKSI20: JKB.10 RE507.1
JKSI21: JKB.9 RE510.1
JKSO0: JKB.8 QE49.6 QE54.6
JKSO1: JKB.7 QE50.6 QE54.3
JKSO2: JKB.6 QE51.6 QE55.6
JKSO3: JKB.5 QE52.6 QE55.3
JKSO4: JKB.4 QE53.6 QE56.6
JRTC1: PD5.2 PR2.1
JTAG_TCLK: T10.1(TP-1) UG9.BK24
JTAG_TDI: T12.1(TP-1) UG9.BM23
JTAG_TDO: T13.1(TP-1) UG9.BM24
JTAG_TMS: T11.1(TP-1) UG9.BL23
JTAG_TRST#: RG518.1 UG9.BL24
KB_LED_B1_DRV#: JKBBL.5 UE4.5
KB_LED_B2_DRV#: JKBBL.8 UE4.9
KB_LED_B3_DRV#: JKBBL.11 UE4.14
KB_LED_B4_DRV#: JKBBL.14 UE4.17
KB_LED_B5_DRV#: JKB3.2 UE8.21
KB_LED_G1_DRV#: JKBBL.4 UE4.4
KB_LED_G2_DRV#: JKBBL.7 UE4.8
KB_LED_G3_DRV#: JKBBL.10 UE4.11
KB_LED_G4_DRV#: JKBBL.13 UE4.16
KB_LED_G5_DRV#: JKB3.3 UE8.20
KB_LED_R1_DRV#: JKBBL.3 UE4.3
KB_LED_R2_DRV#: JKBBL.6 UE4.6
KB_LED_R3_DRV#: JKBBL.9 UE4.10
KB_LED_R4_DRV#: JKBBL.12 UE4.15
KB_LED_R5_DRV#: JKB3.4 UE8.19
KB_RST#: RE646.1 RH518.1 UH1.BE39
KSI0: QE42.3 RE469.2 RE630.1 UE5.55
KSI0_R: JKB2.5 JKB2.6 RE630.2
KSI1: QE42.6 RE470.2 RE632.1 UE5.56
KSI1_R: JKB2.9 JKB2.10 RE632.2
KSI2: QE41.3 RE464.2 RE634.1 UE5.57
KSI2_R: JKB2.13 JKB2.14 RE634.2
KSI3: QE41.6 RE463.2 RE635.1 UE5.58
KSI3_R: JKB2.15 JKB2.16 RE635.2
KSI4: QE40.3 RE459.2 RE633.1 RE666.1 UE5.59
KSI4_R: JKB2.11 JKB2.12 RE633.2
KSI5: QE40.6 RE457.2 RE631.1 RE667.1 UE5.60
KSI5_R: JKB2.7 JKB2.8 RE631.2
KSI6: QE39.3 RE452.2 RE664.1 UE5.61
KSI7: QE39.6 RE451.2 RE665.1 UE5.62
KSI8: QE29.3 RE398.2 UE5.47
KSI9: QE29.6 RE400.2 UE5.48
KSI10: QE43.3 RE475.2 UE5.49
KSI11: QE43.6 RE477.2 UE5.50
KSI12: QE44.3 RE481.2 UE5.51
KSI13: QE44.6 RE483.2 UE5.52
KSI14: QE45.3 RE487.2 UE5.53
KSI15: QE45.6 RE489.2 UE5.54
KSI16: QE46.3 RE493.2 UE5.45
KSI17: QE46.6 RE494.2 UE5.46
KSI18: QE47.3 RE500.2 UE5.81
KSI19: QE47.6 RE499.2 UE5.82
KSI20: QE48.3 RE505.2 UE5.85
KSI21: QE48.6 RE506.2 UE5.86
KSO0: RE513.1 UE5.39
KSO1: RE516.1 UE5.40
KSO2: RE520.1 UE5.41
KSO3: RE524.1 UE5.42
KSO4: RE528.1 UE5.43
KSO5: JKB2.3 JKB2.4 UE5.44
LAN_ACTIVITY#: CL27.1 JLAN.10 UL1.38
LAN_LED2#: CL29.1 JLAN.13 RL15.1
LAN_LED2#_R: RL15.2 UL1.23
LAN_LINK#: CL28.1 JLAN.11 RL13.1
LAN_LINK#_R: QL3.2 RL4.2 UL1.39
LAN_MDIN0: TL1.11 UL1.12
LAN_MDIN1: TL1.7 UL1.15
LAN_MDIN2: TL1.5 UL1.18
LAN_MDIN3: TL1.1 UL1.21
LAN_MDIP0: TL1.12 UL1.11
LAN_MDIP1: TL1.8 UL1.14
LAN_MDIP2: TL1.6 UL1.17
LAN_MDIP3: TL1.2 UL1.20
LCD_TEST: JEDP.31 UE5.72
LDO2-CAP: CA28.1 CA29.1 RA12.2 UA1.22
LDO_EN: DK3.3 JPK.18 UE10.15
LG_3V: PQ101.4 PU100.11
LG_5V: PQ103.4 PU100.15
LG_+1VALWP: PQ301.4 PU300.6
LID_SW#: CE43.1 DE1.1 JIO.20 RE70.2 UE5.115
LINE1_JD: JACK2.5 RA36.2
LINE1_L: CA49.1 UA1.35
LINE1_R: CA47.1 UA1.34
LINE1_VREFO_L: RA41.1 UA1.40
LINE1_VREFO_R: RA40.1 UA1.39
LINE-IN-L: LA9.2 RA35.2 RA38.1
LINE-IN-R: LA10.2 RA37.2 RA39.1
LOGO_LED_B_DRV#: JLOGO.8 UE3.9
LOGO_LED_G_DRV#: JLOGO.7 UE3.8
LOGO_LED_R_DRV#: JLOGO.6 UE3.6
LPC_AD0: UE5.10 UH1.BB39
LPC_AD1: UE5.8 UH1.AW37
LPC_AD2: UE5.7 UH1.AV37
LPC_AD3: UE5.5 UH1.BA38
LPC_FRAME#: UE5.4 UH1.BE38
LX_1.0VS_VGAP: PC808.2 PL800.1 PR803.1 PU800.6 PU800.19 PU800.20
LX_3V: PC105.1 PL101.2 PQ100.1 PQ100.2 PQ100.3 PQ101.5 PR110.1 PU100.8
LX_5V: PC106.2 PL102.1 PQ102.1 PQ102.2 PQ102.3 PQ103.5 PR111.1 PU100.18
LX_+1.8VGS: PC823.2 PL801.1 PR809.1 PU802.6 PU802.19 PU802.20
LX_CHG: PC702.1 PL700.1 PQ704.1 PQ704.2 PQ704.3 PQ706.5 PR713.1 PU700.27
LX_VCCIO: PC593.2 PL509.1 PR5009.1 PU509.6 PU509.19 PU509.20
ME_EN: RH16.1 UE5.99
ME_SUS_PWR_ACK: RH506.1 UH1.BC37
MEM_VDD_CTL: PR8214.1 UG9.BH4
MEM_VREF: QG2.2 QG3.2 QG4.2 QG8.2 RG24.1 UG9.BD3
MIC1-VREFO_L: RA26.1 RA28.1 UA1.38
MIC_CLK: CA34.1 JEDP.23 LA6.1 RV13.1
MIC_DATA: CA35.1 JEDP.22 RA19.1
N17_ID0: RH27.1 RH28.1 UH1.AR18
N17_ID1: RH25.1 RH26.1 UH1.BF14
NC_B4: RT45.1 RT86.2 UT1.B4
NC_B5: RT46.1 UT1.B5
NC_G2: RT47.1 UT1.G2
NRB_BIT: RH524.2 UH1.BE30
NTC_LA: PH6000.1 PR6008.2 PR6009.1
NTC_LB: PC6003.2 PC6004.2 PC6006.2 PC6008.1 PH6000.2 PR6009.2 PR6010.2 PR6011.2 PR6012.2 PR6013.2 PR6014.2 PR6020.1
NUM: JKB.2 RE636.1
NUM_LED: RE637.1 UE5.36
NVVDD1_EN: CG481.1 DG7.1 PQ8203.2 PR6036.2 QG508.2 RG549.2 UG31.18
NVVDD1_ENP: PQ8203.3 PR6034.1 PU6000.36
NVVDD1_PGOOD: DG4.1 PR6042.2 PR6403.1 PU6000.38 UG29.2
NVVDD2_EN: PR6403.2 PR6404.2 PR6436.1 PR8217.1 PU6400.3 QG507.2 UG28.4 UG31.17
NVVDD2_PGOOD: DG4.2 PR801.2 PR6408.1 PU6400.13 QG502.4 QV3.2 RG506.2 UG31.5
NVVDD2_PSI: PR6406.1 PR6410.2 PR6413.2 PU6400.4
NVVDD_B+: PC6000.2 PC6100.1 PC6104.1 PC6105.1 PC6106.1 PC6107.1 PC6109.1 PC6110.1 PC6111.1 PC6112.1 PC6117.1 PC6118.1 PC6119.1 PC6120.1 PC6121.1 PC6122.1 PC6123.1 PC6125.1 PC6126.1 PC6200.1 PC6204.1 PC6205.1 PC6206.1 PC6208.1 PC6209.1 PC6210.1 PC6211.1 PC6212.1 PC6217.1 PC6218.1 PC6219.1 PC6220.1 PC6222.1 PC6223.1 PC6224.1 PC6225.1 PC6226.1 PR6006.1 PR6101.4 PU6100.8 PU6100.9 PU6101.8 PU6101.9 PU6200.8 PU6200.9 PU6201.8 PU6201.9
NVVDD_ISUMN1: PL6100.3 PR6010.1
NVVDD_ISUMN2: PL6101.3 PR6011.1
NVVDD_ISUMN3: PL6200.3 PR6013.1
NVVDD_ISUMN4: PL6201.3 PR6014.1
NVVDD_ISUMP1: PL6100.2 PR6001.1
NVVDD_ISUMP2: PL6101.2 PR6002.1
NVVDD_ISUMP3: PL6200.2 PR6003.1
NVVDD_ISUMP4: PL6201.2 PR6004.1
NVVDD_PSI: PR6039.2 RG15.1 RG565.1 UG9.BD2
NVVDD_VCC_SENSE: PR6021.2 UG9.BK45
NVVDD_VID: PR6044.1 UG9.BD6
NVVDD_VSS_SENSE: PR6025.2 UG9.BL45
NVVDDS_B+: PC6417.1 PC6418.1 PC6419.1 PC6420.1 PC6421.1 PC6422.1 PC6429.1 PC6430.1 PC6431.1 PC6432.1 PC6433.1 PC6435.1 PC6436.1 PQ6400.2 PQ6401.2 PQ6402.2 PQ6403.2 PR6401.4
NVVDDS_BST1: PR6405.1 PU6400.1
NVVDDS_BST2: PR6407.1 PU6400.15
NVVDDS_COMP: PC6427.2 PR6411.2 PU6400.12
NVVDDS_HG1: PR6429.1 PU6400.2
NVVDDS_HG2: PR6431.1 PU6400.14
NVVDDS_LG1: PQ6400.6 PQ6401.6 PR6434.2 PU6400.19
NVVDDS_LG2: PQ6402.6 PQ6403.6 PR6435.2 PU6400.17
NVVDDS_PSI: PR6410.1 RG503.1 RG564.2 RG565.2
NVVDDS_SNB1: PC6428.1 PR6409.2
NVVDDS_SNB2: PC6440.1 PR6424.2
NVVDDS_SW1: PC6423.1 PR6428.1 PU6400.20
NVVDDS_SW2: PC6415.1 PR6432.1 PU6400.16
NVVDDS_VCC_SENSE: PR6422.1 PR6425.2 UG9.BM45
NVVDDS_VID: PR6412.1 UG9.BE4
NVVDDS_VIDBUF: PR6416.1 PU6400.6
NVVDDS_VREF: PC6441.2 PR6419.1 PR6426.1 PU6400.8
NVVDDS_VSS_SENSE: PC6437.2 PC6439.2 PR6421.1 PR6423.2 PR6427.2 UG9.BM44
OC_WARN#: RG522.1 RG529.2 UG9.BB4 UG11.8
ON/OFF#: CE27.1 JPWR.5 RE63.1 SW1.2 UE5.114
OSC24M_IN: RE18.2 UE1.5
OSC24M_IN_R: CE2.1 RE3.1 RE18.1 YE1.1
OSC24M_OUT: RE19.2 UE1.6
OSC24M_OUT_R: CE5.1 RE3.2 RE19.1 YE1.3
OUT_A: CA67.1 CA87.1 LA50.1 UA4.55
OUT_B: CA68.1 CA88.1 LA51.1 UA4.52
OUT_C: CA69.1 CA89.1 LA52.1 UA4.47
OUT_D: CA70.1 CA90.1 LA53.1 UA4.44
OVERT#: RG9.1 RG572.1 UG9.BG5 UG23.5 UG31.3
P1: PC701.1 PQ700.3 PQ701.1 PQ701.2 PQ701.3 PQ702.1 PQ702.2 PQ702.3 PQ707.1 PQ707.2 PQ707.3 PQ708.1 PQ708.2 PQ708.3 PR701.2 PR706.1
P2: PQ702.5 PQ708.5 PR702.1
PA_USB2_RBIAS: RT43.1 UT1.H19
PANELL_LED_B_DRV#: JLOGO.11 UE8.14
PANELL_LED_G_DRV#: JLOGO.10 UE8.11
PANELL_LED_R_DRV#: JLOGO.9 UE8.10
PANELR_LED_B_DRV#: JLOGO.14 UE8.17
PANELR_LED_G_DRV#: JLOGO.13 UE8.16
PANELR_LED_R_DRV#: JLOGO.12 UE8.15
PB_USB2_RBIAS: RT44.1 UT1.F19
PBTN_OUT#: CH174.1 RH2.2 UE5.106 UH1.BE46
PC_BEEP: DA1.1 RA9.1 RA15.1
PCH_BATLOW#: RH515.1 RT14.2 UH1.BF44
PCH_CPU_BCLK_N: UC1.A32 UH1.C8
PCH_CPU_BCLK_P: UC1.B31 UH1.B8
PCH_CPU_PCIBCLK_N: UC1.C36 UH1.B6
PCH_CPU_PCIBCLK_P: UC1.D35 UH1.A6
PCH_DP3_CTRL_DATA: RH601.2 UH1.AR3
PCH_DP4_CTRL_DATA: RH602.2 UH1.AN40
PCH_DPWROK: DE4.2 RH90.2 UE5.127 UH1.AW41
PCH_JTAG_TCK: JPCMC.32 RC35.1 UC1.BR28 UH1.AH4
PCH_PECI: RH73.1 UH1.AF2
PCH_PLTRST#: UG10.2 UG31.8 UH1.AV29 UH3.1 UH3.2 UM3.2
PCH_PWR_EN: C268.1 PR300.1 PR807.2 RE74.1 U18.4
PCH_PWROK: CE44.1 DE3.2 RE75.1 UE5.32 UH1.AY42
PCH_RTCRST#: CH53.1 CLRP1.1 QE5.6 RH84.2 UH1.BE47
PCH_RTCX1: CH45.1 RH70.1 UH1.BA49 YH1.1
PCH_RTCX2: CH46.1 RH70.2 UH1.BA48 YH1.2
PCH_SATADET#: RH512.1 RS8.1 UH1.AK48
PCH_SMBCLK: JDIMM1.253 JDIMM2.253 RE659.1 RH463.2 UH1.BE26 US1.4
PCH_SMBDATA: JDIMM1.254 JDIMM2.254 RE660.1 RH462.2 UH1.BF26 US1.6
PCH_SML1ALERT#: RH63.2 UH1.BD33
PCH_SPI_0_CLK: RH104.1 UH1.AW47
PCH_SPI_0_CLK_R: RH104.2 RH591.1 UH4.6
PCH_SPI_0_CS#: UH1.AY47 UH4.1
PCH_SPI_0_HOLD#: RH78.2 RPH5.4 UH1.BA46
PCH_SPI_0_HOLD#_R: RPH5.5 UH4.7
PCH_SPI_0_SI: RH1.2 RPH5.2 UH1.AU41
PCH_SPI_0_SI_R: RH489.1 RPH5.7 UH4.5
PCH_SPI_0_SO: RPH5.3 UH1.BA45
PCH_SPI_0_SO_R: RPH5.6 UH4.2
PCH_SPI_0_WP#: RC354.2 RH75.2 RPH5.1 UH1.AY48
PCH_SPI_0_WP#_R: RPH5.8 UH4.3
PCH_SRTCRST#: CH52.1 QE5.3 RH83.2 UH1.BD46
PCH_SYS_PWROK_XDP: RH489.2 RH493.2
PCH_TRIGGER: RH167.1 UH1.AK3
PCH_XDP_CLK_N: T49.1(TP-1) UH1.Y3
PCH_XDP_CLK_P: T50.1(TP-1) UH1.Y4
PCIE_GEN3#_GEN2: UE1.28 UE6.11
PCIE_PRX_C_DTX_N15: CL2.1 UL1.29
PCIE_PRX_C_DTX_P15: CL1.1 UL1.30
PCIE_PRX_DTX_N9: JSSD3.5 UH1.G36
PCIE_PRX_DTX_N10: JSSD3.17 UH1.K37
PCIE_PRX_DTX_N11: JSSD3.29 UH1.G38
PCIE_PRX_DTX_N12: JSSD3.43 UH1.H42
PCIE_PRX_DTX_N15: CL2.2 UH1.F44
PCIE_PRX_DTX_N16: JWLAN.35 UH1.L41
PCIE_PRX_DTX_N17: JSSD1.43 UH1.K43
PCIE_PRX_DTX_N18: JSSD1.29 UH1.P41
PCIE_PRX_DTX_N19: JSSD1.17 UH1.M44
PCIE_PRX_DTX_N20: JSSD1.5 UH1.R35
PCIE_PRX_DTX_N21: JSSD2.41 UH1.T43
PCIE_PRX_DTX_N22: JSSD2.29 UH1.U40
PCIE_PRX_DTX_N23: JSSD2.17 UH1.W43
PCIE_PRX_DTX_N24: JSSD2.5 UH1.Y40
PCIE_PRX_DTX_P9: JSSD3.7 UH1.F36
PCIE_PRX_DTX_P10: JSSD3.19 UH1.J37
PCIE_PRX_DTX_P11: JSSD3.31 UH1.F39
PCIE_PRX_DTX_P12: JSSD3.41 UH1.J41
PCIE_PRX_DTX_P15: CL1.2 UH1.E45
PCIE_PRX_DTX_P16: JWLAN.33 UH1.M40
PCIE_PRX_DTX_P17: JSSD1.41 UH1.K44
PCIE_PRX_DTX_P18: JSSD1.31 UH1.R40
PCIE_PRX_DTX_P19: JSSD1.19 UH1.N42
PCIE_PRX_DTX_P20: JSSD1.7 UH1.R37
PCIE_PRX_DTX_P21: JSSD2.43 UH1.R44
PCIE_PRX_DTX_P22: JSSD2.31 UH1.U41
PCIE_PRX_DTX_P23: JSSD2.19 UH1.W44
PCIE_PRX_DTX_P24: JSSD2.7 UH1.Y41
PCIE_PTX_C_DRX_N9: CH202.1 JSSD3.11
PCIE_PTX_C_DRX_N10: CH204.1 JSSD3.23
PCIE_PTX_C_DRX_N11: CH207.2 JSSD3.35
PCIE_PTX_C_DRX_N12: CH209.2 JSSD3.47
PCIE_PTX_C_DRX_N15: CL4.1 UL1.36
PCIE_PTX_C_DRX_N16: CN24.1 JWLAN.29
PCIE_PTX_C_DRX_N17: CH210.1 JSSD1.47
PCIE_PTX_C_DRX_N18: CH212.1 JSSD1.35
PCIE_PTX_C_DRX_N19: CH214.2 JSSD1.23
PCIE_PTX_C_DRX_N20: CH216.2 JSSD1.11
PCIE_PTX_C_DRX_N21: CH218.1 JSSD2.47
PCIE_PTX_C_DRX_N22: CH220.1 JSSD2.35
PCIE_PTX_C_DRX_N23: CH222.1 JSSD2.23
PCIE_PTX_C_DRX_N24: CH224.1 JSSD2.11
PCIE_PTX_C_DRX_P9: CH203.1 JSSD3.13
PCIE_PTX_C_DRX_P10: CH205.1 JSSD3.25
PCIE_PTX_C_DRX_P11: CH206.2 JSSD3.37
PCIE_PTX_C_DRX_P12: CH208.2 JSSD3.49
PCIE_PTX_C_DRX_P15: CL3.1 UL1.35
PCIE_PTX_C_DRX_P16: CN23.1 JWLAN.27
PCIE_PTX_C_DRX_P17: CH211.1 JSSD1.49
PCIE_PTX_C_DRX_P18: CH213.1 JSSD1.37
PCIE_PTX_C_DRX_P19: CH215.2 JSSD1.25
PCIE_PTX_C_DRX_P20: CH217.2 JSSD1.13
PCIE_PTX_C_DRX_P21: CH219.1 JSSD2.49
PCIE_PTX_C_DRX_P22: CH221.1 JSSD2.37
PCIE_PTX_C_DRX_P23: CH223.1 JSSD2.25
PCIE_PTX_C_DRX_P24: CH225.1 JSSD2.13
PCIE_PTX_DRX_N9: CH202.2 UH1.C34
PCIE_PTX_DRX_N10: CH204.2 UH1.C35
PCIE_PTX_DRX_N11: CH207.1 UH1.B36
PCIE_PTX_DRX_N12: CH209.1 UH1.D38
PCIE_PTX_DRX_N15: CL4.2 UH1.B40
PCIE_PTX_DRX_N16: CN24.2 UH1.B41
PCIE_PTX_DRX_N17: CH210.2 UH1.A42
PCIE_PTX_DRX_N18: CH212.2 UH1.C42
PCIE_PTX_DRX_N19: CH214.1 UH1.C44
PCIE_PTX_DRX_N20: CH216.1 UH1.A44
PCIE_PTX_DRX_N21: CH218.2 UH1.G47
PCIE_PTX_DRX_N22: CH220.2 UH1.H47
PCIE_PTX_DRX_N23: CH222.2 UH1.G49
PCIE_PTX_DRX_N24: CH224.2 UH1.G46
PCIE_PTX_DRX_P9: CH203.2 UH1.D34
PCIE_PTX_DRX_P10: CH205.2 UH1.B35
PCIE_PTX_DRX_P11: CH206.1 UH1.C36
PCIE_PTX_DRX_P12: CH208.1 UH1.E37
PCIE_PTX_DRX_P15: CL3.2 UH1.C40
PCIE_PTX_DRX_P16: CN23.2 UH1.C41
PCIE_PTX_DRX_P17: CH211.2 UH1.B42
PCIE_PTX_DRX_P18: CH213.2 UH1.D42
PCIE_PTX_DRX_P19: CH215.1 UH1.D43
PCIE_PTX_DRX_P20: CH217.1 UH1.B44
PCIE_PTX_DRX_P21: CH219.2 UH1.F46
PCIE_PTX_DRX_P22: CH221.2 UH1.H48
PCIE_PTX_DRX_P23: CH223.2 UH1.G48
PCIE_PTX_DRX_P24: CH225.2 UH1.G45
PCIE_RBIAS: RT3.1 UT1.N16
PCIE_RCOMPN: RH193.1 UH1.B12
PCIE_RCOMPP: RH193.2 UH1.A13
PCIE_WAKE#: RH4.1 RL1.2 UE5.64 UL1.3
PCIRST#: CE34.1 JSSD1.50 JSSD2.50 JSSD3.50 JWLAN.44 RH199.1 RT1.1 UE5.13 UH3.4 UL1.2
