# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PD_EE_DO: length 16.3
  IN1 w0.081: v2(200.21,159.21) 200.16,159.16 199.99,159.16 198.55,160.6 197.68,160.6 196.62,161.66 196.18,161.66 195.47,162.38 189.33,162.38 v2(189.14,162.18)
  BOTTOM w0.114: RT99.2 188.44,162.13 189.09,162.13 v2(189.14,162.18) ; UT4.A4 199.66,161.15 199.91,160.9 199.91,160.18 v1(199.93,160.16) 199.93,159.64 200.21,159.36 v2(200.21,159.21)
PD_IRQ#: length 250.7
  TOP w0.107: v2(298.23,15.75) 298.39,15.75 302.74,11.4 UE5.89
  IN4 w0.102: v2(205.04,157.92) 204.62,157.92 202.69,155.98 202.69,152.21 200.61,150.12 200.61,148.88 201.48,148.01 201.48,145.69 199.14,143.35 199.14,130.6 200.13,129.61 200.13,126.88 200.13,126.74 203.7,123.17 203.7,115.51 203.97,115.24 206.85,112.36 206.85,105.72 209,103.57 209,69.95 207.62,68.56 207.62,58.84 210.93,55.52 210.93,52.27 214,49.2 214.15,49.2 215.8,47.55 215.87,47.48 215.87,47.48 216.16,47.19 223.38,47.19 223.67,47.48 229,47.48 229.27,47.21 237.05,47.21 237.32,47.48 237.4,47.48 237.48,47.55 237.91,47.98 247.48,47.98 248.99,46.47 259.95,46.47 260.56,45.86 268.63,45.86 272.87,41.62 277.8,41.62 278.61,42.42 292.34,42.42 293.04,41.72 296.64,41.72 297.06,41.3 v2(297.06,40.82)
  BOTTOM w0.076: 200.55,161.42 200.41,161.57 200.41,162.12 UT4.B6
  BOTTOM w0.089: 200.55,161.42 200.93,161.05
  BOTTOM w0.102: v2(205.04,157.92) 205.15,157.8 RT107.2 ; v2(297.06,40.82) 297.06,38.98 297.54,38.51 297.54,38.44 297.58,38.4 297.58,34.32 297.54,34.27 297.54,23.95 296.91,23.32 296.91,17.07 v2(298.23,15.75)
  BOTTOM w0.107: 200.93,161.05 201.05,160.92 v1(201.05,158.72) 201.05,158.6 201.74,157.92 v2(205.04,157.92)
PD_RESET: length 3.3
  TOP w0.102: RT109.1 319.92,56.61 v2(320.02,56.71) 320.2,56.89 320.2,58.54 319.92,58.81 UE10.8
PD_UART: length 3.2
  TOP w0.102: v2(197.62,164.23) 197.47,164.23 v1(197.19,163.95)
  TOP w0.107: v2(197.62,164.23) 197.97,164.23 198.26,163.93 RT62.1
  BOTTOM w0.076: v2(197.62,164.23) 197.73,164.12 198.28,164.12 198.45,163.95
  BOTTOM w0.089: UT4.F2 UT4.E2 198.53,163.87 198.45,163.95
PECI_KB9012: length 2.1
  TOP w0.114: UE5.118 308.7,20.01 RE76.1
PEG_CRX_C_GTX_N0: length 41.4
  TOP w0.107: CG9.2 208.06,134.67 208.16,134.57 208.16,134.42 208.28,134.31 208.71,134.31 208.74,134.33 209.31,134.33 209.34,134.31 209.96,134.31 220.45,123.82 v4(223.49,123.82) 234.42,123.82 236.04,122.2 236.04,121.66 236.55,121.16 236.55,116.18 236.44,116.07 236.2,116.07 236.07,115.94 v2(236.07,115.7)
  BOTTOM w0.117: UG9.BH26 236.47,115.58 236.35,115.7 v2(236.07,115.7)
PEG_CRX_C_GTX_N1: length 46.5
  TOP w0.107: CG16.2 207.27,135.69 207.53,135.43 209.81,135.43 220.72,124.53 234.69,124.53 236.78,122.44 v4(236.78,122.02) 236.78,121.48 237.05,121.21 237.05,117.88 236.98,117.8 236.98,115.8 236.78,115.6 236.78,113.54 236.46,113.21 236.33,113.21 v2(236.17,113.05)
  BOTTOM w0.107: UG9.BE26 236.28,113.35 236.17,113.24 v2(236.17,113.05)
PEG_CRX_C_GTX_N2: length 44.5
  TOP w0.107: v2(237.6,115.16) 237.59,115.16 237.45,115.03 237.29,115.03 237.18,115.13 237.18,115.43 237.38,115.63 237.38,117.63 237.47,117.72 237.47,122.81 234.94,125.34 220.93,125.34 209.93,136.34 v4(209.04,136.34) 208.02,136.34 207.93,136.43 207.78,136.43 CG25.2
  BOTTOM w0.107: v2(237.6,115.16) 237.59,115.16 237.48,115.06 237.48,115.06 UG9.BG27
PEG_CRX_C_GTX_N3: length 46.5
  TOP w0.107: CG27.2 206.57,137.25 206.63,137.25 206.67,137.21 210.11,137.21 221.28,126.04 235.47,126.04 238.16,123.34 v4(238.16,119.59) 238.16,117.6 238.58,117.19 238.58,116.26 238.45,116.13 238.17,116.13 238.04,116.01 238.04,115.85 v2(238.19,115.7)
  BOTTOM w0.107: v2(238.19,115.7) 238.46,115.7 238.57,115.59 UG9.BH29
PEG_CRX_C_GTX_N4: length 49.3
  TOP w0.107: v2(238.27,113.05) 238.49,113.27 238.8,113.27 238.97,113.45 238.97,114.25 238.78,114.44 238.78,115.67 238.97,115.86 238.97,118.31 239.1,118.43 239.1,123.42 235.71,126.81 221.52,126.81 210.34,137.99 v4(209.06,137.99) 208.08,137.99 207.97,138.1 207.97,138.25 207.86,138.36 CG29.2
  BOTTOM w0.117: UG9.BE29 v2(238.27,113.05)
PEG_CRX_C_GTX_N5: length 50
  TOP w0.107: v2(239.65,115.13) 239.45,114.93 239.3,114.93 239.18,115.06 239.18,115.43 239.37,115.62 239.37,117.56 239.85,118.03 v4(239.85,121.39) 239.85,123.69 236.03,127.51 221.81,127.51 210.27,139.05 206.56,139.05 CG31.2
  BOTTOM w0.117: v2(239.65,115.13) UG9.BG30
PEG_CRX_C_GTX_N6: length 49.2
  TOP w0.107: v2(240.29,115.7) 240.16,115.7 240.05,115.81 240.05,115.96 240.8,116.71 240.8,120.13 240.57,120.37 240.57,124.05 236.34,128.27 222.11,128.27 210.64,139.74 209.82,139.74 209.79,139.77 209.22,139.77 209.19,139.74 208.21,139.74 208.1,139.85 208.1,139.96 207.99,140.07 CG33.2
  BOTTOM w0.117: v2(240.29,115.7) 240.53,115.7 240.67,115.56 UG9.BH32
PEG_CRX_C_GTX_N7: length 54.5
  TOP w0.107: v2(240.37,113.05) 241.01,113.05 241.26,113.3 241.26,124.37 236.49,129.14 222.24,129.14 210.14,141.24 209.17,141.24 209.15,141.27 208.57,141.27 208.55,141.24 207.02,141.24 206.89,141.37 206.89,141.49 206.79,141.6 CG36.2
  BOTTOM w0.117: UG9.BE32 v2(240.37,113.05)
PEG_CRX_C_GTX_P0: length 41.4
  TOP w0.107: v2(236.06,115.15) 235.7,115.51 235.7,115.85 236.34,116.5 236.34,121.07 235.84,121.58 235.84,122.11 234.34,123.61 223.8,123.61 223.78,123.58 223.21,123.58 223.18,123.61 220.37,123.61 209.88,134.1 v4(209.03,134.1) CG8.2
  BOTTOM w0.117: UG9.BG26 236.07,115.15 v2(236.06,115.15)
PEG_CRX_C_GTX_P1: length 46.5
  TOP w0.107: CG10.2 206.34,135.16 206.62,135.16 206.7,135.25 206.7,135.42 206.76,135.49 207.19,135.49 207.45,135.23 209.73,135.23 220.63,124.32 234.61,124.32 236.58,122.35 236.58,121.4 236.85,121.13 236.85,117.96 236.78,117.89 236.78,115.88 236.58,115.68 236.58,113.62 236.38,113.42 236.15,113.42 236,113.57 v2(236,113.82)
  BOTTOM w0.107: UG9.BF26 236.23,114.05 v2(236,113.82)
PEG_CRX_C_GTX_P2: length 44.6
  TOP w0.107: v2(237.47,114.35) 236.98,114.84 236.98,115.52 237.18,115.72 237.18,117.71 237.27,117.81 237.27,122.72 234.86,125.14 220.84,125.14 209.85,136.13 209.35,136.13 209.32,136.11 208.75,136.11 208.72,136.13 207.63,136.13 CG22.2
  BOTTOM w0.107: UG9.BF27 237.17,114.24 237.29,114.36 237.46,114.36 v2(237.47,114.35)
PEG_CRX_C_GTX_P3: length 46.5
  TOP w0.107: v2(238.17,115.15) 237.82,115.5 237.82,116.08 238.32,116.58 238.32,117.15 237.96,117.52 v4(237.96,121.15) 237.96,123.26 235.38,125.83 221.19,125.83 210.02,137 206.47,137 CG26.2
  BOTTOM w0.107: UG9.BG29 v2(238.17,115.15)
PEG_CRX_C_GTX_P4: length 49.3
  TOP w0.107: CG28.2 208.75,137.79 208.78,137.76 209.35,137.76 209.38,137.79 210.26,137.79 221.43,126.61 235.62,126.61 238.9,123.34 v4(238.9,122.36) 238.9,118.52 238.77,118.39 238.77,115.94 238.58,115.75 238.58,114.35 238.77,114.16 238.77,113.58 238.66,113.48 237.98,113.48 237.88,113.58 237.88,113.79 237.98,113.9 v2(238.18,113.9)
  BOTTOM w0.117: v2(238.18,113.9) 238.18,113.91 238.42,113.91 UG9.BF29
PEG_CRX_C_GTX_P5: length 50
  TOP w0.107: CG30.2 206.53,138.84 210.19,138.84 221.73,127.31 235.94,127.31 239.65,123.6 239.65,118.12 239.17,117.64 239.17,115.71 238.98,115.51 238.98,114.94 v2(239.57,114.35)
  BOTTOM w0.117: v2(239.57,114.35) 239.39,114.35 239.27,114.23 UG9.BF30
PEG_CRX_C_GTX_P6: length 49.2
  TOP w0.107: v2(240.3,115.12) 239.85,115.57 239.85,116.04 240.6,116.79 240.6,120.05 240.36,120.28 240.36,123.97 236.26,128.07 222.02,128.07 210.56,139.54 v4(209.51,139.54) 207.6,139.54 CG32.2
  BOTTOM w0.117: UG9.BG32 v2(240.3,115.12)
PEG_CRX_C_GTX_P7: length 54.5
  TOP w0.107: v2(240.23,113.91) 240.05,113.72 240.05,113.57 240.15,113.47 240.55,113.47 240.76,113.25 240.93,113.25 241.05,113.38 241.05,124.29 236.41,128.94 222.15,128.94 210.05,141.04 v4(208.86,141.04) 206.5,141.04 CG35.2
  BOTTOM w0.117: UG9.BF32 240.53,113.91 v2(240.23,113.91)
PEG_CRX_C_RD_GTX_N8: length 2.5
  BOTTOM w0.099: UM8.4 134.61,154.88
  BOTTOM w0.107: CM69.2 135.01,153.27 135.01,153.75 134.81,153.96 134.81,154.69 134.76,154.74 134.61,154.88
PEG_CRX_C_RD_GTX_N9: length 2.5
  BOTTOM w0.107: CM66.2 132.4,153.26 v4(132.4,153.84) 132.4,154.1 132.71,154.41 132.71,154.57 132.61,154.66 UM8.8
PEG_CRX_C_RD_GTX_N10: length 4.5
  BOTTOM w0.099: 133.75,154.45 133.61,154.59 UM8.6
  BOTTOM w0.107: 133.75,154.45 133.79,154.41 133.79,154.09 133.76,154.06 133.76,153.45 133.79,153.42 v4(133.79,152.39) 133.79,151.85 133.6,151.66 133.6,151.41 CM62.2
PEG_CRX_C_RD_GTX_N11: length 4.6
  BOTTOM w0.107: CM65.2 136.33,151.35 136.33,152.29 136.31,152.32 136.31,152.89 136.33,152.92 136.33,153.75 v4(136.13,153.95) 135.77,154.31 135.77,154.59 135.61,154.75 UM8.2
PEG_CRX_C_RD_GTX_P8: length 2.5
  BOTTOM w0.099: UM8.3 135.11,154.85
  BOTTOM w0.107: CM67.2 135.21,153.29 135.21,153.84 135.01,154.04 135.01,154.75 135.11,154.85
PEG_CRX_C_RD_GTX_P9: length 2.6
  BOTTOM w0.107: CM63.2 132.63,153.27 132.63,154.05 132.91,154.33 132.91,154.55 133.11,154.75 UM8.7
PEG_CRX_C_RD_GTX_P10: length 4.4
  BOTTOM w0.099: UM8.5 134.11,154.59
  BOTTOM w0.107: 134.11,154.59 133.99,154.47 v4(133.99,153.77) 133.99,152.7 134.02,152.68 134.02,152.11 133.99,152.08 133.99,151.77 133.8,151.58 133.8,151.34 CM68.2
PEG_CRX_C_RD_GTX_P11: length 4.6
  BOTTOM w0.107: UM8.1 136.11,154.74 135.98,154.6 135.98,154.42 136.08,154.31 136.1,154.31 136.54,153.87 v4(136.54,152.61) 136.54,151.4 CM64.2
PEG_CRX_C_TTX_N12: length 5.3
  TOP w0.089: UT1.V22 185.81,163.59 186.57,163.59 187.05,163.11
  TOP w0.107: CT16.2 189.92,162.34 189.76,162.34 189.38,162.72 189.34,162.72 188.96,163.1 188.4,163.1 188.32,163.02 v4(187.8,163.02) 187.15,163.02 187.05,163.11
PEG_CRX_C_TTX_N13: length 2.5
  TOP w0.089: UT1.P22 185.65,165.66 185.87,165.44 186.25,165.44 186.3,165.49 186.67,165.49 187.05,165.11 187.63,165.11 CT2.2
PEG_CRX_C_TTX_N14: length 2.4
  TOP w0.089: CT108.2 187.74,167.84 187.59,167.69 187.14,167.69 187.05,167.6 186.71,167.6 186.58,167.73 185.84,167.73 UT1.K22
PEG_CRX_C_TTX_N15: length 2.5
  TOP w0.089: UT1.F22 185.59,169.29 185.86,169.11 186.61,169.11 187.06,169.55 CT110.2
PEG_CRX_C_TTX_P12: length 5.3
  TOP w0.089: UT1.V23 186.03,163.82 185.93,163.92 185.93,164.01 185.98,164.06 186.3,164.06 186.36,164 186.36,163.82 186.4,163.77 186.67,163.77 187.16,163.29
  TOP w0.107: CT14.2 189.98,162.56 189.83,162.56 v4(189.3,163.08) 189.09,163.3 188.24,163.3 188.18,163.25 187.2,163.25 187.16,163.29 187.16,163.29
PEG_CRX_C_TTX_P13: length 2.5
  TOP w0.089: CT12.2 187.49,165.55 187.4,165.46 187.4,165.39 187.31,165.3 187.13,165.3 186.75,165.68 186.43,165.68 186.36,165.74 186.36,165.84 186.31,165.89 185.98,165.89 185.94,165.85 185.94,165.76 UT1.P23
PEG_CRX_C_TTX_P14: length 2.4
  TOP w0.089: CT109.2 187.52,167.5 187.21,167.5 187.12,167.41 186.62,167.41 186.52,167.51 186.42,167.51 186.36,167.44 186.36,167.34 186.28,167.27 186.05,167.27 185.92,167.4 185.92,167.5 UT1.K23
PEG_CRX_C_TTX_P15: length 2.5
  TOP w0.089: UT1.F23 186.04,169.46 186.13,169.55 186.29,169.55 186.38,169.46 186.38,169.41 186.47,169.32 186.57,169.32 186.98,169.73 187.35,169.73 187.44,169.82 187.44,170.02 187.46,170.04
  TOP w0.107: CT111.2 187.72,170.16 187.58,170.16 187.46,170.04
PEG_CRX_GTX_N0: length 59.8
  TOP w0.107: v2(203.2,130.1) 203.35,130.25 203.35,130.49 203.66,130.8 204.54,130.8 205.69,131.94 v4(205.69,132.82) 205.69,134.29 206.07,134.67 CG9.1
  IN3 w0.089: 179.44,101.17 179.35,101.17 178.76,100.57 172.57,100.57 172.44,100.7 171.08,100.7 170.64,101.14 170.32,101.14 170.05,101.41 v2(170.05,101.69)
  IN3 w0.127: 179.44,101.17 181.21,102.94 181.21,103.38 181.97,104.15 181.97,105.14 184.77,107.94 184.77,108.85 185.62,109.69 185.62,110.54 187.46,112.39 187.46,113.55 191.12,117.21 191.12,119.48 191.66,120.03 192.07,120.03 193.76,121.72 194.02,121.72 197.21,124.91 197.35,124.91 198.32,125.87 198.32,128.38 199.84,129.9 202.65,129.9 202.98,129.57 203.16,129.57 203.35,129.76 203.35,129.94 v2(203.2,130.1)
  BOTTOM w0.076: UC1.E10 170.05,101.61 v2(170.05,101.69)
PEG_CRX_GTX_N1: length 59
  TOP w0.107: CG16.1 205.64,135.61 204.97,135.61 204.52,135.17 v4(204.52,133.91) 204.52,132.78 204.2,132.46 203.29,132.46 202.96,132.14 v2(202.96,131.22)
  IN3 w0.089: v2(170.71,101.67) 170.71,101.67 171.28,101.09 172.42,101.09 173.06,101.73 178.59,101.73 178.96,102.1 179.53,102.1
  IN3 w0.127: v2(202.96,131.22) 202.96,131.22 203.15,131.4 203.15,131.69 203.02,131.82 202.19,131.82 201.91,131.53 199.56,131.53 196.63,128.61 196.63,127.15 195.17,125.69 195.17,124.55 193.09,122.46 193.09,122 191.71,120.63 191.15,120.63 189.77,119.25 189.77,116.58 186.89,113.7 186.89,112.53 184.91,110.55 184.91,109.7 184.27,109.06 184.27,108.15 181.27,105.15 181.27,104.16 180.7,103.59 180.7,103.15 179.65,102.1 179.53,102.1
  BOTTOM w0.076: UC1.E11 170.38,102 v2(170.71,101.67)
PEG_CRX_GTX_N2: length 62.3
  TOP w0.107: CG25.1 206.85,136.52 206.8,136.52 206.67,136.38 204.76,136.38 204.13,135.75 203.14,135.75 203.03,135.86 203.03,136.06 203.37,136.39 v2(203.49,136.39)
  IN3 w0.089: v2(170.06,102.46) 170.29,102.69 170.42,102.69 170.99,102.12 172.62,102.12 172.77,102.27 178.2,102.27 179.43,103.5 179.49,103.5
  IN3 w0.127: 179.49,103.5 179.7,103.71 179.7,103.71 179.7,103.99 180.31,104.6 180.31,105.23 183.54,108.45 183.54,109.36 184.18,110 184.18,110.85 186.06,112.74 186.06,113.9 187.64,115.48 187.64,115.94 188.85,117.15 188.85,119.37 194.24,124.75 194.24,127.8 196.73,130.29 196.73,135.09 197.2,135.56 203.02,135.56 203.27,135.82 203.27,136.17 v2(203.49,136.39)
  BOTTOM w0.089: UC1.E12 170.06,102.53 v2(170.06,102.46)
PEG_CRX_GTX_N3: length 61.4
  TOP w0.107: v2(203.78,136.9) 203.91,137.02 203.91,137.37 204.14,137.6 205.08,137.6 205.2,137.49 205.33,137.49 205.35,137.47 CG27.1
  IN3 w0.089: 179.17,104.38 179.13,104.35 179.13,104.07 178.36,103.31 172.98,103.31 172.32,102.64 171.31,102.64 v2(170.71,103.25)
  IN3 w0.127: v2(203.78,136.9) 203.97,137.08 203.97,137.61 203.44,138.14 197.73,138.14 194.82,135.23 194.82,129.65 194,128.83 194,128.71 193.22,127.93 193.22,124.77 188.12,119.67 188.12,117.46 186.91,116.24 186.91,115.78 185.23,114.1 185.23,112.93 183.46,111.15 183.46,110.3 182.81,109.66 182.81,108.75 179.17,105.11 179.17,104.38
  BOTTOM w0.076: UC1.E13 170.38,103.43 170.56,103.25 v2(170.71,103.25)
PEG_CRX_GTX_N4: length 64.5
  TOP w0.107: v2(202.86,139.26) 202.75,139.26 202.62,139.13 202.62,139.11 202.42,138.9 202.42,138.68 202.8,138.29 v4(203.54,138.29) 205.37,138.29 205.48,138.18 205.62,138.18 205.64,138.16 206.06,138.16 206.17,138.05 206.62,138.05 206.72,138.14 206.77,138.14 CG29.1
  IN3 w0.089: v2(170.05,104.85) 170.26,104.64 170.32,104.64 170.94,104.01 174.47,104.01 174.48,104.01 178,104.01 178.23,104.24 178.23,104.9
  IN3 w0.127: v2(202.86,139.26) 202.75,139.26 202.63,139.38 202.63,139.45 202.43,139.65 202.43,139.9 202.13,140.2 198.03,140.2 193.87,136.05 193.87,130.04 193.06,129.22 193.06,129.1 192.28,128.32 192.28,125.16 187.18,120.06 187.18,117.85 185.97,116.64 185.97,116.17 184.29,114.49 184.29,113.32 182.51,111.55 182.51,110.81 181.86,110.15 181.86,109.2 178.23,105.56 178.23,104.9
  BOTTOM w0.076: UC1.E14 170.05,104.76 v2(170.05,104.85)
PEG_CRX_GTX_N5: length 62.3
  TOP w0.107: v2(203.97,139.7) 203.93,139.7 203.53,139.3 203.53,139.14 203.69,138.98 205.46,138.98 205.51,139.03 205.56,139.03 CG31.1
  IN3 w0.089: 176.72,105.13 176.72,105.13 176.72,105.1 176.59,104.98 173.03,104.98 172.41,105.59 170.89,105.59 170.67,105.38 v2(170.67,104.82)
  IN3 w0.127: 176.72,105.13 181.13,109.54 181.13,110.45 181.78,111.11 181.78,111.85 183.48,113.55 183.48,115.75 186.35,118.62 186.35,120.26 191.55,125.46 191.55,129.04 193.02,130.51 193.02,136.29 197.66,140.93 203.24,140.93 203.83,140.34 203.83,139.84 v2(203.97,139.7)
  BOTTOM w0.107: v2(170.67,104.82) 170.65,104.82 170.38,105.09 UC1.E15
PEG_CRX_GTX_N6: length 65.1
  TOP w0.107: v2(202.53,142.16) 202.46,142.16 202.05,141.75 202.05,141.36 202.38,141.02 203.07,141.02 203.57,140.53 204.63,140.53 204.83,140.33 205.75,140.33 206.22,139.86 206.77,139.86 CG33.1
  IN3 w0.089: 177.49,106.72 177.48,106.71 177.47,106.71 177.46,106.72 177.42,106.68 177.39,106.68 176.07,105.35 173.28,105.35 172.85,105.78 170.82,105.78 170.65,105.61 v2(170.06,105.61)
  IN3 w0.127: v2(202.53,142.16) 202.31,141.93 202.31,141.68 202.06,141.43 200.45,141.43 200.13,141.76 196.37,141.76 191.65,137.04 191.65,129.86 191.04,129.25 191.04,125.75 185.05,119.75 185.05,118.04 182.97,115.96 182.97,113.76 181.9,112.68 181.28,112.06 181.28,111.32 180.09,110.14 180.09,109.33 177.49,106.72
  BOTTOM w0.089: UC1.E16 170.06,105.68 v2(170.06,105.61)
PEG_CRX_GTX_N7: length 63.6
  TOP w0.107: CG36.1 205.85,141.6 205.54,141.29 205.16,141.29 205.1,141.35 203.72,141.35 203.45,141.63 203.45,141.78 203.65,141.98 v2(203.89,141.98)
  IN3 w0.127: v2(203.89,141.98) 203.83,142.04 203.83,142.2 203.83,142.6 203.09,143.33 202.36,143.33 201.71,143.97 197.25,143.97 190.64,137.36 190.64,130.18 190.1,129.64 190.1,126.14 184.07,120.11 184.07,118.4 182.03,116.35 182.03,114.15 180.79,112.91 180.33,112.45 180.33,111.71 179.11,110.49 179.11,109.68 176.66,107.23 170.92,107.23 170.66,106.97 v2(170.66,106.4)
  BOTTOM w0.076: UC1.E17 170.65,106.47 170.64,106.43 v2(170.66,106.4)
PEG_CRX_GTX_N8: length 87.4
  IN3 w0.091: v2(170.06,107.19) 170.3,107.43 172.41,107.43 172.6,107.62
  IN3 w0.127: v2(134.75,151.37) 134.75,152.03 135.01,152.29 135.63,152.29 135.86,152.29 136.56,151.59 136.56,148.35 135.34,147.12 135.34,135.11 139.74,130.71 157.24,130.71 159.45,128.5 167.93,128.5 170.94,125.49 174.31,125.49 174.62,125.18 175.75,124.05 175.75,113.47 174.71,112.42 174.71,109.24 173.86,108.39 173.36,108.39 172.6,107.62
  BOTTOM w0.076: v2(170.06,107.19) 170.06,107.19 169.73,107.51 UC1.F18
  BOTTOM w0.107: v2(134.75,151.37) 135.01,151.63 135.01,152.02 CM69.1
PEG_CRX_GTX_N9: length 83.9
  IN3 w0.127: v2(171.36,107.97) 171.36,108.21 171.74,108.59 172.26,108.59 173.42,109.74 173.42,113.33 173.09,113.66 173.09,114.36 173.63,114.91 173.63,115.51 174.84,116.72 174.84,117.87 174.58,118.13 174.58,121.83 172.12,124.29 170.99,124.29 170.24,125.04 167.57,127.71 155.62,127.71 154.11,129.21 139.96,129.21 136.28,132.9 136.28,133.14 134.61,134.81 134.61,147.42 135.84,148.65 135.84,149.73 135.12,150.45 134.34,150.45 133.06,151.73 131.96,151.73 v2(131.9,151.79)
  BOTTOM w0.076: UC1.D19 171.03,108.3 v2(171.36,107.97)
  BOTTOM w0.107: CM66.1 132.41,152.35 132.52,152.24 132.52,151.81 132.31,151.6 132.09,151.6 v2(131.9,151.79)
PEG_CRX_GTX_N10: length 72
  IN3 w0.127: v2(170.07,108.76) 169.8,109.02 169.78,109.02 169.69,109.02 167.99,110.72 167.99,114.98 166.77,116.2 166.17,116.2 165.43,116.93 165.43,124.59 163.97,126.04 154.39,126.04 152.95,127.47 139.34,127.47 138.5,128.31 132.92,133.89 v2(132.92,149.25)
  BOTTOM w0.076: UC1.F20 169.73,109.1 v2(170.07,108.76)
  BOTTOM w0.107: CM62.1 133.52,150.14 133.52,149.98 133.18,149.64 133.18,149.51 v2(132.92,149.25)
PEG_CRX_GTX_N11: length 79.2
  IN3 w0.127: v2(134.27,149.69) 134.86,149.69 135.11,149.43 135.11,148.95 133.89,147.72 133.89,134.26 139.7,128.45 153.61,128.45 155.07,126.98 164.98,126.98 166.6,125.37 168.88,125.37 169.33,124.92 169.33,122.38 169.96,121.75 171.23,121.75 172.88,120.1 172.88,116.17 172.63,115.92 172.63,115.47 171.59,114.43 171.59,113.97 172.63,112.93 172.63,110.81 171.88,110.06 171.46,110.06 171.33,109.93 171.33,109.57 v2(171.36,109.55)
  BOTTOM w0.076: UC1.D21 171.03,109.87 v2(171.36,109.55)
  BOTTOM w0.107: v2(134.27,149.69) 134.44,149.51 136.07,149.51 136.47,149.91 136.47,150.34 136.36,150.45 CM65.1
PEG_CRX_GTX_P0: length 59.8
  TOP w0.107: CG8.1 206.77,134.32 206.71,134.32 206.58,134.45 206.13,134.45 205.89,134.21 205.89,133.13 205.92,133.11 205.92,132.53 205.89,132.51 205.89,131.86 204.63,130.6 203.75,130.6 203.59,130.44 203.59,130.21 203.7,130.1 v2(203.88,130.1)
  IN3 w0.089: v2(170.06,100.89) 170.13,100.96 170.57,100.96 171,100.52 172.36,100.52 172.49,100.39 178.84,100.39 179.39,100.95 179.53,100.95
  IN3 w0.127: v2(203.88,130.1) 203.57,129.78 203.57,129.67 203.25,129.36 202.88,129.36 202.55,129.69 199.93,129.69 198.54,128.29 198.54,125.78 197.44,124.69 197.3,124.69 194.11,121.5 193.85,121.5 192.16,119.81 191.76,119.81 191.33,119.39 191.33,117.12 187.68,113.46 187.68,112.29 185.84,110.45 185.84,109.6 184.99,108.76 184.99,107.85 182.19,105.05 182.19,104.06 181.43,103.29 181.43,102.84 179.59,101.01 179.53,100.95
  BOTTOM w0.076: v2(170.06,100.89) 169.73,101.21 UC1.F10
PEG_CRX_GTX_P1: length 59
  TOP w0.107: CG10.1 205.41,135.12 205.3,135.23 205.3,135.31 205.2,135.41 205.05,135.41 204.73,135.09 204.73,134.23 204.76,134.2 204.76,133.63 204.73,133.6 204.73,132.7 204.29,132.26 203.37,132.26 203.17,132.06 203.17,131.6 v2(203.55,131.22)
  IN3 w0.089: 179.53,102.32 179.51,102.32 179.51,102.31 178.92,102.31 178.51,101.91 172.98,101.91 172.35,101.27 171.36,101.27 171.22,101.41 171.22,101.54 v2(171.36,101.67)
  IN3 w0.127: v2(203.55,131.22) 203.36,131.4 203.36,131.79 203.12,132.04 202.1,132.04 201.82,131.75 199.47,131.75 196.41,128.7 196.41,127.24 194.95,125.78 194.95,124.64 192.87,122.55 192.87,122.09 191.62,120.85 191.06,120.85 189.56,119.35 189.56,116.67 186.67,113.79 186.67,112.62 184.69,110.64 184.69,109.79 184.05,109.15 184.05,108.24 181.05,105.24 181.05,104.25 180.48,103.69 180.48,103.24 179.56,102.32 179.53,102.32
  BOTTOM w0.076: UC1.D11 171.03,102 v2(171.36,101.67)
PEG_CRX_GTX_P2: length 62.2
  TOP w0.107: v2(202.83,136.43) 202.83,135.78 203.05,135.55 204.21,135.55 204.84,136.18 206.87,136.18 CG22.1
  IN3 w0.089: v2(170.04,103.27) 170.04,103.01 170.17,102.88 170.49,102.88 171.07,102.3 172.55,102.3 172.7,102.45 178.13,102.45 179.48,103.8
  IN3 w0.127: 179.48,103.8 179.48,104.08 180.09,104.69 180.09,105.32 183.32,108.54 183.32,109.45 183.96,110.09 183.96,110.94 185.85,112.83 185.85,113.99 187.42,115.57 187.42,116.03 188.63,117.25 188.63,119.46 194.02,124.84 194.02,127.89 196.51,130.38 196.51,135.18 197.11,135.78 202.9,135.78 203.03,135.91 203.03,136.23 v2(202.83,136.43)
  BOTTOM w0.089: UC1.F12 170.04,103.16 v2(170.04,103.27)
PEG_CRX_GTX_P3: length 61.5
  TOP w0.107: CG26.1 205.46,136.9 205.37,136.99 205.37,137.18 205.26,137.29 205.11,137.29 205,137.4 204.22,137.4 204.11,137.29 204.11,137.14 204.36,136.9 v2(204.36,136.9)
  IN3 w0.089: 178.95,104.46 178.95,104.15 178.29,103.49 172.91,103.49 172.25,102.82 171.39,102.82 171.22,102.99 171.22,103.11 v2(171.36,103.25)
  IN3 w0.127: v2(204.36,136.9) 204.19,137.08 204.19,137.7 203.53,138.36 197.64,138.36 194.6,135.32 194.6,129.74 193.78,128.92 193.78,128.8 193.01,128.02 193.01,124.86 187.91,119.76 187.91,117.55 186.69,116.34 186.69,115.87 185.01,114.19 185.01,113.02 183.24,111.25 183.24,110.4 182.59,109.75 182.59,108.84 178.95,105.2 178.95,104.46
  BOTTOM w0.076: v2(171.36,103.25) 171.18,103.25 171.03,103.39 UC1.D13
PEG_CRX_GTX_P4: length 64.4
  TOP w0.107: v2(202.21,139.28) 202.21,138.59 202.71,138.09 203.23,138.09 203.25,138.06 203.82,138.06 203.85,138.09 205.29,138.09 205.4,137.98 205.53,137.98 205.55,137.96 205.98,137.96 206.08,137.85 206.92,137.85 CG28.1
  IN3 w0.089: v2(170.07,104.02) 170.06,104.02 169.85,104.22 169.85,104.35 169.94,104.44 170.26,104.44 170.29,104.41 170.87,103.83 174.47,103.83 174.48,103.83 178.07,103.83 178.41,104.17 178.41,104.79 178.44,104.83
  IN3 w0.127: 178.44,104.83 178.44,105.47 182.08,109.1 182.08,110.06 182.73,110.72 182.73,111.46 184.5,113.23 184.5,114.4 186.19,116.08 186.19,116.55 187.4,117.76 187.4,119.97 192.5,125.07 192.5,128.23 193.27,129.01 193.27,129.13 194.09,129.95 194.09,135.96 198.12,139.98 202.04,139.98 202.21,139.81 v2(202.21,139.28)
  BOTTOM w0.076: UC1.F14 170.06,104.11 170.06,104.04 v2(170.07,104.02)
PEG_CRX_GTX_P5: length 62.3
  TOP w0.107: v2(203.3,139.64) 203.3,139.09 203.6,138.78 205.67,138.78 CG30.1
  IN3 w0.089: 176.88,104.98 176.87,104.97 176.84,104.97 176.67,104.79 172.95,104.79 172.34,105.41 170.96,105.41 170.85,105.3 170.85,105.17 171.03,104.99 171.03,104.91 171.19,104.74 171.32,104.74 v2(171.4,104.82)
  IN3 w0.127: 176.88,104.98 181.35,109.45 181.35,110.36 182,111.02 182,111.76 183.7,113.45 183.7,115.66 186.57,118.53 186.57,120.17 191.77,125.37 191.77,128.95 193.24,130.42 193.24,136.2 197.75,140.71 203.15,140.71 203.61,140.25 203.61,139.91 203.34,139.64 v2(203.3,139.64)
  BOTTOM w0.076: v2(171.4,104.82) 171.4,104.88 171.06,105.22 UC1.D15
PEG_CRX_GTX_P6: length 65.1
  TOP w0.107: CG32.1 206.83,139.65 206.13,139.65 205.66,140.12 204.75,140.12 204.54,140.33 203.49,140.33 202.99,140.82 202.3,140.82 201.85,141.27 v2(201.85,142.12)
  IN3 w0.089: v2(170.06,106.4) 170.06,106.17 170.43,105.79 170.58,105.79 170.75,105.96 172.93,105.96 173.36,105.53 175.99,105.53 177.34,106.88
  IN3 w0.127: 177.34,106.88 179.88,109.42 179.88,110.23 181.06,111.41 181.06,112.15 181.68,112.77 182.75,113.85 182.75,116.05 184.83,118.13 184.83,119.84 190.83,125.84 190.83,129.34 191.43,129.95 191.43,137.13 196.28,141.98 200.22,141.98 200.54,141.65 201.96,141.65 202.09,141.78 202.09,141.88 v2(201.85,142.12)
  BOTTOM w0.089: UC1.F16 170.06,106.33 v2(170.06,106.4)
PEG_CRX_GTX_P7: length 63.6
  TOP w0.107: CG35.1 205.84,141.09 205.08,141.09 205.02,141.15 203.64,141.15 203.24,141.54 203.24,141.96 v2(203.15,142.06)
  IN3 w0.127: v2(203.15,142.06) 203.38,142.06 203.61,142.29 203.61,142.51 203,143.11 202.26,143.11 201.62,143.75 197.34,143.75 190.86,137.27 190.86,130.09 190.32,129.55 190.32,126.05 184.29,120.02 184.29,118.31 182.25,116.26 182.25,114.06 181.01,112.82 180.55,112.36 180.55,111.62 179.33,110.4 179.33,109.59 176.75,107.01 171.03,107.01 170.9,106.88 170.9,106.7 171.04,106.57 171.04,106.47 171.14,106.37 171.39,106.37 v2(171.4,106.39)
  BOTTOM w0.076: UC1.D17 171.03,106.79 171.4,106.42 v2(171.4,106.39)
PEG_CRX_GTX_P8: length 87.4
  IN3 w0.091: v2(170.06,108.02) 170.05,108.02 169.93,108.02 169.77,107.87 169.77,107.7 169.86,107.61 172.33,107.61 172.45,107.73 172.45,107.78
  IN3 w0.127: 172.45,107.78 173.27,108.6 173.77,108.6 174.49,109.33 174.49,112.51 175.53,113.56 175.53,123.96 174.21,125.28 170.85,125.28 167.84,128.28 159.36,128.28 157.15,130.49 139.65,130.49 135.12,135.02 135.12,147.21 136.35,148.44 136.35,151.5 135.77,152.07 135.48,152.07 135.39,152.07 135.11,152.07 134.98,151.94 134.98,151.73 135.34,151.37 v2(135.45,151.37)
  BOTTOM w0.089: UC1.E18 170.38,107.65 170.06,107.97 v2(170.06,108.02)
  BOTTOM w0.107: CM67.1 135.21,152 135.21,151.62 v2(135.45,151.37)
PEG_CRX_GTX_P9: length 84
  IN3 w0.127: v2(131.9,151.21) 131.91,151.21 132.21,151.51 132.97,151.51 134.25,150.23 135.03,150.23 135.62,149.64 135.62,148.74 134.4,147.51 134.4,134.72 136.06,133.05 136.06,132.81 139.87,128.99 154.02,128.99 155.53,127.49 167.48,127.49 170.9,124.07 172.03,124.07 174.36,121.74 174.36,118.04 174.62,117.78 174.62,116.81 173.41,115.6 173.41,115 172.87,114.45 172.87,113.57 173.2,113.24 173.2,109.84 172.17,108.81 171.65,108.81 171.17,108.33 171.06,108.33 v2(170.71,107.97)
  BOTTOM w0.076: v2(170.71,107.97) 170.38,108.3 UC1.E19
  BOTTOM w0.107: v2(131.9,151.21) 132.09,151.4 132.4,151.4 132.72,151.72 132.72,152.11 CM63.1
PEG_CRX_GTX_P10: length 71.9
  IN3 w0.127: v2(133.51,149.25) 133.51,149.24 133.14,148.88 133.14,133.98 138.59,128.53 139.43,127.69 153.04,127.69 154.48,126.26 164.07,126.26 165.64,124.68 165.64,117.03 166.26,116.41 166.86,116.41 168.21,115.07 168.21,110.81 169.78,109.24 169.93,109.24 170.05,109.37 v2(170.05,109.58)
  BOTTOM w0.076: v2(170.05,109.58) 170.05,109.49 UC1.E20
  BOTTOM w0.107: CM68.1 133.73,150.06 133.73,149.89 133.39,149.55 133.39,149.37 v2(133.51,149.25)
PEG_CRX_GTX_P11: length 79.2
  IN3 w0.127: v2(134.27,149.1) 134.43,149.27 134.44,149.27 134.64,149.47 134.77,149.47 134.89,149.34 134.89,149.04 133.67,147.82 133.67,134.17 139.61,128.23 153.52,128.23 154.98,126.76 164.89,126.76 166.51,125.15 168.79,125.15 169.11,124.83 169.11,122.29 169.87,121.53 171.14,121.53 172.66,120.01 172.66,116.26 172.41,116.01 172.41,115.56 171.37,114.52 171.37,113.88 172.41,112.84 172.41,110.9 171.79,110.28 171.37,110.28 171.11,110.03 171.11,109.93 170.73,109.55 v2(170.71,109.55)
  BOTTOM w0.076: v2(170.71,109.55) 170.38,109.87 UC1.E21
  BOTTOM w0.107: v2(134.27,149.1) 134.41,149.25 134.47,149.3 136.16,149.3 136.67,149.82 136.67,150.22 CM64.1
PEG_CRX_RD_GTX_N8: length 43.2
  IN6 w0.089: v2(135.82,163.06) 135.82,161.45 136.75,160.52 138.01,160.52 139.22,161.73 139.94,161.73 140.84,162.63 144.79,162.63 145.85,163.69 149.89,163.69 149.89,163.69 150.36,163.69 150.36,163.69 151.81,163.69 152.58,164.46 152.58,164.61 154.47,166.51 155.86,166.51 157.91,168.56 157.91,170.99 158.54,171.62 158.83,171.62 160.04,172.84 160.04,174.17 158.55,175.66 158.55,177.56 v2(158.67,177.68)
  BOTTOM w0.099: JCDRA.16 158.62,178.6
  BOTTOM w0.107: UM8.42 134.61,161.07 134.88,161.34 134.88,161.7 135.5,162.31 135.57,162.31 136,162.73 136,162.89 v2(135.82,163.06) ; 158.62,178.6 158.52,178.5 158.52,177.83 v2(158.67,177.68)
PEG_CRX_RD_GTX_N9: length 51.8
  IN6 w0.089: v2(131.89,161.92) 131.97,161.83 131.97,160.22 133.38,158.8 138.31,158.8 139.97,160.46 140.47,160.46 141.37,161.36 145.31,161.36 146.03,162.07 148.43,162.07 148.73,162.37 153.06,162.37 154.83,164.14 155.44,164.14 160.33,169.03 160.33,169.64 162.65,171.95 162.65,172.74 163.39,173.49 163.39,174.02 163.65,174.27 163.65,176.94 162.69,177.9 160.91,177.9 160.51,177.5 160.02,177.5 v2(159.85,177.67)
  BOTTOM w0.099: JCDRA.19 159.82,178.53
  BOTTOM w0.107: v2(131.89,161.92) 132.11,161.69 UM8.37 ; v2(159.85,177.67) 159.71,177.81 159.71,178.43 159.82,178.53
PEG_CRX_RD_GTX_N10: length 46.7
  IN6 w0.089: v2(162.5,177.29) 162.5,175.32 161.63,174.45 161.63,173.13 159.65,171.15 159.65,169.25 155.24,164.84 154.63,164.84 152.8,163.01 148.47,163.01 148.17,162.71 145.76,162.71 145.05,161.99 141.1,161.99 140.21,161.1 139.51,161.1 138.3,159.88 136.24,159.88 135.83,160.29 133.7,160.29 132.9,161.09 132.9,162.44 132.72,162.61 v2(132.66,162.61)
  BOTTOM w0.099: UM8.39 133.11,161.38
  BOTTOM w0.107: v2(162.5,177.29) 162.27,177.52 162.27,177.77 162.12,177.92 162.12,178.43 162.22,178.52 JCDRA.25 ; 133.11,161.38 133.23,161.49 133.23,161.5 133.28,161.55 133.28,161.77 132.97,162.09 132.97,162.42 132.77,162.61 v2(132.66,162.61)
PEG_CRX_RD_GTX_N11: length 42.6
  IN6 w0.089: v2(136.91,162.11) 137.23,161.79 138.06,161.79 139.48,163.21 140.29,163.21 140.5,163.42 140.54,163.43 144.45,163.43 145.59,164.56 145.59,168.39 150.22,173.03 150.69,173.03 152.68,175.01 152.68,175.9 154.21,177.44 155.38,177.44 156.91,178.97 164.53,178.97 164.79,178.7 v2(164.79,177.99)
  BOTTOM w0.099: JCDRA.31 164.62,178.51
  BOTTOM w0.107: UM8.44 135.61,161.37 135.97,161.73 135.97,161.73 136.01,161.77 136.81,161.77 136.91,161.88 v2(136.91,162.11) ; 164.62,178.51 164.62,178.16 v2(164.79,177.99)
PEG_CRX_RD_GTX_P8: length 43.2
  IN6 w0.089: v2(158.09,177.68) 158.17,177.68 158.27,177.58 158.27,177.51 158.39,177.4 158.39,175.6 159.88,174.1 159.88,172.91 158.76,171.79 158.47,171.79 157.74,171.06 157.74,168.63 155.79,166.67 154.4,166.67 152.42,164.68 152.42,164.53 151.74,163.86 150.29,163.86 150.29,163.86 149.96,163.86 149.95,163.86 145.78,163.86 144.72,162.79 140.77,162.79 139.87,161.9 139.15,161.9 137.94,160.68 136.82,160.68 135.99,161.51 135.99,162.66 136.22,162.89 136.22,162.97 136.31,163.06 v2(136.53,163.06)
  BOTTOM w0.099: UM8.43 135.11,161.21 ; JCDRA.15 158.22,178.61
  BOTTOM w0.107: 158.22,178.61 158.31,178.51 158.31,177.91 v2(158.09,177.68) ; 135.11,161.21 135.11,161.64 135.58,162.11 135.66,162.11 136.2,162.65 136.2,162.79 136.47,163.06 v2(136.53,163.06)
PEG_CRX_RD_GTX_P9: length 51.8
  IN6 w0.089: v2(132.47,161.92) 132.13,161.58 132.13,160.28 133.45,158.97 138.24,158.97 139.9,160.63 140.4,160.63 141.3,161.52 145.24,161.52 145.96,162.24 148.37,162.24 148.67,162.54 152.99,162.54 154.76,164.3 155.37,164.3 160.16,169.1 160.16,169.71 162.48,172.02 162.48,172.81 163.23,173.56 163.23,174.09 163.48,174.34 163.48,176.87 162.62,177.73 160.98,177.73 160.57,177.33 160.08,177.33 160.01,177.27 159.68,177.27 159.28,177.67 v2(159.26,177.67)
  BOTTOM w0.099: JCDRA.18 159.42,178.43 ; UM8.38 132.61,161.38 132.47,161.52 v2(132.47,161.92)
  BOTTOM w0.107: 159.42,178.43 159.51,178.34 159.51,177.91 v2(159.26,177.67)
PEG_CRX_RD_GTX_P10: length 46.7
  IN6 w0.089: v2(161.92,177.29) 162.33,176.87 162.33,175.39 161.47,174.52 161.47,173.2 159.48,171.22 159.48,169.32 155.17,165 154.56,165 152.73,163.17 148.4,163.17 148.1,162.87 145.7,162.87 144.98,162.16 141.03,162.16 140.14,161.26 139.44,161.26 138.23,160.05 136.31,160.05 135.9,160.46 133.76,160.46 133.06,161.16 133.06,162.65 133.15,162.74 133.4,162.74 133.49,162.65 v2(133.49,162.61)
  BOTTOM w0.099: UM8.40 133.61,161.38
  BOTTOM w0.107: JCDRA.24 161.82,178.54 161.92,178.44 161.92,177.83 162.07,177.69 162.07,177.44 v2(161.92,177.29) ; v2(133.49,162.61) 133.36,162.61 133.17,162.43 133.17,162.17 133.49,161.85 133.49,161.5 133.61,161.38
PEG_CRX_RD_GTX_P11: length 42.6
  IN6 w0.089: v2(136.91,161.15) 137.38,161.62 138.13,161.62 139.55,163.05 140.36,163.05 140.58,163.26 144.52,163.26 145.75,164.49 145.75,168.32 150.29,172.86 150.76,172.86 152.84,174.94 152.84,175.83 154.28,177.27 155.44,177.27 156.98,178.81 164.46,178.81 164.63,178.64 164.63,178.39 164.23,177.99 v2(164.21,177.99)
  BOTTOM w0.099: JCDRA.30 164.22,178.49
  BOTTOM w0.107: v2(136.91,161.15) 136.94,161.15 137.04,161.26 137.04,161.46 136.94,161.57 136.09,161.57 135.96,161.43 135.96,161.28 136.11,161.13 UM8.45 ; 164.22,178.49 164.39,178.32 164.39,178.17 v2(164.21,177.99)
PEG_CRX_TTX_N12: length 91.1
  TOP w0.107: CT16.1 190.83,162.26 191.17,162.26 191.2,162.23 191.94,162.23 192.24,162.52 192.24,163.05 192.48,163.29 192.79,163.29 193.35,163.86 v2(193.35,164.52)
  IN6 w0.089: v2(170.05,110.33) 170.65,109.91 173.95,109.91 175.26,108.6 177.18,108.6 178.39,109.81 184.1,109.81 189.4,115.12 189.4,115.37 190.99,116.95 190.99,119.11 193.14,121.26 194.22,121.26 195.44,122.48 196.37,122.48 197.34,123.45 197.89,123.45 198.96,124.51 199.27,124.51 199.69,124.93 199.69,126 200.07,126.38 200.07,128.95 200.8,129.68 200.8,130.61 202.61,132.43 202.61,132.69 202.61,135.5 201.79,136.33 201.79,138.07 200.61,139.25 200.61,143.95 201.24,144.58 201.24,149.91 202.85,151.53 202.85,155.78 200.48,158.15 200.22,158.15 199.73,158.65 199.05,158.65 197.21,160.48 197.21,161.12 196.47,161.86 196.11,161.86 196.09,161.88 195.94,161.88 195.77,162.06 195.77,162.22 195.77,162.22 195.77,162.74 194.23,164.28 193.59,164.28 v2(193.35,164.52)
  BOTTOM w0.089: UC1.F22 169.73,110.64 v2(170.05,110.33)
PEG_CRX_TTX_N13: length 87.4
  TOP w0.107: v2(190.73,164.09) 190.48,164.34 190.15,164.34 189.76,164.72 189.13,164.72 188.69,165.17 188.54,165.17 CT2.1
  IN6 w0.089: v2(190.73,164.09) 190.79,164.15 190.79,164.39 190.82,164.43 190.88,164.43 191.01,164.55 191.65,164.55 192.92,163.28 193.46,163.28 194.1,163.28 194.97,162.41 194.97,161.72 195.55,161.14 195.55,152.63 200.37,147.81 200.37,145.48 199.08,144.19 199.08,138.8 200.68,137.21 200.68,134.09 200.75,134.01 200.75,132.13 200,131.38 200,130.01 198.36,128.38 198.36,125.05 197.56,124.25 197,124.25 196.04,123.28 194.03,123.28 191.7,120.95 191.15,120.95 189.27,119.08 189.27,118.21 188.46,117.4 188.46,115.3 183.78,110.62 176.72,110.62 176.65,110.69 175.44,110.69 174.8,111.33 172.92,111.33 172.23,110.64 171.17,110.64 171.01,110.8 171.01,110.97 171.02,110.98 171.02,111.22 171.11,111.31 171.29,111.31 171.4,111.19 v2(171.4,111.13)
  BOTTOM w0.089: v2(171.4,111.13) 171.03,111.5 UC1.D23
PEG_CRX_TTX_N14: length 85.2
  TOP w0.107: CT108.1 188.53,167.65 189.88,167.65 190.41,168.18 190.41,168.49 191.08,169.17 191.39,169.17 v2(191.6,169.38)
  IN6 w0.089: v2(170.06,112.7) 170.06,112.64 170.34,112.36 170.45,112.36 170.93,111.88 175.35,111.88 176.12,112.64 176.12,114.8 176.6,115.28 177.04,115.28 177.91,116.15 182.8,116.15 184.95,118.3 184.95,118.44 186.1,119.59 186.1,120.78 194.8,129.48 194.8,131.5 195.87,132.58 195.87,135.86 195.04,136.68 195.04,148.65 192.29,151.4 192.16,151.53 192.16,153.58 190.81,154.93 190.81,158.32 190.09,159.04 190.09,160.33 188.03,162.39 188.03,167.29 188.28,167.54 189.57,167.54 191.19,169.17 191.38,169.17 191.44,169.23 191.45,169.23 v2(191.6,169.38)
  BOTTOM w0.107: UC1.F24 170.06,112.63 v2(170.06,112.7)
PEG_CRX_TTX_N15: length 81.1
  TOP w0.107: v2(189.33,169.96) 189.38,170.01 189.44,170.01 189.54,170.11 189.54,170.11 189.6,170.21 189.6,170.36 189.4,170.56 189.12,170.56 188.91,170.35 188.91,169.99 188.68,169.77 188.56,169.77 CT110.1
  IN6 w0.089: v2(171.32,112.68) 171.13,112.68 171.04,112.59 171.04,112.39 171.17,112.26 172.26,112.26 172.96,112.96 173.05,112.96 173.13,113.03 173.43,113.03 173.51,112.96 173.76,112.96 173.84,113.03 174.14,113.03 174.22,112.96 174.47,112.96 174.57,113.06 174.83,113.06 174.93,112.96 175.08,112.96 175.42,113.3 175.42,115.08 176.34,116 177.07,116 177.28,116.21 177.28,116.35 177.89,116.96 182.71,116.96 184.03,118.28 184.03,119.61 194.16,129.74 194.16,137.99 194.15,138 194.15,148.64 191.52,151.27 191.52,153.31 190.18,154.66 190.18,157.99 187.36,160.81 187.36,168.02 188.81,169.47 189.55,169.47 189.77,169.69 189.77,169.9 189.59,170.09 189.46,170.09 v2(189.33,169.96)
  BOTTOM w0.089: UC1.D25 171.03,112.96 v2(171.32,112.68)
PEG_CRX_TTX_P12: length 91.1
  TOP w0.107: v2(192.64,164.49) 192.85,164.49 192.94,164.39 192.94,164.35 193.15,164.14 193.15,163.94 192.71,163.5 192.4,163.5 192.03,163.13 192.03,162.61 191.89,162.46 v4(191.58,162.46) 191.01,162.46 190.97,162.49 190.92,162.49 CT14.1
  IN6 w0.089: v2(170.68,110.33) 170.68,110.16 170.77,110.08 172.68,110.08 172.8,110.19 173.04,110.19 173.15,110.08 173.4,110.08 173.51,110.19 173.75,110.19 173.86,110.08 174.02,110.08 175.33,108.77 175.58,108.77 175.69,108.87 175.94,108.87 176.04,108.77 177.11,108.77 178.32,109.97 184.03,109.97 189.24,115.18 189.24,115.43 190.83,117.02 190.83,119.18 193.07,121.43 194.15,121.43 195.37,122.65 196.3,122.65 197.27,123.61 197.83,123.61 198.89,124.68 199.2,124.68 199.53,125 199.53,126.07 199.91,126.45 199.91,129.02 200.63,129.75 200.63,130.68 202.45,132.5 202.45,132.62 202.45,135.44 201.62,136.26 201.62,138 200.44,139.18 200.44,144.01 201.08,144.65 201.08,149.98 202.69,151.6 202.69,155.71 200.42,157.98 200.16,157.98 199.66,158.48 198.98,158.48 197.05,160.41 197.05,161.05 196.4,161.69 196.04,161.69 196.02,161.71 195.88,161.71 195.6,161.99 195.6,162.28 195.6,162.48 195.6,162.67 194.16,164.11 193.57,164.11 193.55,164.09 193.22,164.09 192.95,164.35 192.95,164.42 192.86,164.52 192.67,164.52 v2(192.64,164.49)
  BOTTOM w0.089: v2(170.68,110.33) 170.38,110.63 UC1.E22
PEG_CRX_TTX_P13: length 87.4
  TOP w0.107: v2(190.72,164.83) 190.43,164.54 190.23,164.54 189.85,164.93 189.22,164.93 188.77,165.38 188.52,165.38 CT12.1
  IN6 w0.089: v2(190.72,164.83) 190.82,164.72 190.83,164.72 191.71,164.72 192.99,163.44 193.46,163.44 194.17,163.44 195.13,162.48 195.13,161.79 195.72,161.21 195.72,152.7 200.54,147.88 200.54,145.41 199.25,144.12 199.25,138.87 200.84,137.28 200.84,134.16 200.92,134.08 200.92,132.06 200.16,131.31 200.16,129.94 198.53,128.31 198.53,124.98 197.63,124.08 197.07,124.08 196.11,123.12 194.1,123.12 191.77,120.79 191.21,120.79 189.44,119.01 189.44,118.14 188.62,117.33 188.62,115.23 183.84,110.45 176.65,110.45 176.58,110.53 175.37,110.53 174.73,111.17 172.99,111.17 172.3,110.48 171.1,110.48 170.85,110.73 170.85,110.94 v2(170.66,111.13)
  BOTTOM w0.089: v2(170.66,111.13) 170.66,111.28 170.42,111.51 UC1.E23
PEG_CRX_TTX_P14: length 85.1
  TOP w0.107: CT109.1 188.43,167.27 188.61,167.45 189.96,167.45 190.61,168.1 190.61,168.41 191.17,168.96 191.44,168.96 v2(191.6,168.8)
  IN6 w0.089: v2(170.06,111.9) 170.06,112 170.25,112.2 170.38,112.2 170.86,111.71 175.42,111.71 176.28,112.58 176.28,114.74 176.67,115.12 177.11,115.12 177.98,115.99 182.87,115.99 185.11,118.23 185.11,118.37 186.26,119.52 186.26,120.71 194.96,129.41 194.96,131.44 196.03,132.51 196.03,135.92 195.2,136.75 195.2,148.72 192.45,151.47 192.32,151.6 192.32,153.65 190.98,155 190.98,158.39 190.25,159.11 190.25,160.4 188.2,162.45 188.2,167.22 188.35,167.38 189.64,167.38 191.26,169 191.4,169 v2(191.6,168.8)
  BOTTOM w0.107: UC1.E24 170.06,111.98 v2(170.06,111.9)
PEG_CRX_TTX_P15: length 81
  TOP w0.107: v2(190.01,170.24) 189.48,170.77 189.04,170.77 188.71,170.44 188.71,170.08 188.6,169.97 188.5,169.97 CT111.1
  IN6 w0.089: v2(190.01,170.24) 190,170.24 190,170.23 189.98,170.21 189.98,170.16 189.94,170.12 189.94,169.62 189.62,169.31 188.88,169.31 187.52,167.96 187.52,160.88 190.34,158.06 190.34,154.73 191.69,153.38 191.69,151.34 194.32,148.71 194.32,138.07 194.33,138.06 194.33,129.67 184.2,119.54 184.2,118.21 182.78,116.79 177.96,116.79 177.45,116.28 177.45,116.14 177.14,115.83 176.41,115.83 175.59,115.01 175.59,113.23 175.15,112.79 173.03,112.79 172.33,112.09 171.1,112.09 170.87,112.32 170.87,112.49 v2(170.68,112.68)
  BOTTOM w0.089: v2(170.68,112.68) 170.68,112.74 170.38,113.04 UC1.E25
PEG_CTX_C_GRX_N0: length 26.9
  BOTTOM w0.089: 236.27,123.5 236.27,123.43 v4(236.82,122.88) 237.56,122.14 237.56,121.26 237.59,121.24 237.59,120.68 237.56,120.65 237.56,118.85 237.74,118.68 237.74,118.1 237.5,117.86 237.5,117.28 237.17,116.95 UG9.BK27
  BOTTOM w0.107: 236.27,123.5 235.98,123.79 235.97,123.79 235.8,123.96 220.4,123.96 220.08,123.64 220.05,123.64 218.89,122.48 CC1.2
PEG_CTX_C_GRX_N1: length 29
  BOTTOM w0.089: 238.25,118 238.34,117.91 238.6,117.91 238.69,117.82 238.69,117.65 238.59,117.55 UG9.BL29
  BOTTOM w0.107: 238.25,118 v4(238.25,122.18) 238.25,122.69 237.59,123.36 237.59,123.38 237.53,123.43 237.53,123.44 237.26,123.71 237.23,123.71 236.3,124.65 219.9,124.65 219.62,124.36 219.55,124.36 219.1,123.9 219.1,123.86 218.25,123.02 217.06,123.02 216.71,123.37 CC2.2
PEG_CTX_C_GRX_N2: length 27.5
  BOTTOM w0.089: 238.45,123.5 239.09,122.86 239.09,118.43 UG9.BM30
  BOTTOM w0.107: CC3.2 v4(218.47,125.4) 219.33,125.4 219.4,125.34 236.61,125.34 238.45,123.5
PEG_CTX_C_GRX_N3: length 32.2
  BOTTOM w0.089: UG9.BK30 239.27,117.03 239.63,117.39 239.63,117.86 239.85,118.08 239.85,121.02 239.87,121.05 239.87,121.61 239.85,121.63 v4(239.85,122.61) 239.85,123.12 239.47,123.5
  BOTTOM w0.107: 239.47,123.5 236.94,126.03 219.66,126.03 219.25,126.44 215.59,126.44 CC4.2
PEG_CTX_C_GRX_N4: length 32.4
  BOTTOM w0.089: 240.16,123.5 240.31,123.36 240.31,120.73 240.16,120.58 v4(240.16,120.11) 240.16,118.04 240.28,117.92 240.28,117.25 240.37,117.16 240.5,117.16 240.55,117.22 240.69,117.22 240.78,117.31 240.78,117.44 UG9.BL32
  BOTTOM w0.107: CC5.2 217.14,126.93 217.24,127.03 217.24,127.14 217.37,127.27 217.99,127.27 218.01,127.3 219.09,127.3 219.87,126.52 237.15,126.52 240.16,123.5
PEG_CTX_C_GRX_N5: length 33.2
  BOTTOM w0.089: 241.18,123.5 241.37,123.3 v4(241.37,122.14) UG9.BM33
  BOTTOM w0.107: CC6.2 215.74,128.22 218.66,128.22 218.68,128.25 219.4,128.25 220.2,127.44 237.63,127.44 241.18,123.9 241.18,123.5
PEG_CTX_C_GRX_N6: length 34.8
  BOTTOM w0.089: 241.93,123.5 241.93,123.49 242.02,123.4 242.02,117.94 241.68,117.6 241.68,117.29 241.65,117.26 241.65,117.13 UG9.BK33
  BOTTOM w0.107: CC7.2 v4(218.12,129.38) 219.24,129.38 220.49,128.13 237.92,128.13 241.93,124.12 241.93,123.5
PEG_CTX_C_GRX_N7: length 37.1
  BOTTOM w0.089: 242.62,123.5 242.62,119.98 242.46,119.82 242.46,117.98 242.52,117.92 242.83,117.92 242.96,117.78 242.96,117.66 242.85,117.55 UG9.BL35
  BOTTOM w0.107: 242.62,123.5 242.62,124.47 v4(239.85,127.24) 238.27,128.83 221.86,128.83 221.83,128.85 221.14,128.85 221.12,128.83 220.77,128.83 219.53,130.07 215.9,130.07 215.62,130.36 CC8.2
PEG_CTX_C_GRX_N8: length 5.5
  BOTTOM w0.107: CC9.2 153.56,174.61 153.56,175.39 153.59,175.42 153.59,175.99 153.56,176.02 153.56,177.09 153.74,177.27 153.74,178.49 153.82,178.57 JCDRA.4
PEG_CTX_C_GRX_N9: length 3.6
  BOTTOM w0.099: JCDRA.7 155.02,178.37
  BOTTOM w0.107: 155.02,178.37 154.92,178.27 154.92,177.6 154.79,177.48 154.79,176.88 154.77,176.85 154.77,176.52 CC10.2
PEG_CTX_C_GRX_N10: length 5.5
  BOTTOM w0.099: JCDRA.10 156.22,178.43
  BOTTOM w0.107: 156.22,178.43 156.1,178.31 156.1,177.32 156.13,177.29 156.13,176.72 156.1,176.69 156.1,176.39 155.99,176.28 v4(155.99,175.43) 155.99,174.61 CC11.2
PEG_CTX_C_GRX_N11: length 3.6
  BOTTOM w0.099: JCDRA.13 157.42,178.61
  BOTTOM w0.107: CC12.2 157.44,176.49 v4(157.44,177.16) 157.44,177.88 157.31,178 157.31,178.5 157.42,178.61
PEG_CTX_C_GRX_P0: length 26.8
  BOTTOM w0.089: UG9.BL27 237.17,117.43 237.08,117.34 236.95,117.34 236.86,117.43 236.86,117.68 237.09,117.91 237.31,117.91 237.56,118.17 237.56,118.6 237.38,118.78 v4(237.38,120.97) 237.38,122.07 236.92,122.53 236.88,122.53 236.47,122.94 236.47,122.99 235.96,123.5
  BOTTOM w0.107: CC13.2 218.02,121.91 218.13,122.02 218.13,122.1 218.24,122.21 218.94,122.21 220.48,123.75 235.72,123.75 235.83,123.64 235.83,123.63 235.96,123.5
PEG_CTX_C_GRX_P1: length 29
  BOTTOM w0.089: UG9.BK29 238.26,117.16 238.26,117.66 238.03,117.88 238.03,118.03
  BOTTOM w0.107: CC14.2 216.46,122.8 218.34,122.8 v4(219.52,123.98) 219.98,124.44 236.22,124.44 237.15,123.51 237.17,123.51 237.32,123.37 237.32,123.35 237.37,123.29 237.37,123.27 238.03,122.6 238.03,118.03
PEG_CTX_C_GRX_P2: length 27.6
  BOTTOM w0.089: UG9.BM29 238.89,118.57 v4(238.89,120.15) 238.89,122.77 238.16,123.5
  BOTTOM w0.107: CC15.2 217.62,124.83 217.69,124.9 217.69,125.07 217.81,125.2 218.16,125.2 218.19,125.16 218.78,125.16 218.82,125.2 219.25,125.2 219.32,125.13 236.53,125.13 238.16,123.5
PEG_CTX_C_GRX_P3: length 32.2
  BOTTOM w0.089: UG9.BL30 239.27,117.49 239.17,117.39 239.05,117.39 238.96,117.48 238.96,117.78 239.1,117.93 239.45,117.93 239.67,118.15 v4(239.67,121.34) 239.67,122.32 239.65,122.34 239.65,122.88 239.67,122.9 239.67,123.01 239.19,123.5
  BOTTOM w0.107: CC16.2 215.63,125.91 215.91,125.91 215.97,125.97 215.97,126.15 216.06,126.24 219.17,126.24 219.58,125.82 236.86,125.82 239.19,123.5
PEG_CTX_C_GRX_P4: length 32.5
  BOTTOM w0.089: UG9.BK32 240.98,117.16 240.98,117.68 240.76,117.9 240.58,117.9 240.36,118.12 240.36,120.5 240.51,120.65 240.51,123.44 240.44,123.5
  BOTTOM w0.107: 240.44,123.5 240.44,123.5 240.32,123.63 240.32,123.63 237.23,126.72 219.95,126.72 219.17,127.5 v4(217.7,127.5) CC17.2
PEG_CTX_C_GRX_P5: length 33.2
  BOTTOM w0.089: UG9.BM32 240.82,118.25 241.17,118.6 241.17,123.22 240.97,123.42 240.97,123.5
  BOTTOM w0.107: CC18.2 215.57,127.82 215.76,128.01 v4(218.97,128.01) 219.34,128.01 220.12,127.24 237.54,127.24 240.97,123.81 240.97,123.5
PEG_CTX_C_GRX_P6: length 34.8
  BOTTOM w0.089: 241.73,123.5 241.73,123.48 241.73,123.48 241.73,123.4 241.82,123.32 v4(241.82,120.62) 241.82,118.02 241.65,117.85 241.46,117.85 241.37,117.94 241.25,117.94 241.16,117.85 241.16,117.55 241.25,117.46 241.28,117.46 UG9.BL33
  BOTTOM w0.107: 241.73,123.5 241.73,124.04 237.83,127.93 220.4,127.93 219.16,129.18 218.43,129.18 218.4,129.15 217.83,129.15 217.81,129.18 217.31,129.18 217.21,129.07 217.21,128.81 217.1,128.71 CC19.2
PEG_CTX_C_GRX_P7: length 37.1
  BOTTOM w0.089: 242.42,123.5 242.42,123.48 242.42,123.48 242.42,120.07 242.26,119.9 242.26,117.9 242.43,117.73 242.43,117.36 242.77,117.01 UG9.BK35
  BOTTOM w0.107: CC20.2 215.58,129.87 219.45,129.87 220.69,128.62 v4(221.43,128.62) 238.18,128.62 239.49,127.32 239.49,127.28 239.89,126.87 239.93,126.87 242.42,124.39 242.42,123.5
PEG_CTX_C_GRX_P8: length 5.5
  BOTTOM w0.107: JCDRA.3 153.42,178.58 153.54,178.46 153.54,177.35 153.36,177.18 v4(153.36,175.71) 153.36,174.53 153.08,174.25 CC21.2
PEG_CTX_C_GRX_P9: length 3.6
  BOTTOM w0.107: CC22.2 154.56,176.47 v4(154.56,177.17) 154.56,177.54 154.72,177.69 154.72,178.34 154.62,178.44 JCDRA.6
PEG_CTX_C_GRX_P10: length 5.5
  BOTTOM w0.099: JCDRA.9 155.82,178.39
  BOTTOM w0.107: 155.82,178.39 155.9,178.3 v4(155.9,177) 155.9,176.48 155.79,176.36 155.79,175.74 155.76,175.71 155.76,175.14 155.79,175.11 155.79,174.59 CC23.2
PEG_CTX_C_GRX_P11: length 3.6
  BOTTOM w0.099: JCDRA.12 157.02,178.58
  BOTTOM w0.107: 157.02,178.58 157.11,178.49 157.11,177.92 157.23,177.8 157.23,177.48 157.21,177.45 157.21,176.86 157.23,176.83 157.23,176.63 157.11,176.51 157.11,176.4 CC24.2
PEG_CTX_C_TRX_N12: length 3.1
  TOP w0.089: CT15.2 187.67,161.64 187.03,161.64 186.86,161.82 186.86,162.41 186.6,162.67 185.83,162.67 185.6,162.9 UT1.Y22
PEG_CTX_C_TRX_N13: length 2.6
  TOP w0.089: CT13.2 187.64,163.96 187.15,163.96 186.82,164.28 186.48,164.28 186.24,164.52 185.8,164.52 UT1.T22
PEG_CTX_C_TRX_N14: length 2.5
  TOP w0.089: UT1.M22 185.81,166.81 186.21,166.81 186.56,166.46 186.73,166.46 186.97,166.7 CT18.2
PEG_CTX_C_TRX_N15: length 2.4
  TOP w0.089: CT21.2 187.57,168.98 187.24,168.65 185.81,168.65 UT1.H22
PEG_CTX_C_TRX_P12: length 3.1
  TOP w0.089: CT3.2 187.46,162.12 187.4,162.06 187.4,161.92 187.31,161.83 187.14,161.83 187.05,161.92 187.05,162.49 186.68,162.85 186.5,162.85 186.41,162.94 186.41,163.05 186.34,163.12 186.05,163.12 186,163.07 186,162.94 UT1.Y23
PEG_CTX_C_TRX_P13: length 2.5
  TOP w0.089: UT1.T23 186.14,164.85 186.29,164.85 186.39,164.75 186.39,164.64 186.56,164.48 186.91,164.48 187.23,164.15 187.3,164.15 187.36,164.22 187.36,164.52 187.43,164.59 187.59,164.59 CT1.2
PEG_CTX_C_TRX_P14: length 2.5
  TOP w0.089: UT1.M23 186.04,166.44 186.13,166.35 186.39,166.35 186.47,166.26 186.82,166.26 187.05,166.5 187.26,166.5 187.33,166.43 187.33,166.05 187.39,165.99 187.62,165.99 CT4.2
PEG_CTX_C_TRX_P15: length 2.4
  TOP w0.089: CT5.2 187.48,168.12 187.25,168.12 187.17,168.2 187.17,168.38 187.1,168.45 186.64,168.45 186.38,168.19 186.11,168.19 186.02,168.27 186.02,168.4 UT1.H23
PEG_CTX_GRX_N0: length 63.4
  IN6 w0.089: v2(175.87,100.97) 175.87,100.16 176.47,99.56 178.25,99.56 182.91,104.22 186.72,104.22 187.86,105.36 188.2,105.36 191.26,108.42 194.56,108.42 195.15,109.02 196.28,110.15 198.78,110.15 199.84,111.21 199.84,112.78 200.66,113.6 200.66,114.43 205.06,118.83 205.06,122.29 208.21,125.44 211.65,125.44 212.23,124.87 212.23,124.37 212.54,124.06 212.87,124.06 213.31,123.62 213.31,123.53 v2(213.58,123.27)
  BOTTOM w0.076: v2(175.87,100.97) 175.44,101.4 174.76,101.4 174.25,100.89 173.35,100.89 173.26,100.98 172.31,100.98 172.23,101.05 172.23,101.18 UC1.B10
  BOTTOM w0.107: v2(213.58,123.27) 213.52,123.27 213.36,123.11 213.36,122.97 213.46,122.87 215.02,122.87 215.77,122.13 216.7,122.13 216.73,122.16 216.73,122.42 216.8,122.48 CC1.1
PEG_CTX_GRX_N1: length 62
  IN6 w0.089: v2(214.34,123.24) 214.51,123.41 214.51,123.84 214.17,124.17 213.42,124.17 212.76,124.84 212.76,125 211.84,125.92 208.79,125.92 208.41,126.3 207.94,126.3 204.58,122.95 204.58,119.02 200.19,114.63 200.19,113.81 199.59,113.21 198.4,113.21 194.47,109.28 190.99,109.28 189.49,107.79 189.49,107.32 188.01,105.83 187.67,105.83 187.13,105.3 183.21,105.3 178.32,100.41 177.53,100.41 177.3,100.64 177.3,100.71 v2(177.03,100.98)
  BOTTOM w0.076: UC1.B11 172.46,102.07 172.54,101.99 172.54,101.79 172.75,101.58 173.3,101.58 173.37,101.65 175.37,101.65
  BOTTOM w0.089: v2(214.34,123.24) 214.5,123.4 214.5,123.93 214.6,124.02 ; v2(177.03,100.98) 177.29,101.23 177.29,101.44 177.08,101.65 175.37,101.65 ; CC2.1 215.62,123.37 215.53,123.46 215.53,123.81 215.32,124.02
  BOTTOM w0.107: 214.6,124.02 214.7,124.12 215.22,124.12 215.32,124.02
