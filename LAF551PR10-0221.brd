# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_DTX_P16: length 167.7
  TOP w0.102: 192.07,37.32 192.06,37.32 192.06,37.32 191.99,37.32 191.85,37.45 191.85,37.46 191.52,37.79 191.52,39.44 192.59,40.51 192.59,41.84 191.08,43.36 191.08,44.47 192.55,45.94 195.1,45.94 195.17,45.87 195.18,45.87 ; v2(199.23,47.37) 199.04,47.18 198.44,47.18 197.55,46.28 196.67,46.28 196.45,46.07 196.44,46.07 196.24,45.87 196.24,45.87
  TOP w0.107: 192.07,37.32 193.14,36.25 193.14,36.25 194.57,34.82 194.57,30.5 195.22,29.85 195.78,29.85 195.96,29.67 195.96,29.41 v2(195.82,29.27) ; 195.18,45.87 196.24,45.87
  IN4 w0.127: v2(195.82,29.27) 195.89,29.2 195.88,29.19 195.88,27.58 194.54,26.24 194.54,23.26 194.54,23.26 194.54,23.08 195.42,22.2 195.69,22.2 195.9,22.2 196.16,21.95 196.16,21.31 196.74,20.73 197.46,20.73 198.14,21.41 198.14,23.13 198.31,23.31 198.56,23.31 198.71,23.16 v2(198.71,23.07)
  IN6 w0.102: v2(199.23,47.37) 199.24,47.37 199.41,47.19 199.79,47.19 200.43,47.83 201.75,47.83 203.1,46.47 210.12,46.47 210.77,47.12 213.83,47.12 214.75,46.2 215.24,46.2 215.32,46.28 228.49,46.28 229.59,45.18 232.45,45.18 232.86,45.58 238.72,45.58 240.4,43.91 265.35,43.91 273.57,35.69 277.36,35.69 277.68,35.37 283.36,35.37 283.83,34.9 286.07,34.9 287.9,36.73 294.13,36.73 294.77,36.1 306.69,36.1 308.39,37.79 v2(310.88,37.79)
  BOTTOM w0.089: v2(198.71,23.07) 198.63,23.15 198.46,23.15 198.37,23.06 198.37,22.77 198.69,22.46 198.69,22.28 198.96,22 198.97,22 199.11,22.01 UH1.M40
  BOTTOM w0.107: v2(310.88,37.79) 310.7,37.61 310.34,37.61 310.1,37.37 310.1,36.72 310.4,36.43 310.4,36.06 310.32,35.99 JWLAN.33
PCIE_PRX_DTX_P17: length 155
  IN1 w0.089: v2(197.82,20.55) 198.08,20.29 198.08,20.16 198.48,19.76 200.47,19.76 201.57,18.67 206.4,18.67 206.71,18.97 206.71,19.07 208.68,21.04 209.27,21.04 209.28,21.05 210.07,21.05 210.68,20.44 211.51,20.44 211.96,19.99 211.96,18.9 212.91,17.95 214.33,17.95 214.59,17.69 214.91,17.69 215.05,17.69 215.97,18.6 218.33,18.6 218.62,18.89 219.54,18.89 220.36,18.08 222.55,18.08 222.77,18.3 223.65,18.3 223.98,17.97 225.88,17.97 226.16,17.7 230.74,17.7 231.04,17.4 235.8,17.4 238.28,19.87 239.1,19.87 240.41,21.18 240.41,21.55 240.99,22.13 240.99,23.33 243.82,26.17 245.82,26.17 248.81,29.16 263.96,29.16 264.39,29.58 266.34,29.58 266.99,28.92 277.83,28.92 278.74,28.02 283.03,28.02 284.09,29.07 289.58,29.07 292.77,32.26 294.8,32.26 295.44,32.91 298.33,32.91 298.7,32.54 304.25,32.54 305.19,31.6 309.56,31.6 311.5,33.54 323.45,33.54 325.32,35.41 325.32,36.31 324.94,36.69 324.62,36.69 323.79,37.53 323.79,39.1 324.18,39.49 325.95,39.49 326.61,40.15 327.16,40.15 327.39,39.92 327.39,39.79 v2(327.28,39.68)
  BOTTOM w0.107: UH1.K44 197.97,20.4 v2(197.82,20.55) ; v2(327.28,39.68) 327.35,39.6 327.35,39.45 327.35,39.39 327.27,39.31 327.05,39.31 326.67,39.69 326.67,39.7 326.46,39.91 JSSD1.41
PCIE_PRX_DTX_P18: length 162.1
  IN1 w0.089: v2(329.19,40.83) 328.82,40.83 328.57,40.58 328.57,39.09 327.63,38.15 327.63,36.14 323.84,32.35 311.94,32.35 309.21,29.62 305.15,29.62 303.39,31.38 300.12,31.38 299.68,30.93 299.68,30.66 299.23,30.21 292.3,30.21 290.04,27.95 284.71,27.95 283.5,26.74 278.38,26.74 277.31,27.81 265.75,27.81 265.05,27.11 257.58,27.11 257.29,26.81 248.05,26.81 246.28,25.05 245.16,25.05 242.57,22.46 242.57,21.85 241.52,20.8 241.52,20.71 239.56,18.75 238.74,18.75 236.27,16.28 231.34,16.28 230.87,15.82 221.62,15.82 221.3,16.14 219.97,16.14 219.66,15.84 218.74,15.84 218.44,16.14 216.35,16.14 216.23,16.25 214.81,16.25 214.43,15.87 212.62,15.87 211.99,16.51 211.85,16.51 211.45,16.91 208.61,16.91 207.76,16.06 203.44,16.06 203,15.62 200.91,15.62 200.58,15.95 198.82,15.95 197.9,16.88 197.9,18.91 196.95,19.86 196.95,20.76 197.83,21.64 200.44,21.64 v2(200.56,21.77)
  BOTTOM w0.107: JSSD1.31 326.56,42.41 326.72,42.56 327.9,42.56 328.28,42.18 328.28,41.47 328.74,41.01 329.01,41.01 v2(329.19,40.83) ; v2(200.56,21.77) 200.56,22.07 UH1.R40
PCIE_PRX_DTX_P19: length 160.9
  IN1 w0.089: v2(200.14,17.37) 200.01,17.37 199.92,17.28 199.92,17.22 199.78,17.08 199.78,16.95 199.94,16.79 200.76,16.79 201.14,16.42 201.47,16.42 201.94,16.89 206.09,16.89 206.83,17.62 206.83,18.15 207.44,18.76 208.74,18.76 209.06,19.08 209.65,19.08 210.26,19.69 210.95,19.69 211.25,19.38 211.25,19.37 211.6,19.02 211.6,18.58 212.63,17.55 212.8,17.55 214.19,17.55 214.49,17.25 215.85,17.25 216.77,18.17 218.49,18.17 218.66,18 219.35,18 219.67,17.69 222.71,17.69 222.86,17.83 223.56,17.83 224.86,16.54 230.57,16.54 231.04,17 235.97,17 238.44,19.48 239.26,19.48 240.8,21.01 240.8,21.39 241.38,21.97 241.38,23.17 243.98,25.77 245.98,25.77 247.75,27.54 251.35,27.54 251.44,27.63 251.68,27.63 252.25,28.2 257.34,28.2 257.56,27.98 259.87,27.98 260.26,28.37 264.4,28.37 264.47,28.3 265.22,28.3 265.45,28.53 277.61,28.53 278.68,27.46 283.05,27.46 284.26,28.67 289.74,28.67 292.82,31.75 299.05,31.75 299.4,32.1 303.69,32.1 305.38,30.41 308.92,30.41 311.59,33.07 323.54,33.07 325.73,35.26 325.73,37.05 324.72,38.06 324.57,38.06 v2(324.25,37.74)
  BOTTOM w0.089: v2(200.14,17.37) 199.95,17.56 199.95,17.75 199.78,17.93 199.41,17.93 199.41,17.93 199.39,17.93 199.27,18.05 199.27,18.17 199.26,18.19 199.26,18.57 199.24,18.59 199.24,18.84 199.38,18.98 199.4,18.98
  BOTTOM w0.107: 199.4,18.98 199.83,19.4 199.83,19.45 200.04,19.66 200.04,20.24 199.83,20.45 199.71,20.45 199.6,20.56 UH1.N42 ; v2(324.25,37.74) 324.53,38.02 324.65,38.02 324.88,38.25 324.88,39.24 324.87,39.25 324.87,39.3 324.05,40.12 324.05,45.21 324.39,45.55 324.39,45.55 324.48,45.63 325.01,45.63 325.24,45.41 JSSD1.19
PCIE_PRX_DTX_P20: length 168.4
  IN1 w0.089: v2(200.17,23.72) 200.17,23.93 200.26,24.02 202.13,24.02 203.5,22.64 204.16,22.37 206.52,22.37 208.04,22.37 208.33,22.66 208.33,22.95 209.5,24.12 210.42,24.12 210.84,23.7 212.03,23.7 213.3,22.43 214.51,22.43 215.11,21.83 215.11,21.03 217.01,19.13 218.03,19.13 218.36,19.46 218.36,19.83 218.61,20.09 218.82,20.09 219.05,19.86 220.98,19.86 221.86,20.74 222.84,20.74 223.78,19.8 224.75,19.8 225.11,19.45 225.77,19.45 226.56,18.66 231.15,18.66 231.37,18.44 234,18.44 234.03,18.41 236.03,18.41 238.05,20.43 238.87,20.43 239.85,21.41 239.85,21.8 240.43,22.38 240.43,23.57 243.58,26.72 245.59,26.72 249.26,30.4 271.01,30.4 271.2,30.21 277.54,30.21 278.28,29.46 280.65,29.46 281.17,29.98 289.7,29.98 292.54,32.82 294.57,32.82 295.21,33.47 299.01,33.47 299.21,33.67 304.03,33.67 305.54,32.16 309.32,32.16 311.27,34.1 323.19,34.1 323.92,34.83 323.92,35.19 v2(324.13,35.4)
  IN6 w0.089: v2(320.18,47.49) 319.97,47.7 319.97,47.96 319.78,48.15 319.12,48.15 318.93,47.96 318.93,47.35 319.36,46.92 320.89,46.92 321.2,46.61 322.3,46.61 323.99,44.92 323.99,44.9 325.23,43.66 325.23,35.63 324.43,34.82 324.01,34.82 323.92,34.91 323.92,35.19 v2(324.13,35.4)
  BOTTOM w0.107: JSSD1.7 325.23,48.41 325.08,48.55 320.37,48.55 319.97,48.15 319.97,47.69 v2(320.18,47.49) ; UH1.R37 v2(200.17,23.72)
PCIE_PRX_DTX_P21: length 79.8
  IN3 w0.127: v2(201.82,19.54) 201.5,19.86 201.32,19.86 201.15,19.69 201.15,19.37 201.61,18.91 202.25,18.91 202.63,18.53 203.02,18.53 204.36,17.19 206.57,17.19 209.56,14.2 211.03,14.2 211.17,14.06 215.55,14.06 215.86,13.74 219.25,13.74 219.67,13.33 221.88,13.33 222.29,12.91 230.92,12.91 231.73,12.1 238.97,12.1 239.8,12.93 240.55,13.67 251.66,13.67 252.09,14.1 259.43,14.1 260.2,14.88 264.83,14.88 265.5,15.55 269.28,15.55 269.69,15.13 269.69,14.84 v2(269.92,14.61)
  BOTTOM w0.107: v2(201.82,19.54) 201.23,20.13 201.23,20.2 201.08,20.29 200.93,20.25 UH1.R44 ; v2(269.92,14.61) 269.54,14.99 269.54,15.14 270.25,15.85 270.91,15.85 271.21,15.56 JSSD2.43
PCIE_PRX_DTX_P22: length 78.7
  IN3 w0.127: v2(201.94,21.01) 202.09,21.16 202.23,21.16 202.35,21.11 202.58,20.88 202.58,20.38 202.29,20.08 202.29,19.46 202.61,19.14 203.12,19.14 203.63,18.63 204.26,18.63 204.45,18.44 206.15,18.44 206.89,17.7 206.89,17.48 209.74,14.63 214.79,14.63 214.88,14.54 215.68,14.54 216.04,14.18 219.43,14.18 219.75,13.86 221.99,13.86 222.51,13.34 231.1,13.34 231.91,12.53 237.87,12.53 238.7,13.36 239.62,13.36 240.37,14.1 249.26,14.1 250.68,15.52 258.55,15.52 260.27,17.23 269.57,17.23 269.82,17.49 269.82,17.94 v2(269.99,18.1)
  BOTTOM w0.107: v2(201.94,21.01) 201.88,21.07 UH1.U41 ; JSSD2.31 271.19,18.56 271.09,18.66 270.12,18.66 269.83,18.36 269.83,18.26 v2(269.99,18.1)
PCIE_PRX_DTX_P23: length 77.5
  IN3 w0.127: v2(270.11,20.98) 269.97,20.84 269.98,20.84 269.98,20.47 269.46,19.96 266.54,19.96 265.6,19.02 262.11,19.02 261.07,17.97 248.93,17.97 248.83,17.87 245.98,17.87 245.5,17.39 242.64,17.39 240.29,15.04 239.46,15.04 237.72,13.3 232.06,13.3 231.37,13.99 222.81,13.99 222.29,14.51 220.02,14.51 219.6,14.92 218.83,14.92 218.06,15.7 212.81,15.7 212.57,15.46 210.49,15.46 209.81,16.14 209.81,16.25 207.15,18.92 207.15,19.29 206.26,20.18 205.37,20.18 204.83,19.65 203.52,19.65 203.38,19.79 v2(203.38,19.99)
  BOTTOM w0.107: v2(270.11,20.98) 270.11,21.52 270.25,21.66 271.14,21.66 271.24,21.56 JSSD2.19 ; UH1.W44 202.53,20.17 202.66,20.25 202.67,20.24 203.13,20.24 v2(203.38,19.99)
PCIE_PRX_DTX_P24: length 83
  IN3 w0.127: v2(269.48,25.23) 269.63,25.09 269.63,25.07 269.67,25.03 269.67,24.78 267.61,22.73 266.06,22.73 265.43,22.09 259.11,22.09 256.52,24.67 256.52,24.76 256.52,25.17 256,25.69 252.82,25.69 252.24,25.11 249.88,25.11 248.5,23.74 247.94,23.18 245.51,23.18 244.57,22.24 244.57,21.61 244.33,21.36 243.63,21.36 239.95,17.68 239.95,16.76 238.35,15.16 237.5,15.16 236.75,14.42 232.66,14.42 231.85,15.23 222.8,15.23 222.65,15.38 222.11,15.38 221.64,15.84 219.24,15.84 218.51,16.56 213.81,16.56 211.84,18.53 210.74,18.53 210.47,18.81 209.94,18.81 209,19.75 208.29,19.75 208.11,19.75 208.11,19.75 206.41,21.45 205.85,21.45 205.65,21.64 203.67,21.64 203.45,21.43 203.45,21.17 v2(203.27,21)
  BOTTOM w0.089: UH1.Y41 202.92,21.68 203.02,21.74 ; 203.45,21.17 v2(203.27,21)
  BOTTOM w0.102: JSSD2.7 269.89,24.56 269.66,24.79 269.66,25.06 v2(269.48,25.23)
  BOTTOM w0.107: 203.02,21.74 203.14,21.71 203.45,21.41 203.45,21.17
PCIE_PTX_C_DRX_N9: length 3.3
  TOP w0.107: v2(250.64,12.86) 250.4,12.63 250.4,12.4 CH202.1
  BOTTOM w0.107: v2(250.64,12.86) 250.57,12.92 250.57,13.22 250.74,13.39 251.15,13.39 251.38,13.61 251.38,13.93 251.53,14.08 JSSD3.11
PCIE_PTX_C_DRX_N10: length 86.1
  IN2 w0.076: v2(185.92,14.26) 186.13,14.05 186.13,13.71 186.7,13.14 186.82,13.14 188.22,11.73 188.22,11.29 189.46,10.06 189.46,9.67 190.12,9.01 198.08,9.01 198.89,9.83 200.3,9.83 200.88,10.41 215.97,10.41 217.72,12.16 247.83,12.16 248.1,12.44 248.1,12.74 v2(248.28,12.92)
  IN6 w0.089: v2(188.03,27.77) 188.03,26.77 186.85,25.59 186.85,19.17 185.71,18.03 185.71,16.24 185.92,16.03 v2(185.92,14.26)
  BOTTOM w0.107: v2(188.03,27.77) 188.03,26.56 188.51,26.09 CH204.1 ; v2(248.28,12.92) 248.28,13.38 248.53,13.62 JSSD3.23
PCIE_PTX_C_DRX_N11: length 71.4
  IN1 w0.089: v2(237.23,16.44) 237.23,15.51 237.14,15.42 221.35,15.42 221.03,15.74 220.13,15.74 219.83,15.44 218.58,15.44 218.28,15.74 216.18,15.74 216.07,15.86 214.97,15.86 214.47,15.36 208.99,15.36 208.45,14.82 204.75,14.82 204.65,14.92 203.76,14.92 203.45,15.22 202.43,15.22 201.72,14.51 201.37,14.51 201.16,14.72 201.16,14.82 200.41,15.56 198.66,15.56 197.43,16.79 197.43,18.72 196.6,19.55 196.6,21.59 193.85,24.35 190.67,24.35 v2(190.45,24.58)
  BOTTOM w0.107: JSSD3.35 245.53,13.58 245.32,13.38 244.72,13.38 244.61,13.27 244.61,11.72 244.07,11.17 240.09,11.17 238.26,13.01 238.26,15.08 237.66,15.68 237.56,15.68 237.31,15.93 237.31,16.36 v2(237.23,16.44) ; CH207.2 190.86,24.38 190.64,24.38 v2(190.45,24.58)
PCIE_PTX_C_DRX_N12: length 3.2
  TOP w0.107: CH209.2 241.56,12.35 241.52,12.35 241.42,12.45 241.42,12.68 v2(241.61,12.88)
  BOTTOM w0.107: JSSD3.47 242.53,14.13 241.78,13.39 241.68,13.39 241.48,13.18 241.48,13.03 241.63,12.88 v2(241.61,12.88)
PCIE_PTX_C_DRX_N15: length 1.9
  BOTTOM w0.107: CL4.1 272.4,167.39 272.4,166.57 272.6,166.38 272.6,165.99 UL1.36
PCIE_PTX_C_DRX_N16: length 11.4
  TOP w0.107: CN24.1 314.73,38.87 315,38.87 v2(315.34,38.54)
  BOTTOM w0.107: JWLAN.29 309.32,35.99 309.08,36.23 309.08,37.66 311.12,39.71 312.71,39.71 313.57,38.84 315.09,38.84 315.1,38.82 315.25,38.82 315.34,38.73 v2(315.34,38.54)
PCIE_PTX_C_DRX_N17: length 184.2
  IN6 w0.089: v2(328.37,37.53) 328.1,37.27 328.1,37.25 327.97,37.11 327.85,37.11 327.12,36.38 327.12,34.15 327.56,33.71 327.56,23.36 325.73,21.52 325.73,19.49 324.93,18.7 324.49,18.7 323.86,18.07 323.86,17.19 320.58,13.9 319.57,13.9 317.25,11.59 312.37,11.59 312.15,11.8 305.03,11.8 302.2,14.63 297.32,14.63 297.29,14.66 290.79,14.66 289.97,15.47 289.94,15.47 289.93,15.48 282.03,15.48 280.94,14.39 275.65,14.39 274.83,15.21 271.83,15.21 270.63,14.01 256.54,14.01 254.3,11.77 254.29,11.77 251.15,8.63 240.14,8.63 237.11,11.66 232.87,11.66 231.74,10.53 229.32,10.53 228.63,9.83 227.84,9.83 226.88,9.83 226.22,9.83 225.86,9.47 207.29,9.47 206.55,10.21 201.18,10.21 199.91,8.95 194.78,8.95 191.37,12.35 189.52,12.35 188.46,13.41 188.46,14.33 187.97,14.82 187.97,15.71 188.06,15.8 188.55,15.8 188.7,15.65 188.7,15.53 v2(188.43,15.26)
  BOTTOM w0.107: v2(188.43,15.26) 188.43,15.26 188.43,15.26 188.81,15.63 188.81,15.82 188.43,16.2 188.43,16.64 188.23,16.84 188.23,17.21 188.05,17.39 188.05,18.67 189.22,19.84 189.81,19.84 CH210.1 ; v2(328.37,37.53) 327.99,37.15 327.82,37.15 327.61,37.36 327.61,37.71 327.29,38.03 327.08,38.03 326.88,38.22 326.65,38.22 326.46,38.41 JSSD1.47
PCIE_PTX_C_DRX_N18: length 194.4
  IN6 w0.089: v2(329.64,38.23) 329.39,37.99 329.39,37.97 329.24,37.81 329.09,37.81 328.9,37.63 328.9,36.7 328.52,36.32 328.52,33.7 328.9,33.32 328.9,22.92 327.57,21.59 327.57,18.86 327.48,18.77 326.19,18.77 325.12,17.69 325.12,16.58 324.63,16.09 323.56,16.09 320.81,13.34 319.83,13.34 317.38,10.89 311.99,10.89 311.67,11.2 304.83,11.2 301.97,14.07 297.09,14.07 297.06,14.1 290.55,14.1 289.74,14.91 282.58,14.91 281.5,13.83 271.53,13.83 271.15,13.45 257.31,13.45 254.9,11.04 254.35,11.04 251.38,8.07 239.91,8.07 236.88,11.1 233.1,11.1 231.97,9.97 229.56,9.97 228.79,9.2 227.09,9.2 226.37,8.49 225.95,8.49 225.53,8.92 206.92,8.92 206.18,9.66 201.57,9.66 200.3,8.39 194.54,8.39 193.19,9.74 191.36,9.74 190.38,10.72 189.35,10.72 187.06,13.01 186.32,13.01 185,14.33 185,14.86 185.2,15.07 185.2,18.82 v2(185.62,19.24)
  BOTTOM w0.107: CH212.1 188.69,21.39 188.48,21.39 187.89,20.81 v4(187.51,20.81) 186.23,20.81 185.24,19.81 185.24,19.62 v2(185.62,19.24) ; v2(329.64,38.23) 329.56,38.15 329.55,38.15 329.3,37.91 329.09,37.91 328.75,38.25 328.75,40.4 327.87,41.27 327.66,41.27 326.9,41.27 326.67,41.27 326.54,41.41 JSSD1.35
PCIE_PTX_C_DRX_N19: length 188.8
  IN6 w0.089: v2(188.67,17.71) 188.88,17.92 189.07,17.92 189.08,17.92 189.3,17.92 189.41,17.81 189.41,14.19 190,13.61 190.67,13.61 193.59,10.68 194.45,10.68 195.79,9.34 199.71,9.34 200.99,10.62 206.7,10.62 207.45,9.87 225.7,9.87 226.09,10.26 227.07,10.26 227.18,10.26 227.37,10.26 227.43,10.26 227.84,10.26 228.49,10.26 229.16,10.92 231.58,10.92 232.7,12.05 237.27,12.05 240.31,9.02 250.98,9.02 252.46,10.5 252.46,12.94 254.3,14.78 265.38,14.78 266.26,15.66 275.25,15.66 276.1,14.81 280.7,14.81 281.82,15.93 290.39,15.93 291.08,15.24 296.61,15.24 296.8,15.05 297.46,15.05 297.48,15.02 302.6,15.02 305.32,12.31 315.08,12.31 315.52,12.75 316.32,12.75 316.68,12.4 317.39,12.4 319.29,14.3 320.19,14.3 321.29,15.4 321.29,16.79 322.59,18.09 322.84,18.09 324.37,19.61 324.87,19.61 325.33,20.07 325.33,21.69 327.17,23.52 327.17,30.19 326.65,30.7 326.65,37.01 328.75,39.11 329.36,39.11 v2(329.38,39.08)
  BOTTOM w0.107: JSSD1.23 326.37,44.41 326.53,44.25 326.77,44.25 326.86,44.15 327.2,44.15 327.91,43.44 329.28,43.44 329.89,42.82 329.89,41.52 330.27,41.14 330.27,39.49 329.93,39.15 329.45,39.15 v2(329.38,39.08) ; CH214.2 190.03,18.34 189.68,18.34 189.58,18.24 189.58,18.17 189.18,17.77 188.73,17.77 v2(188.67,17.71)
PCIE_PTX_C_DRX_N20: length 190.4
  IN6 w0.089: v2(322.02,47.81) 321.69,47.48 321.53,47.48 321.45,47.57 321.45,48.23 321.55,48.33 324.41,48.33 324.42,48.31 324.43,48.31 325.89,46.85 325.89,30.31 325.89,30.31 325.89,30.17 326.44,29.62 326.44,23.82 324.84,22.22 324.32,22.22 323.48,21.38 323.48,19.87 322.46,18.85 322.29,18.85 320.52,17.08 320.52,15.68 319.86,15.02 318.95,15.02 317.55,13.62 315.22,13.62 314.67,13.07 305.7,13.07 303,15.78 299.02,15.78 297.99,16.81 295.48,16.81 295.4,16.73 275.78,16.73 275.72,16.79 275.5,16.79 274.58,17.71 274.47,17.71 274.15,18.02 271.98,18.02 271.57,17.62 267.72,17.62 267.11,17.01 260.17,17.01 259.07,15.91 254.3,15.91 253.83,15.91 251.33,13.41 251.33,12.04 251.16,11.88 240.64,11.88 238.17,14.35 231.75,14.35 231.07,13.66 222.03,13.66 221.32,12.95 216,12.95 215.52,12.46 210.25,12.46 209.69,13.03 208.17,13.03 207.37,13.82 205.17,13.82 204.67,14.32 203.72,14.32 203.4,14.01 201.9,14.01 201.47,14.43 201.47,14.43 201.11,14.8 201.11,14.8 200.52,15.38 200.06,15.38 200.06,15.38 197.89,15.38 196.61,16.67 195.11,16.67 194.83,16.39 194.83,16.18 v2(194.51,15.88)
  BOTTOM w0.107: CH216.2 189.96,17.42 189.86,17.31 189.5,17.31 189.27,17.09 189.27,16.47 189.63,16.11 191.92,16.11 192.22,15.8 193.4,15.8 194.04,16.44 194.66,16.44 194.8,16.31 194.8,16.16 v2(194.51,15.88) ; v2(322.02,47.81) 322.2,47.63 322.74,47.63 323.51,46.85 324.05,46.85 324.43,47.23 325.18,47.23 325.35,47.41 JSSD1.11
PCIE_PTX_C_DRX_N21: length 7
  BOTTOM w0.107: CH218.1 267.55,16.53 267.55,16.2 267.71,16.04 267.75,16.04 268.15,15.64 268.15,15.6 268.33,15.42 268.33,14.23 268.47,14.1 v4(268.72,14.1) 270.49,14.1 270.64,14.26 270.96,14.26 271.25,14.56 JSSD2.47
PCIE_PTX_C_DRX_N22: length 2.4
  BOTTOM w0.107: CH220.1 269.86,17.32 271.02,17.32 271.25,17.56 JSSD2.35
PCIE_PTX_C_DRX_N23: length 86.5
  IN2 w0.076: v2(197.61,14.22) 197.39,13.99 197.39,13.27 197.74,12.92 215.97,12.92 216.81,13.77 239.61,13.77 240.36,14.51 251.38,14.51 252.59,15.73 259.55,15.73 260.74,16.92 269.5,16.92 270.01,17.43 271.78,17.43 272.29,17.93 273.76,17.93 273.98,17.71 273.98,17.44 v2(274.25,17.17)
  BOTTOM w0.107: CH222.1 197.49,14.75 197.49,14.68 197.47,14.65 197.47,14.36 v2(197.61,14.22) ; v2(274.25,17.17) 274.24,17.19 274.24,17.87 273.38,18.73 273.38,20.33 273.15,20.56 JSSD2.23
PCIE_PTX_C_DRX_N24: length 90.2
  IN2 w0.076: v2(198.21,14.23) 198.39,14.42 198.39,14.64 198.61,14.85 200.4,14.85 201.24,14.01 203.05,14.01 203.64,14.6 208.49,14.6 208.49,14.6 213.99,14.6 214.23,14.35 239.33,14.35 240.1,15.13 250.34,15.13 251.22,16.01 251.22,16.72 252.53,18.03 262.37,18.03 264.41,20.06 269.38,20.06 269.52,20.06 270.85,18.73 273.76,18.73 273.76,18.73 273.9,18.73 274.41,18.22 274.76,18.22 274.89,18.35 v2(274.89,18.72)
  BOTTOM w0.107: v2(198.21,14.23) 198.37,14.39 198.37,14.7 CH224.1 ; v2(274.89,18.72) 275.02,18.59 275.02,18.44 274.86,18.27 274.71,18.27 273.99,18.98 273.99,20.94 273.53,21.4 273.53,22.76 273.03,23.26 272.78,23.26 272.48,23.56 JSSD2.11
PCIE_PTX_C_DRX_P9: length 3.4
  TOP w0.107: v2(250.05,12.86) 250.2,12.72 250.2,12.41 CH203.1
  BOTTOM w0.107: JSSD3.13 251.02,14.02 251.17,13.88 251.17,13.7 251.07,13.59 250.66,13.59 250.37,13.3 250.37,13.18 v2(250.05,12.86)
PCIE_PTX_C_DRX_P10: length 86.2
  IN2 w0.076: v2(186.5,14.26) 186.29,14.05 186.29,13.77 186.77,13.3 186.88,13.3 188.39,11.8 188.39,11.36 189.62,10.12 189.62,9.74 190.19,9.18 198.01,9.18 198.83,9.99 200.23,9.99 200.81,10.57 215.9,10.57 217.65,12.33 247.76,12.33 247.94,12.5 247.94,12.67 v2(247.7,12.92)
  IN6 w0.089: v2(188.62,27.77) 188.2,27.35 188.2,26.7 187.02,25.52 187.02,19.1 185.87,17.96 185.87,16.31 186.08,16.1 186.08,14.68 v2(186.5,14.26)
  BOTTOM w0.107: JSSD3.25 248.02,14.1 248.32,13.81 248.32,13.7 248.08,13.46 248.08,13.3 v2(247.7,12.92) ; CH205.1 189.11,26.66 188.74,26.29 188.59,26.29 188.24,26.65 188.24,27.38 v2(188.62,27.77)
PCIE_PTX_C_DRX_P11: length 71.4
  IN1 w0.089: v2(237.82,16.44) 237.6,16.22 237.58,16.22 237.4,16.04 237.4,15.44 237.21,15.26 221.28,15.26 220.96,15.58 220.2,15.58 219.9,15.28 218.51,15.28 218.21,15.58 216.12,15.58 216,15.69 215.04,15.69 214.54,15.19 209.06,15.19 208.52,14.66 204.68,14.66 204.59,14.75 203.69,14.75 203.38,15.06 202.5,15.06 201.79,14.35 201.3,14.35 200.99,14.65 200.99,14.75 200.35,15.4 198.59,15.4 197.27,16.72 197.27,18.65 196.44,19.48 196.44,21.52 193.78,24.18 190.64,24.18 v2(190.45,23.99)
  BOTTOM w0.107: CH206.2 190.86,24.18 190.63,24.18 v2(190.45,23.99) ; v2(237.82,16.44) 237.51,16.13 237.51,16.01 237.64,15.88 237.75,15.88 238.46,15.17 238.46,13.09 240.18,11.38 243.98,11.38 244.41,11.8 244.41,13.35 244.63,13.58 245.24,13.58 245.32,13.66 245.32,13.84 245.26,13.9 245.12,13.9 245.02,13.99 JSSD3.37
PCIE_PTX_C_DRX_P12: length 3.1
  TOP w0.107: v2(241.03,12.88) 241.21,12.7 241.21,12.45 241.05,12.3 CH208.2
  BOTTOM w0.107: v2(241.03,12.88) 241.09,12.88 241.22,13.01 241.22,13.22 241.6,13.59 241.7,13.59 242.02,13.92 JSSD3.49
PCIE_PTX_C_DRX_P15: length 1.9
  BOTTOM w0.107: UL1.35 272.2,167.28 CL3.1
PCIE_PTX_C_DRX_P16: length 11.4
  TOP w0.107: CN23.1 314.32,39.37 314.59,39.11 315.15,39.11 v2(315.27,39.23)
  BOTTOM w0.107: v2(315.27,39.23) 315.08,39.04 313.7,39.04 312.8,39.94 311.1,39.94 311.07,39.91 311.04,39.91 308.88,37.75 308.88,36.19 308.82,36.14 JWLAN.27
PCIE_PTX_C_DRX_P17: length 184.1
  IN6 w0.089: v2(189.01,15.26) 188.86,15.4 188.86,15.72 188.62,15.97 187.99,15.97 187.8,15.78 187.8,14.75 188.29,14.26 188.29,13.34 189.45,12.18 191.31,12.18 194.71,8.78 199.98,8.78 201.25,10.05 206.48,10.05 207.22,9.31 225.93,9.31 226.29,9.67 226.88,9.67 227.84,9.67 228.7,9.67 229.39,10.37 231.81,10.37 232.94,11.49 237.04,11.49 240.07,8.46 251.22,8.46 254.36,11.6 254.37,11.6 256.61,13.85 270.7,13.85 271.9,15.05 274.77,15.05 275.59,14.23 281.01,14.23 282.1,15.32 289.86,15.32 289.87,15.31 289.9,15.31 290.72,14.49 297.22,14.49 297.25,14.47 302.13,14.47 304.96,11.64 312.09,11.64 312.3,11.42 317.32,11.42 319.64,13.74 320.65,13.74 324.02,17.12 324.02,18 324.56,18.53 325,18.53 325.89,19.42 325.89,21.45 327.73,23.29 327.73,33.78 327.29,34.22 327.29,36.31 327.92,36.95 v2(328.37,36.95)
  BOTTOM w0.107: v2(328.37,36.95) 327.73,36.95 327.4,37.28 327.4,37.63 327.2,37.82 326.99,37.82 326.8,38.02 326.65,38.02 326.53,37.91 JSSD1.49 ; CH211.1 189.75,19.63 189.3,19.63 188.25,18.58 188.25,17.48 188.43,17.3 188.43,16.93 188.63,16.73 188.63,16.28 189.01,15.9 v2(189.01,15.26)
PCIE_PTX_C_DRX_P18: length 194.4
  IN6 w0.089: v2(329.64,37.65) 329.15,37.65 329.07,37.56 329.07,36.63 328.68,36.25 328.68,33.77 329.07,33.39 329.07,22.85 327.73,21.52 327.73,18.79 327.55,18.6 326.26,18.6 325.28,17.63 325.28,16.51 324.7,15.93 323.63,15.93 320.88,13.18 319.9,13.18 317.45,10.72 311.92,10.72 311.6,11.04 304.77,11.04 301.9,13.91 297.02,13.91 296.99,13.93 290.48,13.93 289.67,14.75 282.65,14.75 281.57,13.67 271.6,13.67 271.22,13.29 257.38,13.29 254.97,10.87 254.42,10.87 251.45,7.9 239.84,7.9 236.81,10.93 233.17,10.93 232.04,9.81 229.62,9.81 228.86,9.04 227.15,9.04 226.44,8.33 225.88,8.33 225.46,8.75 206.85,8.75 206.11,9.49 201.64,9.49 200.37,8.22 194.48,8.22 193.12,9.58 191.29,9.58 190.31,10.56 189.28,10.56 186.99,12.84 186.25,12.84 184.83,14.26 184.83,14.93 185.04,15.14 v2(185.04,19.24)
  BOTTOM w0.107: v2(185.04,19.24) 185.04,19.89 186.15,21.01 187.2,21.01 187.23,21.04 187.84,21.04 188.39,21.59 188.71,21.59 CH213.1 ; v2(329.64,37.65) 329.57,37.71 329,37.71 328.55,38.17 328.55,40.31 327.79,41.07 327.59,41.07 326.9,41.07 326.73,41.07 326.57,40.91 JSSD1.37
PCIE_PTX_C_DRX_P19: length 188.7
  IN6 w0.089: v2(188.67,18.29) 188.88,18.08 189,18.08 189.01,18.09 189.37,18.09 189.58,17.88 189.58,14.26 190.06,13.77 190.74,13.77 193.66,10.85 194.51,10.85 195.86,9.5 199.64,9.5 200.92,10.79 206.76,10.79 207.52,10.03 225.63,10.03 226.02,10.42 227,10.42 227.01,10.42 227.18,10.42 227.37,10.42 227.43,10.42 227.84,10.42 228.43,10.42 229.09,11.09 231.51,11.09 232.64,12.22 237.34,12.22 240.37,9.19 250.92,9.19 252.29,10.56 252.29,13.01 254.23,14.94 265.31,14.94 266.2,15.83 275.32,15.83 276.17,14.98 280.64,14.98 281.75,16.09 290.46,16.09 291.15,15.41 296.67,15.41 296.87,15.22 297.53,15.22 297.55,15.19 302.67,15.19 305.39,12.47 315.01,12.47 315.45,12.92 316.39,12.92 316.75,12.56 317.32,12.56 319.22,14.46 320.13,14.46 321.13,15.46 321.13,16.86 322.52,18.25 322.77,18.25 324.3,19.78 324.81,19.78 325.17,20.14 325.17,21.75 327,23.59 327,30.12 326.49,30.64 326.49,37.08 328.68,39.27 329.01,39.27 329.22,39.48 329.31,39.48 329.38,39.55 v2(329.38,39.69)
  BOTTOM w0.107: JSSD1.25 326.37,43.91 326.49,44.03 326.7,44.03 326.78,43.95 327.11,43.95 327.83,43.23 329.19,43.23 329.69,42.74 329.69,41.44 330.07,41.05 330.07,39.57 329.85,39.35 329.69,39.35 329.55,39.49 329.51,39.49 329.38,39.61 v2(329.38,39.69) ; CH215.2 189.88,18.64 189.82,18.64 189.73,18.55 189.6,18.55 189.37,18.32 189.37,18.26 189.09,17.97 188.98,17.97 v2(188.67,18.29)
PCIE_PTX_C_DRX_P20: length 190.4
  IN6 w0.089: v2(322.02,47.22) 321.93,47.31 321.47,47.31 321.28,47.5 321.28,48.29 321.49,48.5 324.47,48.5 324.49,48.48 324.5,48.48 326.06,46.92 326.06,30.24 326.61,29.69 326.61,23.75 324.91,22.05 324.77,22.05 324.39,22.06 323.64,21.31 323.64,19.8 322.53,18.69 322.36,18.69 320.68,17.01 320.68,15.61 319.93,14.86 319.02,14.86 317.62,13.45 315.29,13.45 314.74,12.91 305.63,12.91 302.93,15.61 298.95,15.61 297.92,16.64 295.54,16.64 295.47,16.56 275.71,16.56 275.65,16.63 275.43,16.63 274.51,17.54 274.4,17.54 274.08,17.86 272.05,17.86 271.64,17.45 267.79,17.45 267.18,16.84 260.24,16.84 259.14,15.74 254.23,15.74 254.23,15.75 253.9,15.75 251.49,13.34 251.49,11.97 251.23,11.71 240.57,11.71 238.1,14.18 231.82,14.18 231.14,13.5 222.1,13.5 221.39,12.79 216.07,12.79 215.59,12.3 210.18,12.3 209.62,12.86 208.1,12.86 207.3,13.66 205.1,13.66 204.6,14.16 203.79,14.16 203.47,13.84 201.83,13.84 201.41,14.27 201.4,14.27 200.94,14.73 200.94,14.73 200.46,15.22 200.13,15.22 197.82,15.22 196.54,16.5 195.18,16.5 194.99,16.31 194.99,15.98 v2(195.1,15.87)
  BOTTOM w0.107: CH217.2 189.74,17.11 189.58,17.11 189.48,17 189.48,16.55 189.72,16.31 192,16.31 192.31,16.01 193.32,16.01 193.96,16.65 194.75,16.65 195,16.39 195,15.96 v2(195.1,15.87) ; v2(322.02,47.22) 322.22,47.43 322.65,47.43 323.43,46.65 324.13,46.65 324.51,47.03 325.14,47.03 325.27,46.91 JSSD1.13
PCIE_PTX_C_DRX_P21: length 7
  BOTTOM w0.107: JSSD2.49 270.73,14.06 270.57,13.9 269.03,13.9 269,13.87 268.41,13.87 268.13,14.15 268.13,15.33 v4(267.79,15.68) 267.34,16.12 267.34,16.91 CH219.1
PCIE_PTX_C_DRX_P22: length 2.3
  BOTTOM w0.107: CH221.1 269.84,17.12 271.11,17.12 271.17,17.06 JSSD2.37
PCIE_PTX_C_DRX_P23: length 86.5
  IN2 w0.076: v2(273.67,17.18) 273.82,17.33 273.82,17.64 273.69,17.77 272.36,17.77 271.85,17.26 270.07,17.26 269.57,16.75 260.8,16.75 259.62,15.57 252.66,15.57 251.44,14.35 240.42,14.35 239.68,13.61 216.88,13.61 216.03,12.76 197.67,12.76 197.22,13.21 197.22,14.02 v2(197.02,14.22)
  BOTTOM w0.107: CH223.1 197.26,14.66 197.26,14.61 197.27,14.61 197.27,14.46 v2(197.02,14.22) ; JSSD2.25 272.49,20.06 272.79,20.35 273.07,20.35 273.17,20.25 273.17,18.65 274.03,17.79 274.03,17.53 273.67,17.17 273.67,17.17 273.67,17.18 v2(273.67,17.18)
PCIE_PTX_C_DRX_P24: length 90.2
  IN2 w0.076: v2(198.79,14.23) 198.57,14.45 198.57,14.56 198.68,14.68 200.33,14.68 201.17,13.84 203.13,13.84 203.71,14.43 208.42,14.43 208.42,14.42 213.92,14.42 214.16,14.18 239.4,14.18 240.17,14.95 250.41,14.95 251.39,15.93 251.39,16.65 252.6,17.86 262.44,17.86 264.48,19.89 269.45,19.89 270.78,18.56 273.83,18.56 274.34,18.05 274.83,18.05 275.05,18.27 v2(275.46,18.27)
  BOTTOM w0.107: v2(198.79,14.23) 198.57,14.45 198.57,14.68 CH225.1 ; JSSD2.13 272.95,23.06 273.32,22.68 273.32,21.32 273.79,20.85 273.79,18.9 274.62,18.07 274.94,18.07 275.14,18.27 v2(275.46,18.27)
PCIE_PTX_DRX_N9: length 77.9
  TOP w0.107: v2(250.46,10.55) 250.45,10.55 250.17,10.82 250.17,10.98 250.38,11.18 250.38,11.43 CH202.2
  IN6 w0.089: v2(250.46,10.55) 250.41,10.55 250.2,10.34 250.2,10.17 250.01,9.99 248.78,9.99 248.27,10.49 243.24,10.49 242.61,9.86 240.99,9.86 240.34,10.51 240.19,10.51 239.95,10.75 237.63,13.07 232.29,13.07 231.6,12.38 222.56,12.38 221.85,11.67 216.55,11.67 216.06,11.18 208.04,11.18 206.68,12.54 201.55,12.54 200.94,13.15 195.04,13.15 193.27,14.92 193.27,17.01 193.77,17.51 193.77,18.66 193.37,19.06 193.37,22.91 193.77,23.32 193.77,24.68 192.91,25.54 192.81,25.54 v2(192.57,25.3)
  BOTTOM w0.107: v2(192.57,25.3) 192.76,25.49 192.9,25.49 193.1,25.29 193.34,25.29 193.54,25.09 193.57,25.09 193.79,24.87 194.43,24.87 194.62,24.68 194.79,24.68 UH1.C34
PCIE_PTX_DRX_N10: length 6
  BOTTOM w0.107: CH204.2 190.2,26.09 191.06,25.24 191.82,25.24 192.42,24.63 193.33,24.63 193.33,24.63 193.42,24.63 193.44,24.61 193.44,24.61 193.79,24.26 193.79,24.26 193.8,24.25 194.33,24.25 194.33,24.24 194.6,24.24 194.67,24.31 UH1.C35
PCIE_PTX_DRX_N11: length 3.4
  BOTTOM w0.107: CH207.1 191.9,24.57 192.01,24.46 192.01,24.3 192.11,24.2 193.52,24.2 193.85,23.87 193.95,23.87 194.14,24.05 194.29,24.05 194.39,23.95 194.39,23.82 UH1.B36
PCIE_PTX_DRX_N12: length 61.8
  TOP w0.107: CH209.1 241.44,11.51 241.44,10.8 v2(241.64,10.6)
  IN6 w0.089: v2(195.84,22.98) 195.78,23.04 195.4,23.04 194.95,22.6 194.95,17.39 194.1,16.53 194.1,15.45 194.43,15.12 196.97,15.12 197.27,14.82 200.23,14.82 201.18,13.87 201.24,13.87 201.85,13.26 207.14,13.26 207.93,12.47 209.46,12.47 210.02,11.9 215.76,11.9 216.25,12.39 221.55,12.39 222.26,13.1 231.3,13.1 231.99,13.79 237.93,13.79 240.49,11.23 241.19,11.23 241.44,10.98 241.44,10.8 v2(241.64,10.6)
  BOTTOM w0.107: v2(195.84,22.98) 195.61,22.98 195.58,23 195.44,23 UH1.D38
PCIE_PTX_DRX_N15: length 239.2
  IN3 w0.127: v2(183.4,24.68) 183.65,24.68 183.73,24.61 183.85,24.48 184.21,24.48 184.86,25.13 184.86,31.93 185.56,32.63 186.46,32.63 187,33.17 187,36.03 186.92,36.1 186.92,39.14 186.54,39.52 186.54,39.81 186.02,40.33 186.02,51.74 185.34,52.43 185.34,52.69 184.47,53.56 184.47,54.97 184.14,55.31 184.14,60.6 184.91,61.37 184.91,68.07 184.19,68.8 184.19,69.92 186.07,71.81 186.07,72.21 186.08,72.22 186.08,88.33 187.4,89.64 187.4,89.78 187.4,98.03 187.01,98.41 187.01,100.04 187.05,100.08 187.05,104.14 187.05,104.51 188.2,105.67 188.2,105.67 189.68,107.15 189.68,108.33 191.36,110.01 194.24,110.01 197.33,113.1 199.49,113.1 202.38,115.99 202.38,118.87 203.36,119.85 203.36,120.49 204,121.12 204,122.45 206,124.45 207.61,124.45 208.82,125.67 208.82,127.74 208.42,128.14 208.42,128.76 208.05,129.12 208.05,131.03 208.37,131.36 208.37,134.3 208.44,134.37 208.44,143.73 206.59,145.58 206.59,149.21 207.65,150.27 207.65,150.67 208.7,151.71 208.7,155.05 210.94,157.3 214.94,157.3 215.49,157.85 216.72,157.85 217.38,158.51 217.59,158.51 218.14,159.06 226.39,159.06 228.34,161.01 231.07,161.01 231.72,161.66 234.9,161.66 237.03,159.54 242.63,159.54 243.48,160.39 263.66,160.39 265.96,162.69 265.96,166.82 266.84,167.69 268.28,167.69 268.66,168.08 271.6,168.08 272.14,168.62 272.14,169.4 v2(272.32,169.58)
  BOTTOM w0.107: v2(272.32,169.58) 272.23,169.49 272.23,169.05 CL4.2 ; v2(183.4,24.68) 183.63,24.68 185.98,22.33 188.11,22.33 188.24,22.19 189.84,22.19 189.95,22.09 191.59,22.09 191.69,22.19 192.44,22.19 192.53,22.29 194.45,22.29 UH1.B40
PCIE_PTX_DRX_N16: length 169.7
  TOP w0.107: CN24.2 313.08,38.79 312.53,38.79 v2(312.45,38.71) ; v2(191.91,21.19) 191.83,21.26 191.81,21.26 191.25,21.26 191.03,21.49 191.03,22.13 192.03,23.14 192.27,23.14 192.51,23.38 192.51,24.44 191.96,24.99 191.96,27.76 193.35,29.16 193.35,30.74 193.54,30.93 193.54,32.32 192.98,32.89 192.98,34.79 191.98,35.79 190.57,35.79 190.12,36.25 190.12,38.72 189.88,38.96 189.88,44.13 191.27,45.52 191.27,48.79 192.5,50.03 194.03,50.03 194.19,49.87 196.85,49.87 197.76,48.96 197.76,47.99 197.54,47.76 v2(196.83,47.76)
  IN6 w0.089: v2(312.45,38.71) 312.37,38.8 311.93,38.8 311.6,39.13 310.36,39.13 309.79,38.56 304.58,38.56 304.05,39.08 292.28,39.08 290.7,37.51 287.7,37.51 286.61,36.41 283.95,36.41 283.34,35.8 278.29,35.8 278,36.09 273.73,36.09 265.4,44.43 240.45,44.43 238.76,46.11 229.35,46.11 228.78,46.68 215.71,46.68 214.87,47.52 210.54,47.52 209.9,46.88 203.42,46.88 202.07,48.23 199.8,48.23 199.35,47.77 196.84,47.77 v2(196.83,47.76)
  BOTTOM w0.107: UH1.B41 194.35,21.65 194.31,21.65 194.15,21.81 192.71,21.81 192.29,21.39 192.11,21.39 v2(191.91,21.19)
PCIE_PTX_DRX_N17: length 4.2
  BOTTOM w0.107: CH210.2 190.76,19.78 190.81,19.78 190.97,19.62 191.16,19.62 191.46,19.93 192.03,19.93 192.35,20.25 192.35,20.44 192.48,20.56 192.67,20.56 192.79,20.69 192.79,20.89 192.91,21.01 193.11,21.01 193.17,21.06 193.71,21.06 UH1.A42
PCIE_PTX_DRX_N18: length 6.7
  BOTTOM w0.107: CH212.2 189.47,21.31 189.57,21.41 189.73,21.41 189.79,21.47 190.02,21.47 190.05,21.44 190.71,21.44 191.61,20.55 192.18,20.55 192.98,21.35 193.24,21.35 193.33,21.26 193.49,21.26 193.58,21.35 193.88,21.35 194.04,21.19 194.66,21.19 194.87,21.03 194.87,21.02 194.89,21 194.89,20.95 194.85,20.91 UH1.C42
PCIE_PTX_DRX_N19: length 5.2
  BOTTOM w0.107: CH214.1 190.95,18.28 191.02,18.34 191.02,18.57 191.09,18.65 191.4,18.65 191.59,18.83 191.97,18.83 193.51,20.37 193.68,20.37 193.78,20.28 193.87,20.28 193.97,20.37 194.13,20.37 194.23,20.27 194.41,20.27 194.5,20.37 194.65,20.37 UH1.C44
PCIE_PTX_DRX_N20: length 5.6
  BOTTOM w0.107: CH216.1 190.62,17.72 190.85,17.72 190.95,17.61 190.95,17.19 191.06,17.08 191.31,17.08 191.42,17.19 191.42,18.08 191.76,18.42 192.2,18.42 193.23,19.44 193.23,19.66 193.5,19.93 193.68,19.93 UH1.A44
PCIE_PTX_DRX_N21: length 81.6
  IN3 w0.127: v2(266.52,14.66) 266.68,14.5 266.68,14.31 266.55,14.18 260.46,14.18 259.73,13.45 252.36,13.45 250.45,11.55 247.98,11.55 247.88,11.45 230.81,11.45 230.01,12.25 222.07,12.25 222.06,12.26 222.02,12.26 221.69,12.59 219.48,12.59 219.1,12.97 210.48,12.97 209.94,13.52 209.32,13.52 206.33,16.5 204.16,16.5 203.31,17.35 202.73,17.35 202.47,17.61 202.47,17.81 202.1,18.18 201.29,18.18 200.85,18.62 197.02,18.62 196.83,18.43 196.39,18.43 196.1,18.72 v2(196.1,19.04)
  BOTTOM w0.107: v2(266.52,14.66) 266.7,14.84 266.7,17.96 266.96,18.22 267.51,18.22 267.74,17.99 267.74,17.73 CH218.2 ; UH1.G47 196.1,18.97 v2(196.1,19.04)
PCIE_PTX_DRX_N22: length 88.5
  IN1 w0.089: v2(268.93,21.01) 268.74,21.19 268.74,22.45 268.05,23.14 261.57,23.14 261.32,23.4 254.27,23.4 253.25,24.41 247.15,24.41 245.82,23.08 245.82,21.31 244.91,20.41 242.99,20.41 239.6,17.01 239.6,15.85 237.9,14.14 221.09,14.14 221.05,14.11 218.49,14.11 209.71,14.11 209.19,13.59 206.23,13.59 205.91,13.26 200.1,13.26 199.86,13.5 199.86,14.11 v2(199.97,14.23)
  BOTTOM w0.107: v2(199.97,14.23) 199.87,14.33 199.87,15.71 199.21,16.37 198.83,16.37 197.99,17.21 197.99,17.87 197.73,18.13 197.73,18.19 197.5,18.42 197.5,18.5 UH1.H47 ; v2(268.93,21.01) 268.74,20.82 268.74,19.99 268.61,19.87 268.61,19.25 268.64,19.22 268.64,18.65 268.61,18.63 268.61,17.49 268.76,17.34 268.91,17.34 CH220.2
PCIE_PTX_DRX_N23: length 3.3
  BOTTOM w0.107: CH222.2 197.43,15.65 197.43,16.03 196.32,17.14 196.32,17.56 196.53,17.77 196.71,17.77 196.77,17.63 UH1.G49
PCIE_PTX_DRX_N24: length 4.8
  BOTTOM w0.107: CH224.2 198.22,15.46 198.33,15.57 198.33,15.72 197.01,17.03 197.01,17.81 196.84,17.99 196.84,18.95 196.87,18.98 196.87,19.2 196.83,19.24 196.68,19.24 196.6,19.16 UH1.G46
PCIE_PTX_DRX_P9: length 77.9
  TOP w0.107: v2(249.85,10.55) 249.84,10.55 249.84,10.58 249.97,10.71 249.97,11.06 250.17,11.26 250.17,11.47 CH203.2
  IN6 w0.089: v2(249.85,10.55) 250.04,10.37 250.04,10.24 249.95,10.15 248.85,10.15 248.34,10.65 243.17,10.65 242.54,10.02 241.05,10.02 240.41,10.67 240.26,10.67 240.02,10.91 237.7,13.23 232.22,13.23 231.53,12.54 222.49,12.54 221.78,11.83 216.48,11.83 215.99,11.35 208.11,11.35 206.75,12.7 201.62,12.7 201.01,13.32 195.11,13.32 193.44,14.99 193.44,16.94 193.94,17.44 193.94,18.73 193.53,19.13 193.53,22.85 193.94,23.25 193.94,24.75 192.98,25.71 192.74,25.71 v2(192.57,25.88)
  BOTTOM w0.107: UH1.D34 195.33,25.07 194.89,25.07 194.89,25.07 194.62,25.07 194.62,25.07 193.87,25.07 193.65,25.29 193.62,25.29 193.49,25.43 193.49,25.43 193.43,25.49 193.19,25.49 192.98,25.69 192.76,25.69 v2(192.57,25.88)
PCIE_PTX_DRX_P10: length 5.8
  BOTTOM w0.107: UH1.B35 194.47,24.54 194.36,24.65 194.2,24.65 194.02,24.47 193.87,24.47 193.52,24.81 193.52,24.81 193.5,24.83 193.25,24.83 192.51,24.83 191.87,25.47 v4(191.36,25.47) 191.11,25.47 190.32,26.26 190.32,26.46 190.12,26.66 CH205.2
PCIE_PTX_DRX_P11: length 3.5
  BOTTOM w0.107: UH1.C36 194.52,23.58 194.25,23.58 194.17,23.66 193.76,23.66 193.43,23.99 CH206.1
PCIE_PTX_DRX_P12: length 61.8
  TOP w0.107: v2(241.05,10.6) 241.23,10.77 241.23,11.52 CH208.1
  IN6 w0.089: v2(195.35,23.68) 195.35,23.22 194.79,22.67 194.79,17.46 193.93,16.6 193.93,15.38 194.36,14.96 196.9,14.96 197.2,14.66 200.16,14.66 201.11,13.71 201.17,13.71 201.79,13.1 207.07,13.1 207.87,12.3 209.39,12.3 209.95,11.74 215.83,11.74 216.32,12.23 221.62,12.23 222.33,12.94 231.37,12.94 232.05,13.62 237.87,13.62 240.42,11.07 241.12,11.07 241.27,10.91 241.27,10.81 v2(241.05,10.6)
  BOTTOM w0.107: UH1.E37 195.62,23.4 v2(195.35,23.68)
PCIE_PTX_DRX_P15: length 239.2
  IN3 w0.127: v2(183.82,25.1) 183.82,24.83 183.94,24.7 184.12,24.7 184.64,25.22 184.64,32.02 185.47,32.85 186.37,32.85 186.78,33.26 186.78,35.93 186.7,36.01 186.7,39.05 186.32,39.43 186.32,39.72 185.8,40.24 185.8,51.65 185.12,52.33 185.12,52.6 184.26,53.46 184.26,54.88 183.92,55.22 183.92,60.69 184.69,61.46 184.69,67.98 183.97,68.71 183.97,70.01 185.85,71.9 185.85,72.3 185.87,72.31 185.87,88.42 187.18,89.73 187.18,97.94 186.79,98.32 186.79,100.13 186.83,100.17 186.83,104.05 186.83,104.05 186.83,104.33 186.83,104.33 186.83,104.6 188.11,105.88 189.46,107.24 189.46,108.42 191.27,110.23 191.41,110.23 194.15,110.23 197.24,113.32 199.4,113.32 202.16,116.08 202.16,118.96 203.15,119.94 203.15,120.58 203.78,121.21 203.78,122.54 205.91,124.67 207.51,124.67 208.6,125.76 208.6,127.65 208.2,128.05 208.2,128.66 207.83,129.03 207.83,131.12 208.16,131.45 208.16,134.39 208.23,134.46 208.23,143.63 206.37,145.49 206.37,149.3 207.44,150.36 207.44,150.76 208.48,151.8 208.48,155.15 210.85,157.51 214.85,157.51 215.4,158.07 216.63,158.07 217.29,158.73 217.5,158.73 218.05,159.28 226.3,159.28 228.25,161.23 230.98,161.23 231.63,161.88 234.99,161.88 237.12,159.76 242.54,159.76 243.39,160.61 263.57,160.61 265.7,162.74 265.7,166.92 266.73,167.95 268.17,167.95 268.55,168.33 271.49,168.33 271.89,168.73 271.89,169.43 v2(271.74,169.58)
  BOTTOM w0.089: UH1.C40 194.62,22.51 194.45,22.51 194.44,22.5 194.33,22.5 194.32,22.5
  BOTTOM w0.107: CL3.2 272,168.79 272,169.32 v2(271.74,169.58) ; 194.32,22.5 192.45,22.5 192.35,22.4 191.61,22.4 191.5,22.29 190.03,22.29 189.93,22.4 188.33,22.4 188.19,22.54 186.07,22.54 183.82,24.79 v2(183.82,25.1)
PCIE_PTX_DRX_P16: length 169.7
  TOP w0.107: CN23.2 313.41,39.38 313.01,38.99 312.76,38.99 v2(312.45,39.3) ; v2(196.85,48.35) 197.23,47.96 197.45,47.96 197.56,48.07 197.56,48.88 196.76,49.67 194.1,49.67 193.95,49.83 192.59,49.83 191.47,48.71 191.47,45.43 190.08,44.04 190.08,39.04 190.32,38.8 190.32,36.33 190.65,36 192.07,36 193.19,34.88 193.19,32.97 193.75,32.41 193.75,30.84 193.56,30.66 193.56,29.07 192.16,27.68 192.16,25.07 192.71,24.52 192.71,23.3 192.35,22.94 192.12,22.94 191.23,22.05 191.23,21.57 191.34,21.47 191.6,21.47 v2(191.91,21.77)
  IN6 w0.089: v2(196.85,48.35) 196.85,48.31 197.23,47.93 199.28,47.93 199.74,48.39 202.14,48.39 203.49,47.04 209.83,47.04 210.47,47.69 214.94,47.69 215.78,46.85 228.85,46.85 229.42,46.28 238.83,46.28 240.51,44.59 265.46,44.59 273.8,36.26 278.07,36.26 278.36,35.97 283.27,35.97 283.88,36.58 286.54,36.58 287.17,37.2 287.17,37.21 287.2,37.25 287.2,37.26 287.62,37.67 290.55,37.67 292.15,39.27 292.19,39.27 292.21,39.25 304.12,39.25 304.63,38.74 309.73,38.74 310.29,39.3 311.67,39.3 312,38.97 312.12,38.97 v2(312.45,39.3)
  BOTTOM w0.089: UH1.C41 194.65,21.85
  BOTTOM w0.107: 194.65,21.85 194.4,21.85 194.24,22.01 192.62,22.01 192.2,21.59 192.08,21.59 v2(191.91,21.77)
PCIE_PTX_DRX_P17: length 4.3
  BOTTOM w0.107: UH1.B42 193.88,20.86 193.25,20.86 192.12,19.73 191.55,19.73 191.24,19.42 CH211.2
PCIE_PTX_DRX_P18: length 6.7
  BOTTOM w0.107: UH1.D42 194.73,21.39 194.13,21.39 193.97,21.55 192.89,21.55 192.1,20.76 191.69,20.76 190.77,21.68 v4(190.33,21.68) 189.56,21.68 CH213.2
PCIE_PTX_DRX_P19: length 5.3
  BOTTOM w0.107: UH1.D43 195.07,20.49 194.98,20.58 193.43,20.58 191.89,19.03 191.5,19.03 191.32,18.85 CH215.1
PCIE_PTX_DRX_P20: length 5.7
  BOTTOM w0.107: CH217.1 191.4,16.88 191.62,17.11 191.62,18 191.84,18.22 192.29,18.22 193.43,19.36 193.43,19.57 193.58,19.72 193.85,19.72 194.13,20 UH1.B44
PCIE_PTX_DRX_P21: length 81.5
  IN3 w0.127: v2(267.1,14.66) 266.9,14.46 266.9,14.22 266.64,13.96 260.55,13.96 259.82,13.23 252.45,13.23 250.54,11.33 248.07,11.33 247.97,11.23 230.72,11.23 229.92,12.03 221.98,12.03 221.97,12.04 221.93,12.04 221.6,12.37 219.39,12.37 219.01,12.75 210.39,12.75 209.85,13.3 209.23,13.3 206.24,16.28 204.07,16.28 203.21,17.14 202.64,17.14 202.26,17.52 202.26,17.72 202.01,17.96 201.2,17.96 200.76,18.4 197.11,18.4 196.92,18.22 196.3,18.22 195.91,18.6 195.64,18.6 v2(195.51,18.47)
  BOTTOM w0.107: UH1.F46 195.61,18.43 195.53,18.47 195.53,18.47 v2(195.51,18.47) ; CH219.2 267.53,17.73 267.53,17.91 267.43,18.01 267.05,18.01 266.91,17.87 266.91,14.85 266.93,14.83 266.93,14.76 267.03,14.66 v2(267.1,14.66)
PCIE_PTX_DRX_P22: length 88.5
  IN1 w0.089: v2(199.39,14.23) 199.69,13.92 199.69,13.43 200.03,13.1 205.98,13.1 206.3,13.42 209.26,13.42 209.78,13.94 218.56,13.94 221.12,13.94 221.16,13.98 237.97,13.98 239.77,15.78 239.77,16.95 243.06,20.24 244.98,20.24 245.98,21.24 245.98,23.01 247.22,24.25 253.18,24.25 254.2,23.23 261.25,23.23 261.5,22.98 267.98,22.98 268.58,22.38 268.58,21.28 v2(268.33,21.03)
  BOTTOM w0.107: UH1.H48 197.42,18.21 197.52,18.11 197.52,18.05 197.79,17.78 197.79,17.13 198.74,16.17 199.12,16.17 199.67,15.63 199.67,14.51 v2(199.39,14.23) ; v2(268.33,21.03) 268.54,20.83 268.54,20.08 268.41,19.95 v4(268.41,18.94) 268.41,17.4 268.68,17.14 268.89,17.14 CH221.2
PCIE_PTX_DRX_P23: length 3.3
  BOTTOM w0.107: CH223.2 197.23,15.64 197.23,15.95 196.11,17.06 196.11,17.64 196.53,18.06 UH1.G48
PCIE_PTX_DRX_P24: length 4.9
  BOTTOM w0.107: CH225.2 198.55,15.67 198.55,15.78 197.21,17.12 197.21,17.9 197.04,18.07 197.04,18.87 197.07,18.9 197.07,19.28 196.88,19.48 UH1.G45
PCIE_RBIAS: length 1.1
  TOP w0.089: UT1.N16 v2(183.25,165.61)
  BOTTOM w0.107: v2(183.25,165.61) 183.38,165.48 183.75,165.48 RT3.1
PCIE_RCOMPN: length 5.4
  BOTTOM w0.102: RH193.1 190.32,35.49 189.82,35.98 v1(189.82,36.35)
  BOTTOM w0.152: 194.04,35.71 194.09,35.67 UH1.B12
  BOTTOM w0.254: RH193.1 190.58,35.49 191.15,36.05 191.15,36.07 191.15,36.07 191.89,36.07 192.16,35.8 193.6,35.8 193.61,35.82 193.9,35.82 194,35.71 194.04,35.71
PCIE_RCOMPP: length 3.3
  BOTTOM w0.102: RH193.2 v1(191.47,34.5)
  BOTTOM w0.254: UH1.A13 193.74,35.46 193.31,35.46 193.3,35.46 193.29,35.46 193.29,35.46 193.28,35.46 193.24,35.42 191.91,35.42 191.84,35.49 RH193.2
PCIE_WAKE#: length 419.7
  TOP w0.114: v2(293.37,23.92) 293.36,23.91 293.36,20.9 294.12,20.14 294.12,19.06 293.47,18.4 293.47,18 293.47,18 293.47,12.64 292.44,11.61 UE5.64 ; RH4.1 v1(221.73,18.05) 222.07,18.4 v2(222.07,18.65)
  IN3 w0.127: v2(262.09,24.82) 260.92,25.99 260.92,26.34 260.08,27.18 252.09,27.18 251.51,26.6 249.26,26.6 247.88,25.23 247.88,25.23 247.32,24.67 243.28,24.67 242.07,23.45 241.95,23.45 241.71,23.21 241.71,23.09 240.52,21.91 240.52,20.52 239.8,19.8 239.05,19.05 238.35,19.05 236.34,17.04 236.34,17.04 235.6,16.3 234.54,16.3 234.54,16.3 232.98,16.3 232.22,17.06 230.93,17.06 230.61,17.38 227.03,17.38 226.46,16.81 224.51,16.81 223.25,18.06 222.66,18.06 v2(222.07,18.65) ; v2(275.9,164.51) 275.55,164.51 273.76,162.72 270.94,162.72 267.15,158.93 267.15,157.47 262.44,152.76 214.44,152.76 212.27,152.76 211.84,152.34 211.84,150.58 210.98,149.71 210.12,149.71 209.86,149.46 209.86,148.86 210.05,148.67 210.05,148.66 210.19,148.52 210.19,148.22 210.93,147.48 210.93,133.64 214.58,130 214.58,127.75 212.23,125.4 212.23,125.08 212.16,125.01 212.16,121.82 212.44,121.54 212.44,116.72 211.65,115.93 211.65,108.32 207.78,104.45 193.06,104.45 192.2,103.59 192.14,103.59 191.3,102.75 191.3,101.93 191.3,87.95 189.97,86.62 189.97,70.38 193.62,66.73 199.21,66.73 202.32,63.62 202.32,62.41 202.85,61.88 202.85,56.07 203.47,55.45 206.93,55.45 209.37,53.01 209.37,49.57 210.64,48.3 210.94,48 213.18,48 215.58,45.59 221.88,45.59 225.23,42.24 225.23,37.67 223.47,35.91 223.47,32.44 224.37,31.54 224.37,28.84 227.49,25.71 227.65,25.71 228.75,24.61 229.75,24.61 230.29,24.07 232.3,24.07 232.91,23.46 234.08,23.46 234.41,23.13 235.98,23.13 237.22,24.37 238.4,24.37 241.84,27.82 245.55,27.82 247.28,29.54 247.48,29.54 248.94,31 259.54,31 259.55,31.02 268.01,31.02 269.23,29.8 277.9,29.8 278.6,29.1 287.61,29.1 292.79,23.92 v2(293.37,23.92)
  IN6 w0.081: v2(293.37,23.92) 290.42,23.92 289.53,24.81 286.62,24.81 286.62,24.8 286.29,24.8 286.29,24.81 285.75,24.81 285.59,24.96 281.35,24.96 281.12,24.73 273.09,24.73 271.46,26.36 266.72,26.36 265.87,25.5 262.77,25.5 v2(262.09,24.82)
  BOTTOM w0.114: RL1.2 276.15,165.56 276.15,164.76 v2(275.9,164.51) 275.83,164.44 UL1.3
PCIRST#: length 633.1
  TOP w0.089: 219.01,37.9 v2(218.39,37.9)
  TOP w0.102: v2(299.41,23.24) 299.41,23.59 300.1,24.28 300.59,24.28 300.74,24.43 UE5.13 300.74,27.07 300.36,27.45 CE34.1 ; 219.01,37.9 v1(219.04,37.87) 219.33,37.58 RH199.1
  IN1 w0.102: v2(331.57,34.24) 331.57,34.06 326.83,29.32 326.83,29.06 326.4,28.63 325.09,28.63 324.29,27.83 323.88,27.83 323.2,28.51 322.26,28.51 321.92,28.85 314.68,28.85 312.94,27.11 312.94,26 311.65,24.71 310.85,24.71 309.75,23.61 302.15,23.61 301.49,22.95 299.7,22.95 v2(299.41,23.24) ; v2(180.9,176.94) 181.19,176.65 182.99,176.65 183.69,175.95 186.1,175.95 186.15,175.89 187.8,175.89 188.3,175.39 190.28,175.39 193.39,172.28 198.47,172.28 199.5,171.25 200.41,171.25 200.73,171.57 201.11,171.57 201.33,171.36 201.33,171.17 203.21,169.28 203.36,169.28 203.46,169.18 v2(203.46,169.17)
  IN2 w0.102: v2(168.92,169.79) 168.68,169.55 168.38,169.55 167.46,168.62 167.46,163.19 167.08,162.8 167.08,159.25 164.25,156.42 159.8,156.42 v2(159.19,157.03)
  IN3 w0.127: v2(211.31,22.57) 211.74,22.57 212.29,22.03 213.18,22.03 214.07,21.14 215.85,21.14 216.16,20.82 217.72,20.82 217.86,20.96 219.73,20.96 219.84,20.85 222.88,20.85 223.04,20.69 223.04,20.69 224.16,19.57 224.16,19.15 224.7,18.62 225.73,18.62 225.76,18.65 231.14,18.65 231.46,18.33 232.75,18.33 233.51,17.57 235.07,17.57 237.83,20.32 238.53,20.32 239.25,21.05 239.25,22.43 240.44,23.62 240.44,23.73 241.43,24.72 241.54,24.72 242.76,25.94 246.11,25.94 247.99,27.82 248.19,27.82 249.66,29.28 263.28,29.28 264.96,27.6 264.96,26.63 265.4,26.19 265.91,26.19 267.55,27.83 268.08,27.83 268.13,27.83 273.14,27.83 274.26,26.71 v2(275.28,26.71) 275.29,26.71 276.06,25.94 282.42,25.94 282.59,26.11 284.75,26.11 285.18,25.68 286.85,25.68 290.29,22.24 297.12,22.24 298.11,23.24 v2(299.41,23.24)
  IN4 w0.089: 198.76,27.28 198.76,28.31 195.66,31.42 195.4,31.42 194.16,32.66 192.23,32.66 192.22,32.65 ; 177.67,117.36 179.53,119.22
  IN4 w0.102: 198.76,27.28 198.76,25.46 199.09,25.14 199.41,25.14 199.7,24.85 200.32,24.85 200.72,24.46 202.87,24.46 203.41,24.99 203.41,25.35 203.85,25.79 208.5,25.79 210.75,23.54 210.75,23.13 v2(211.31,22.57) ; 192.22,32.65 192.1,32.65 192.1,32.65 191.91,32.65 190.6,33.95 188.76,33.95 188.53,33.72 187.64,33.72 187.51,33.86 187.05,34.31 187.05,36.92 186.09,37.88 186.09,41.72 183.26,44.55 183.26,46.24 180.51,48.99 180.51,50.25 179.31,51.46 179.31,52.28 178.32,53.27 178.32,55.62 177.63,56.3 177.63,60.51 178.74,61.61 178.74,70.99 180.01,72.26 180.01,73.2 179.77,73.43 177.52,73.43 175.38,75.57 175.38,94.35 178.33,97.3 178.33,107.48 177.67,108.14 177.67,117.36 ; v2(159.19,157.03) 159.98,156.24 161.2,156.24 166.78,150.66 166.91,150.52 166.91,150.52 172.06,150.52 172.7,149.89 184.49,149.89 186.75,147.63 186.75,145.09 187.42,144.42 187.42,130.38 179.92,122.88 179.92,119.99 180.04,119.87 180.04,119.73 179.92,119.61 179.53,119.22
  IN6 w0.089: v2(211.31,22.57) 210.57,23.31 210.57,24.46 210.99,24.87 211.54,24.87 212.12,25.45 212.12,27.08 211.63,27.57 211.63,28.8 211.25,29.18 211.25,29.94 212.92,31.61 212.92,32.25 212.48,32.69 212.48,34.16 213.43,35.12 213.75,35.12 213.93,35.3 214.64,35.3 215.27,35.93 216.61,35.93 217.82,37.15 217.82,37.33 v2(218.39,37.9)
  IN6 w0.102: v2(244.01,10.09) 244.04,10.09 244.54,9.59 250.75,9.59 251.89,10.73 251.89,13.17 254.07,15.34 265.08,15.34 265.97,16.23 275.49,16.23 276.22,15.5 v2(277.82,15.5) ; v2(180.9,176.94) 180.86,176.94 180.64,177.16 176.7,177.16 175.68,178.17 172.35,178.17 169.76,175.58 169.76,170.63 v2(168.92,169.79) ; v2(275.71,165.07) 275.97,165.07 276.83,164.2 276.83,157.22 275,155.39 271.79,155.39 271.05,156.13 264.41,156.13 264.1,156.44 253.82,156.44 253,157.26 246.76,157.26 245.47,158.55 245.47,160.35 243.09,162.74 243.09,168.39 240.86,170.62 239.59,170.62 238.96,171.25 234.9,171.25 234.26,170.62 233.5,170.62 232.86,171.25 226.77,171.25 226.32,170.81 223.97,170.81 220.39,167.22 220.39,164.55 218.49,162.65 210.72,162.65 205.67,167.69 204.03,167.69 203.72,168.01 203.72,168.9 203.46,169.15 v2(203.46,169.17)
  BOTTOM w0.089: 219.18,37.9 v2(218.39,37.9)
  BOTTOM w0.102: v2(299.41,23.24) 299.41,24.99 304.44,30.01 304.44,31.69 307.74,34.99 307.74,37.28 310.97,40.5 311.92,40.5 313.07,41.66 JWLAN.44 ; UL1.2 275.49,164.84 v2(275.71,165.07) ; 172.49,169.64 173.34,168.79 173.34,167.86 173.77,167.43 174.44,167.43 175.13,166.74 175.24,166.74 175.24,166.74 175.7,166.74 RT1.1 ; 219.18,37.9 219.5,37.9 220.06,38.45 220.47,38.45 ; v2(244.01,10.09) 244.01,9.81 243.89,9.68 243.44,9.68 241.77,8.01 JSSD3.50 ; v2(331.57,34.24) 331.57,36.97 332.25,37.66 JSSD1.50
  BOTTOM w0.107: v2(275.28,26.71) 276.36,25.63 276.36,21.06 277.48,19.94 277.48,19.51 277.65,19.34 277.65,15.68 v2(277.82,15.5) 277.82,14.66 278.68,13.81 JSSD2.50 ; v2(168.92,169.79) 169.07,169.64 172.49,169.64
  BOTTOM w0.114: UH3.4 221.07,40.7 221.07,38.76 220.76,38.45 220.47,38.45
PD100_PIN1: length 3.2
  TOP w0.127: PR113.1 v1(61.91,44.96)
  TOP w0.254: PR113.1 61.4,46.15 61.16,46.39 61.16,46.79 60.91,47.04 PD100.1
PD_EE_CLK: length 4.1
  BOTTOM w0.107: UT4.A3 199.1,161.81 199.1,160.86
  BOTTOM w0.114: 199.1,160.86 199.35,160.6 199.35,159.89 198.89,159.43 RT123.2 198.89,158.92 198.81,158.84 198.12,158.84 RT101.2
PD_EE_CS_N: length 5.1
  BOTTOM w0.076: 198.91,161.45 198.91,162.12 UT4.B3
  BOTTOM w0.107: 198.91,161.45 198.91,161.3 198.38,160.77 198.38,160.65
  BOTTOM w0.114: 198.38,160.65 198.14,160.41 197.95,160.41 197.27,159.72 196.14,159.72 RT100.2
PD_EE_DI: length 3.4
  BOTTOM w0.076: 199.53,160.84 199.41,160.95 199.41,162.12 199.65,162.37 UT4.B4
  BOTTOM w0.107: 199.55,160.81 199.53,160.84
  BOTTOM w0.114: RT98.2 199.6,159.28 199.6,160.77 199.55,160.81
