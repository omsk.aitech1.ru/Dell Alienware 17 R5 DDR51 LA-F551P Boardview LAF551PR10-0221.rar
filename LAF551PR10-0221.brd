# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DPSNK_RBIAS: length 2.6
  TOP w0.089: UT1.Y18 v2(183.26,163)
  BOTTOM w0.102: v1(183.93,162.03) 183.26,162.7 v2(183.26,163)
  BOTTOM w0.107: v2(183.26,163) 183.88,163.63 RT19.1
DPSRC_RBIAS: length 1.4
  TOP w0.102: v2(178.7,165.61) UT1.N6
  BOTTOM w0.127: v2(178.7,165.61) 178.6,165.61 RT5.1
DRVON: length 71.6
  TOP w0.203: v2(125.61,147.25) 125.71,147.15 125.71,146.75 125.36,146.4 125.36,146.21 125.34,146.19 PU500.17
  IN1 w0.254: v2(149.11,153.06) 149.11,153.06 149.77,152.4 150.43,152.4 150.88,152.86 151.9,152.86 153.2,151.57 155.43,151.57 156.35,150.65 156.35,149.5 v2(156.47,149.37) 156.97,148.87 157.67,148.87 158.3,149.51 161.23,149.51 161.31,149.43 163.98,149.43 v2(164.08,149.33) 164.66,148.75 165.29,148.75 165.97,149.43 167.68,149.43 168.49,148.61 171.43,148.61 171.69,148.87 171.69,148.9 171.99,149.2 v2(172.74,149.2) 173.39,148.56 173.73,148.56 174.94,149.76 174.94,149.81 179.54,149.81 v2(180.19,149.15)
  IN4 w0.254: v2(149.11,153.06) 149.11,151.92 148.57,151.39 142.07,151.39 v2(140.52,152.94) 140.27,153.19 132.04,153.19 129.68,150.83 127.42,150.83 125.38,148.8 125.38,147.48 v2(125.61,147.25)
  BOTTOM w0.254: PR556.1 v2(149.11,153.06) ; PR576.1 v2(164.08,149.33) ; PR5006.1 v2(180.19,149.15) ; PR566.1 v2(156.47,149.37) ; PR585.1 v2(140.52,152.94) ; v2(172.74,149.2) 172.74,148.68 172.82,148.6 PR594.1
EAP: length 2.6
  BOTTOM w0.203: PU6000.29 272.42,141.47 271.66,142.23 270.79,142.23 PR6018.2
EAPD#: length 9.2
  TOP w0.107: DA3.2 35.25,40.84 35.25,37.81 34.82,37.38 v1(34.58,37.38) 34.21,37.38 v2(33.9,37.69)
  BOTTOM w0.107: UA1.52 33.22,37.32 RA22.1 33.64,38.24 RA21.2 33.73,37.86 v2(33.9,37.69)
EC_AC_BAT#: length 297.4
  TOP w0.089: RG16.1 222.07,114.08 v2(222.07,113.75)
  TOP w0.102: v2(334.52,44.25) 334.71,44.25 v1(335.16,43.81) ; UE5.1 305.54,26.62 v2(305.06,27.09)
  IN4 w0.102: v2(305.06,27.09) 306.35,28.38 306.84,28.38 308.75,30.28 319.03,30.28 320.12,31.37 320.22,31.47 324.53,31.47 326.84,33.79 328.11,33.79 328.68,33.21 331.4,33.21 332.99,34.8 333.7,35.51 333.7,43.43 v2(334.52,44.25)
  IN6 w0.102: v2(222.07,113.75) 221.7,113.38 219.41,113.38 218.13,112.11 218.13,111 217.56,110.43 217.22,110.43 216.86,110.07 216.86,109.58 213.62,106.34 209.74,106.34 206.9,103.51 197.18,103.51 196.83,103.85 191.02,103.85 188.91,101.74 187.75,101.74 186.17,100.16 186.17,95.37 187.08,94.45 187.08,72.95 189.36,70.67 199.97,70.67 201.74,68.9 209.74,68.9 210.87,67.77 210.87,58.42 212.46,56.83 212.46,54.96 214.45,52.97 220.34,52.97 220.6,52.7 225.7,52.7 226.23,53.24 228.3,53.24 229.61,51.93 232.11,51.93 232.51,51.53 249.49,51.53 250.72,50.3 259.42,50.3 260.49,51.36 272.34,51.36 273.43,50.27 277.72,50.27 278.57,49.42 292.84,49.42 296.63,53.21 296.63,57.97 298.04,59.39 309.88,59.39 310.88,58.39 312.13,58.39 312.66,57.86 318.36,57.86 318.97,58.47 320.43,58.47 320.69,58.21 320.69,53.15 322.57,51.27 324.15,51.27 328.69,46.73 332.05,46.73 v2(334.52,44.25)
  BOTTOM w0.1: UG9.BE6 v2(222.07,113.75)
EC_CLK1: length 19.3
  TOP w0.102: UE5.83 300.34,9.03 300.4,8.97 300.4,6.6 299.95,6.15 291.91,6.15 290.21,7.85 v1(288.73,7.85) 286.29,7.85 RE668.1 RE670.1
EC_DAT1: length 19.5
  TOP w0.102: UE5.84 300.74,9.1 300.62,8.99 300.62,6.5 300.05,5.92 291.81,5.92 290.27,7.47 v1(287.21,7.47) RE669.1 RE671.1
EC_ENBKL: length 266.1
  TOP w0.089: UG30.6 215.32,114.38 RG566.2 RG569.1 215.43,115.41 v2(215.29,115.55)
  TOP w0.102: UE5.76 297.54,11.25 v2(297.39,11.4) ; v2(181.49,75.19) v1(180.92,75.19)
  IN3 w0.102: v2(175.29,29.28) 178.09,32.08 178.09,32.69 180.09,34.69 180.09,44.32 181.06,45.29 181.06,47.6 180.03,48.63 180.03,55.81 179.71,56.12 178.38,56.12 178.01,56.49 178.01,72.39 179.87,74.25 180.55,74.25 v2(181.49,75.19)
  IN4 w0.102: v2(236.04,9.83) 236.04,12.37 237.49,13.82 251.08,13.82 251.6,14.34 260.86,14.34 261.07,14.55 264.32,14.55 265.28,15.52 276.59,15.52 276.72,15.38 277.07,15.04 282.01,15.04 285.18,11.87 296.92,11.87 v2(297.39,11.4)
  IN6 w0.089: v2(215.29,115.55) 215.29,115.74 215.02,116.01
  IN6 w0.102: v2(178.77,16.34) 179.36,16.92 180.13,16.92 185.59,11.46 186.54,10.5 187.46,10.5 188.64,9.33 188.93,9.33 188.93,9.33 189.19,9.33 189.63,9.33 190.16,8.79 193.05,8.79 194.22,7.61 203.66,7.61 203.79,7.48 203.92,7.35 229.62,7.35 230.35,8.09 234.97,8.09 236.04,9.15 v2(236.04,9.83) ; 215.02,116.01 214.75,116.27 213.2,116.27 213.09,116.16 212.02,116.16 211.53,115.67 208.8,115.67 208.36,116.12 205.43,116.12 201.72,112.41 201.72,111.54 198.72,108.54 197.78,108.54 196.61,107.37 194.05,107.37 193.82,107.14 191.54,107.14 188.65,104.24 188.39,104.24 185.49,101.35 185.49,101.11 185.02,100.64 185.02,94.89 185.31,94.6 185.31,78.36 183.12,76.17 182.47,76.17 v2(181.49,75.19)
  BOTTOM w0.102: v2(175.29,29.28) 175.29,20.44 178.77,16.96 v2(178.77,16.34)
EC_ESB_CLK: length 72.6
  TOP w0.102: RE642.2 299.03,27.6 v2(299.03,27.02) 298.97,26.95 298.97,26.67 298.97,26.58 299.14,26.41 UE5.17 ; v2(330.38,41.64) 330.4,41.64 330.4,41.65 330.4,41.65 330.04,42.01 UE6.1 ; v2(315.89,56.73) 316.26,57.1 UE10.1
  IN2 w0.102: v2(330.38,41.64) 330.4,41.64 330.4,41.65 330.4,41.65 330.22,41.82 328.74,41.82 327.9,40.99 322.9,40.99 321.14,39.23 321.14,35.74 318.19,32.79 312.42,32.79 309.47,29.85 308.56,29.85 307.18,28.46 306.13,28.46 305.49,27.83 303.83,27.83 303.65,27.65 301.94,27.65 301.57,27.28 299.29,27.28 v2(299.03,27.02)
  BOTTOM w0.102: v2(330.38,41.64) 330.4,41.64 330.4,41.84 330.97,42.41 330.97,43.87 329.13,45.71 329.13,51.3 328.43,52 v1(323.17,52) 321,52 320.71,52.29 320.71,55.34 319.5,56.54 319.5,56.87 318.98,57.39 316.56,57.39 v2(315.89,56.73)
EC_ESB_DAT: length 69
  TOP w0.102: v2(317.7,56.63) 317.7,56.76 317.76,56.82 UE10.4 ; RE643.2 298.27,27.15 v2(298.4,27.02) 298.4,26.91 298.74,26.57 UE5.18 ; v2(331.86,41.65) 331.54,41.97 UE6.4
  IN2 w0.102: v2(331.86,41.65) 331.45,42.05 328.64,42.05 327.81,41.22 322.8,41.22 320.91,39.33 320.91,35.84 318.1,33.02 312.32,33.02 309.38,30.08 308.47,30.08 307.08,28.69 306.03,28.69 305.4,28.06 303.73,28.06 303.56,27.88 301.85,27.88 301.47,27.51 298.89,27.51 v2(298.4,27.02)
  IN6 w0.102: v2(317.7,56.63) 318.04,56.29 319.37,56.29 320.46,55.2 320.46,53.06 322.48,51.04 324.05,51.04 328.94,46.16 328.94,44 330.65,42.28 331.22,42.28 v2(331.86,41.65)
EC_MUTE#: length 350.7
  TOP w0.102: v2(313.64,53.97) 313.89,53.97 314.45,54.52 315.55,54.52 315.79,54.28 318.44,54.28 319.52,53.2 320.33,53.2 v1(320.68,53.56) 320.89,53.76 320.89,59.73 320.3,60.32 UE10.11
  TOP w0.107: v2(35.79,40.63) DA3.3
  IN2 w0.089: 205.52,45.3 206.29,45.3 ; 204.11,43.88 204.03,43.81 203.68,43.81 203.34,43.47 199.2,43.47 199.11,43.38 196.61,43.38 196.33,43.66 194.52,43.66 194.4,43.53
  IN2 w0.102: 194.4,43.53 194.1,43.23 191.84,43.23 191.77,43.3 190.38,43.3 189.54,42.46 186.43,42.46 185.11,41.14 184.64,41.14 180.83,37.33 133.81,37.33 130.89,40.25 112.66,40.25 108.65,44.26 100.52,44.26 98.5,46.28 96.62,46.28 96.44,46.1 93.98,46.1 93.26,46.83 87.87,46.83 87.69,46.65 65.14,46.65 65,46.79 62.31,46.79 61.56,47.54 58.58,47.54 57.08,46.04 57.08,44.97 56.77,44.66 55.47,44.66 54.36,45.76 53.35,45.76 52.87,46.24 49.87,46.24 48.42,47.7 40.93,47.7 39.7,46.46 39.7,43.17 37.36,40.83 35.99,40.83 v2(35.79,40.63) ; 206.29,45.3 211.06,45.3 211.51,44.85 217.1,44.85 217.48,44.47 223.69,44.47 225.79,42.37 228.82,42.37 229.87,43.42 237.8,43.42 238.97,42.26 240.16,42.26 240.95,41.47 244.27,41.47 245.7,42.89 265.67,42.89 276.15,32.41 279.54,32.41 283.35,28.6 289.76,28.6 294.8,23.56 296.76,23.56 297.69,24.49 302.25,24.49 303.96,24.49 303.96,24.49 305.6,24.49 306.56,25.45 306.59,25.45 306.59,25.46 308.16,25.46 308.73,26.03 308.73,27.1 309.48,27.84 310.63,27.84 311.98,29.2 v2(312.17,29.2) ; 204.11,43.88 205.52,45.3
  IN3 w0.102: v2(313.64,53.97) 313.06,53.39 313.06,49.39 310.88,47.21 310.88,40.68 310.21,40.01 310.21,35.54 310.46,35.29 310.46,33.71 312.77,31.4 312.77,30.75 312.17,30.15 v2(312.17,29.2)
EC_ON: length 281.2
  TOP w0.102: v1(58.45,45.3) 58.3,45.46 58.3,46.56 58.88,47.14 v2(59.36,47.14)
  TOP w0.107: v2(300.14,23.74) 300.14,22.88 299.47,22.22 299.47,19.23 299.79,18.91 300.9,18.91 301.01,18.81 301.01,17.93 300.57,17.5 300.57,17.16 300.81,16.92 302.61,16.92 303.83,15.71 304.69,15.71 304.9,15.92 304.9,16.54 304.75,16.69 304.75,17.16 305.2,17.61 UE5.112
  TOP w0.254: v2(59.36,47.14) 59.36,47.44 59.1,47.69 PD100.2
  IN2 w0.102: v2(300.14,23.74) 299.62,24.26 297.86,24.26 296.94,23.33 294.7,23.33 289.66,28.37 283.26,28.37 279.45,32.18 276.06,32.18 265.58,42.66 245.79,42.66 244.37,41.24 240.85,41.24 240.59,41.51 238.57,41.51 236.88,43.2 229.96,43.2 228.91,42.14 225.31,42.14 224.04,43.41 218.21,43.41 217.01,44.62 211.35,44.62 210.9,45.07 205.62,45.07 204.17,43.62 203.75,43.62 203.42,43.29 199.28,43.29 199.19,43.2 196.53,43.2 196.25,43.48 194.61,43.48 194.14,43.01 191.74,43.01 191.67,43.08 190.48,43.08 189.64,42.23 186.53,42.23 185.2,40.91 184.74,40.91 180.93,37.1 133.71,37.1 130.79,40.02 112.57,40.02 108.56,44.03 98.59,44.03 98.27,43.72 96.05,43.72 95.07,44.69 92.59,44.69 91.51,45.77 88.68,45.77 88.03,46.42 65.04,46.42 64.91,46.56 62.22,46.56 61.64,47.14 v2(59.36,47.14)
EC_RSMRST#: length 482.9
  TOP w0.102: v2(221.24,11.19) 221.24,11.19 221.24,11.55 219.83,12.96 RH88.2 ; RC355.2 127.59,160.7 v2(127.01,161.28)
  TOP w0.107: UE5.100 304.63,12.81 301.53,15.92 v2(301.53,16.19)
  IN2 w0.089: v2(193.15,31.7) 197.95,31.7 198.54,31.12 198.54,30.33 198.84,30.03 200.26,30.03 200.87,29.42 206.46,29.42 206.99,29.95 208.42,29.95 208.75,30.28 208.75,30.51 209.25,31.02 210.98,31.02 211.18,31.22 211.69,31.22 212.12,31.65 212.12,34.45 212.97,35.29 216.17,35.29 216.19,35.31 216.29,35.31 216.8,35.82 219.18,35.82
  IN2 w0.102: 219.18,35.82 220.02,35.82 220.51,35.33 220.53,35.33 220.59,35.27 223.54,35.27 223.61,35.33 224.67,35.33 224.9,35.11 v2(225.12,35.11)
  IN3 w0.127: v2(225.12,35.11) 225.12,34.28 226.89,32.5 228.29,32.5 228.55,32.25 228.55,28.63 231.22,25.96 232.56,25.96 232.65,25.87 235.13,25.87 235.92,26.66 236.17,26.66 237.46,27.96 239.07,27.96 239.83,27.96 242.94,31.07 246.85,31.07 248.87,33.09 250.44,33.09 250.72,33.37 259.69,33.37 260.51,32.54 268.64,32.54 268.92,32.26 269.53,31.65 280.45,31.65 281.42,30.68 289.04,30.68 293.7,26.03 301.06,26.03 302.75,24.33 302.75,21.86 303.63,20.98 303.63,17.14 303.03,16.55 303.03,15.97 303.03,15.97 303.03,15.89 302.68,15.54 301.91,15.54 301.53,15.92 v2(301.53,16.19)
  IN4 w0.089: 219.18,24.57 218.7,24.57 217.69,23.55 216.99,23.55 215.46,22.03 215.46,20.95 214.68,20.17 214.68,20.16 214.47,19.95 214.47,19.95 214,19.49 v2(214,19.04) ; v2(193.15,31.7) 192.2,31.7 192.1,31.81 ; 179.53,119.54 177.36,117.38 177.36,115.84 176.26,114.74 176.26,111.34 177.49,110.11 177.49,108.06 178.15,107.41 178.15,97.38 175.17,94.4 175.17,93.02 175.15,93 175.15,92.9
  IN4 w0.102: v2(222.32,30.28) 221.75,30.28 221.61,30.14 221.6,30.14 221.31,29.85 221.31,28.06 222.64,26.72 222.64,25.84 222.16,25.36 222.16,25.05 221.68,24.57 219.18,24.57 ; v2(127.01,161.28) 127.01,160.28 126.97,160.25 126.97,155.67 128.06,154.58 130.66,154.58 131.71,153.53 141.96,153.53 143.21,152.28 147.15,152.28 151.67,156.8 158.66,156.8 159.42,156.04 159.86,156.04 159.88,156.01 161.1,156.01 166.55,150.56 166.82,150.3 171.97,150.3 172.6,149.66 184.4,149.66 186.52,147.54 186.52,145 187.19,144.33 187.19,131.69 179.7,124.19 179.7,119.71 179.53,119.54 ; v2(301.53,16.19) 301.53,14.11 301.43,14.01 295.17,14.01 292.76,16.42 276.86,16.42 276.44,16 265.08,16 264.12,15.04 260.87,15.04 260.66,14.82 251.4,14.82 250.88,14.3 223.43,14.3 221.29,12.17 221.29,11.24 v2(221.24,11.19) ; 175.15,92.9 175.15,75.05 176.41,73.79 176.41,66.12 174.63,64.34 174.63,63.55 172.76,61.68 172.76,60.29 172.47,60 172.47,48.82 173.95,47.35 173.95,40.57 175.6,38.92 175.6,35.03 176.69,33.94 181.92,33.94 182.15,34.17 184.69,34.17 185.59,33.26 188.53,33.26 188.72,33.26 188.95,33.49 190.41,33.49 192.1,31.81
  IN6 w0.102: v2(225.12,35.11) 225.81,34.41 225.81,33.33 225.94,33.2 225.94,32.48 225.42,31.97 223.56,31.97 222.32,30.72 v2(222.32,30.28)
  BOTTOM w0.102: DE2.2 225.12,36.6 v1(225.12,35.72) v2(225.12,35.11)
  BOTTOM w0.122: v2(214,19.04) 213.66,18.7 UH1.BA47
EC_RTCRST: length 3.5
  TOP w0.102: UE5.34 289.58,23.61 RE650.1 288.86,23.93 288.76,23.83 QE5.2
EC_RX: length 41.4
  TOP w0.107: v2(289.76,38.51) 289.76,37.44 292.58,34.61 292.58,30.65 v1(293.69,29.54) 294.2,29.04 294.2,27.21 293.54,26.55 UE5.31
  IN1 w0.102: v2(309.7,44.65) 309.13,44.07 309.13,42.98 308.36,42.22 299.94,42.22 299.3,41.58 290.39,41.58 289.98,41.16 289.98,38.73 v2(289.76,38.51)
  BOTTOM w0.107: JWLAN.32 310.07,43.61 310.11,43.64 310.11,44.24 v2(309.7,44.65)
EC_SCI#: length 118.8
  TOP w0.089: v2(212.16,28.12) 212.16,28.31 v1(212.63,28.78) 212.73,28.88 215.13,28.88 RH521.2
  TOP w0.107: UE5.20 297.94,24.24 297.06,23.36 297.06,16.23 297.06,16.29 296.99,16.29 v2(296.99,16.24)
  IN2 w0.089: 219.18,28.12 218.07,28.12 218.01,28.18 217.36,28.18 217.31,28.13 215.24,28.13 214.87,28.5 212.54,28.5 v2(212.16,28.12)
  IN2 w0.102: v2(296.99,16.24) 296.45,16.78 293.93,16.78 293.81,16.9 293.81,16.91 293.02,17.69 280.83,17.69 277.88,20.65 277.31,21.21 276.58,21.21 276.5,21.3 275.96,21.83 274.27,21.83 271.69,24.41 271.69,25.55 270.89,26.34 266.84,26.34 266.38,25.89 261.37,25.89 260.41,24.92 260.4,24.92 259.99,24.51 258.29,24.51 256.09,26.71 248.16,26.71 248.08,26.63 246.77,25.32 246.77,25.13 246.77,25 246.49,24.72 246.49,24.28 246.49,20.91 246.18,20.6 246.18,19.71 246.03,19.56 246.03,19.26 245.4,18.63 245.21,18.63 236.86,18.63 235.78,17.55 230.57,17.55 228.1,20.02 227.17,20.94 227.17,21.81 225.29,23.69 225.29,25.08 222.68,27.69 219.84,27.69 219.62,27.92 219.38,27.92 219.18,28.12
  BOTTOM w0.122: UH1.AU26 211.66,28.82 212.16,28.31 v2(212.16,28.12)
EC_SMB_CK1: length 285.9
  TOP w0.114: v2(83.98,19.87) 83.84,19.72 83.84,18.96 83.52,18.65 83.52,16.66 PD2.2 83.9,16.21 83.52,15.84 83.52,15.72 83.27,15.48 82.38,15.48 82.19,15.28 82.19,14.84 PR19.2 ; v2(297.65,11.93) 297.82,11.75 297.82,11.41 298.01,11.22 298.01,10.93 297.94,10.86 UE5.77 297.94,8.67 297.82,8.55 RE90.4 ; v2(52.14,23.09) 52.28,23.23 52.61,23.23 PR721.1
  IN1 w0.081: v2(130.51,21.71) 130.48,21.71 130.33,21.86 130.33,22 135.72,27.46 153.16,27.46 155.12,25.5 155.44,25.5 171.49,25.5 184.76,12.22 185.25,12.22 186.87,10.6 192.88,10.6 193.14,10.34 198.17,10.34 198.42,10.09 225.46,10.09 225.68,10.31 229.58,10.31 230.69,11.42 239,11.42 240.94,13.36 251.03,13.36 251.52,13.36 252.59,14.43 255.2,14.43 257.02,12.61 271.71,12.61 272.13,13.03 272.29,13.19 280.15,13.19 283.7,16.74 290.33,16.74 292.73,14.34 296.24,14.34 297.82,12.75 297.82,12.1 v2(297.65,11.93)
  IN6 w0.081: v2(130.51,21.71) 130.32,21.52 130.32,21.28 129.96,20.91 127.26,20.91 124.96,18.62 93.8,18.62 91.46,20.96 86.24,20.96 85.65,20.37 83.96,20.37 83.8,20.21 83.8,20.05 v2(83.98,19.87) 83.98,18.84 81.54,16.4 74.9,16.4 72.92,14.42 62.12,14.42 59.68,16.86 59.68,18.83 58.64,19.87 56.4,19.87 52.99,23.27 52.32,23.27 v2(52.14,23.09)
EC_SMB_CK2: length 676.7
  TOP w0.114: v2(137.4,5.67) 137.21,5.48 137.21,5.13 DK2.2 137.4,4.55 137.31,4.55 137.19,4.44 137.19,4.28 137.77,3.71 139.8,3.71 139.99,3.51 139.99,3.26 v2(140.22,3.04) ; v2(130.06,27.58) 129.89,27.4 129.89,26.57 132.15,24.31 132.15,21.75 133.33,20.56 142.19,20.56 142.41,20.79 142.41,21.41 v2(142.21,21.61) ; RE90.2 298.82,8.47 298.74,8.55 UE5.79 298.74,10.89 298.82,10.96 298.82,13.54 297.55,14.8 297.55,20.61 298.4,21.45 298.4,21.9 298.28,22.01 298.06,22.01 v2(297.94,21.89) ; v2(13.98,53.78) 14.04,53.78 14.08,53.74 UU2.29
  IN1 w0.081: v2(297.94,21.89) 297.77,22.07 281.65,22.07 279.54,24.18 272.96,24.18 270.84,26.29 266.86,26.29 266.09,25.53 261.66,25.53 260.04,23.91 257.48,23.91 255.93,25.46 247.54,25.46 246.53,24.45 245.4,24.45 244.92,23.96 244.92,21.69 244.4,21.18 242.83,21.18 239.13,17.48 239.13,16.04 237.7,14.61 220.89,14.61 220.86,14.57 218.3,14.57 209.51,14.57 209,14.05 204.44,14.05 204.34,14.15 203.59,14.15 203.17,13.73 200.9,13.73 200.37,14.26 200.37,14.39 199.99,14.77 196.95,14.77 196.62,14.45 196.62,14 196.31,13.69 193.66,13.69 191.18,16.17 190.04,16.17 189.88,16.32 187.71,16.32 187.1,16.93 185.34,16.93 182.34,19.93 182.34,25.6 182.81,26.07 182.81,27.41 182.4,27.82 v2(182.1,27.82) ; v2(137.4,5.67) 137.21,5.49 137.21,5.27 137.29,5.19 137.9,5.19 138.16,5.45 138.16,6.15 138.93,6.92 138.93,16.54 142.4,20 142.4,21.43 v2(142.21,21.61) ; v2(205.13,152.96) 204.91,152.75 204.44,152.75 203.91,153.28 203.91,154.47 201.07,157.31 201.07,160.55 201.01,160.61 201.01,160.62 200.65,160.98 200.64,160.98 199.05,162.57 199.03,162.57 198.8,162.8 198.8,162.83 198.32,163.31 198.32,166 198.85,166.53 199.89,166.53 200.48,167.12 200.48,167.6 201.21,168.33 201.21,168.93 200.83,169.3 200.62,169.3 200.6,169.31 200.1,169.31 200.09,169.3 198.22,169.3 196.13,171.38 191.34,171.38 190.66,172.06 189.44,172.06 188.69,172.82 188.69,173.79 187.44,175.03 185.79,175.03 185.74,175.09 182.28,175.09 182.06,174.87 180.29,174.87 178.76,176.39 171.08,176.39 170.02,175.33 165.7,175.33 164.76,174.39 164.76,171.86 164.08,171.19 162.38,171.19 161.68,171.89 158.01,171.89 157.87,171.74 156.28,171.74 155.79,172.22 152.04,172.22 151.72,171.9 149.24,171.9 145.92,168.58 145.92,167.48 145.61,167.17 145.61,166.06 145.92,165.75 145.92,164.3 145.92,163.92 144.55,162.55 141.51,162.55 138.17,159.21 138.17,158.31 138.37,158.11 138.68,158.11 v2(138.82,157.97)
  IN3 w0.127: v2(182.1,27.82) 182.1,28.05 181.3,28.84 181.3,32.67 183.16,34.53 183.16,45.76 182.89,46.03 182.89,51.29 182.16,52.02 182.16,54.01 181.62,54.55 181.62,60.32 179.78,62.16 179.78,68.8 183.76,72.78 183.76,89.47 184.81,90.52 184.81,94.91 184.47,95.25 184.47,101.39 184.66,101.58 184.66,105.41 186.48,107.23 186.48,108.14 187.33,108.99 187.33,109.84 189.18,111.69 189.18,112.32 189.57,112.71 189.57,112.94 192.14,115.51 192.53,115.51 194.05,117.03 195.47,117.03 196.37,117.94 198.49,117.94 199.61,119.06 199.61,122.61 200.56,123.56 200.88,123.56 201.81,124.49 201.81,125.32 204.16,127.67 204.16,128.05 205.27,129.16 205.27,130.17 205.37,130.27 205.37,134.57 206.09,135.3 206.09,142.49 204.27,144.31 204.27,149.27 204.27,152.41 204.63,152.77 204.94,152.77 v2(205.13,152.96)
  IN4 w0.127: v2(142.21,21.61) 142.38,21.45 142.38,21.16 142.65,20.89 143.04,20.89 147.11,24.96 178.05,24.96 181.53,28.44 181.73,28.44 182.1,28.07 v2(182.1,27.82) 182.41,27.82 182.62,27.61 183.63,27.61 184.16,28.14 184.16,29.1 186.11,31.04 187.09,31.04 188.21,32.16 v2(189.94,32.69)
  IN6 w0.081: v2(130.06,27.58) 129.84,27.79 129.84,28.27 128.84,29.27 108.81,29.27 108.81,29.27 108.53,29.27 102.39,35.41 102.39,41.73 97.7,46.43 94.27,46.43 92.66,48.04 91.47,48.04 91.43,48.08 65.08,48.08 64.82,48.33 57.78,48.33 57.16,48.95 53.12,48.95 52.57,48.4 52.57,47.83 51.78,47.04 50.72,47.04 48.9,48.87 37.88,48.87 37.53,48.52 33.94,48.52 32.31,46.89 32.31,45.51 31.92,45.12 31.74,45.12 31.11,44.49 31.11,43.22 29.16,41.27 27.91,41.27 25.15,38.51 23.68,38.51 22.62,39.57 22.62,43.88 23.25,44.5 23.25,47.04 22.04,48.25 21.42,48.25 21.15,48.52 21.15,49.54 18.72,51.98 18.04,51.98 16.8,53.22 15.4,53.22 15.21,53.41 14.71,53.41 14.46,53.66 14.09,53.66 v2(13.98,53.78)
  BOTTOM w0.114: U2407.10 185.89,42.17 183.01,39.29 183.01,34.72 181.89,33.6 181.89,30.81 181.89,30.65 181.89,28.29 182.08,28.09 182.08,28.04 182.1,28.02 v2(182.1,27.82) ; v2(138.82,157.97) 138.61,158.17 137.7,158.17 137.51,157.98 UM8.50 ; QH5.1 189.67,32.96 v2(189.94,32.69) ; QG6.3 207.26,150.41 207.71,150.86 207.71,152.63 207.24,153.1 207.01,153.1 206.72,153.39 206.21,153.39 205.74,152.92 205.16,152.92 v2(205.13,152.96) 205.13,153.37 205.81,154.05 RT60.1 ; JPK.16 141.08,2.05 140.22,2.91 v2(140.22,3.04)
EC_SMB_DA1: length 286.5
  TOP w0.114: v2(298.23,11.93) 298.08,11.77 298.08,11.77 298.08,11.76 298.08,11.76 298.07,11.74 298.07,11.51 298.25,11.32 298.25,10.99 298.34,10.9 UE5.78 298.34,8.55 298.32,8.53 RE90.3 ; v2(52.14,23.68) 52.35,23.47 52.58,23.47 PR720.1 ; v2(83.4,19.87) 83.6,19.67 83.6,19.06 83.28,18.75 83.28,16.66 PD2.3 83.28,15.9 83.28,15.82 83.17,15.72 82.28,15.72 81.94,15.38 81.94,14.89 PR21.2
  IN1 w0.081: v2(298.23,11.93) 298.03,12.13 298.03,12.84 296.32,14.55 292.81,14.55 290.42,16.95 283.62,16.95 280.07,13.4 272.2,13.4 271.92,13.12 271.63,12.82 257.1,12.82 255.28,14.64 252.51,14.64 251.44,13.57 251.12,13.57 240.85,13.57 238.92,11.63 230.61,11.63 229.49,10.51 225.59,10.51 225.37,10.3 198.5,10.3 198.25,10.55 193.22,10.55 192.96,10.81 186.95,10.81 185.33,12.43 184.85,12.43 171.57,25.71 155.35,25.71 155.2,25.71 153.24,27.67 135.63,27.67 130.12,22.08 130.12,21.85 129.98,21.71 v2(129.93,21.71)
  IN6 w0.081: v2(52.14,23.68) 52.34,23.48 53.08,23.48 56.48,20.07 58.73,20.07 59.89,18.91 59.89,16.94 62.21,14.63 72.84,14.63 74.82,16.61 81.46,16.61 83.78,18.92 83.78,19.49 v2(83.4,19.87) 83.58,20.05 83.58,20.29 83.88,20.58 85.57,20.58 86.15,21.17 91.54,21.17 93.89,18.82 124.87,18.82 127.17,21.12 129.87,21.12 130.12,21.36 130.12,21.52 v2(129.93,21.71)
EC_SMB_DA2: length 667.4
  TOP w0.114: v2(14.3,52.66) 14.32,52.66 14.49,52.82 14.61,52.82 14.73,52.94 UU2.31 ; RE90.1 299.32,8.51 299.14,8.69 299.14,9.98 UE5.80 299.14,10.88 299.06,10.96 299.06,13.64 297.79,14.9 297.79,20.51 298.64,21.35 298.64,22 298.38,22.25 298.17,22.25 v2(297.94,22.48) ; v2(136.81,5.67) 136.97,5.52 136.97,5.12 DK2.3 136.78,4.55 136.84,4.55 136.95,4.44 136.95,4.18 137.67,3.46 139.7,3.46 139.75,3.41 139.75,3.09 v2(139.64,2.97) ; v2(142.79,21.61) 142.66,21.47 142.66,20.69 142.29,20.32 133.23,20.32 131.91,21.65 131.91,24.21 129.65,26.47 129.65,27.4 v2(129.47,27.58)
  IN1 w0.081: v2(136.81,5.67) 137,5.49 137,5.18 137.2,4.98 137.98,4.98 138.37,5.37 138.37,6.06 139.14,6.83 139.14,16.45 142.6,19.92 142.6,21.42 v2(142.79,21.61) ; v2(205.13,152.33) 204.91,152.54 204.35,152.54 203.7,153.19 203.7,154.39 200.86,157.23 200.86,160.47 200.8,160.53 200.8,160.54 200.57,160.77 200.56,160.77 198.96,162.36 198.95,162.36 198.59,162.72 198.59,162.75 198.11,163.23 198.11,166.09 198.76,166.74 199.8,166.74 200.27,167.21 200.27,167.69 201,168.41 201,168.84 200.75,169.09 200.53,169.09 200.52,169.11 200.19,169.11 200.17,169.09 198.13,169.09 196.05,171.17 191.26,171.17 190.57,171.85 189.36,171.85 188.48,172.73 188.48,173.7 187.35,174.83 185.71,174.83 185.66,174.88 182.37,174.88 182.15,174.66 180.2,174.66 178.68,176.19 171.16,176.19 170.11,175.13 165.79,175.13 164.97,174.31 164.97,171.78 164.17,170.98 162.29,170.98 161.59,171.68 158.1,171.68 157.95,171.53 156.19,171.53 155.71,172.01 152.13,172.01 151.81,171.69 149.33,171.69 146.13,168.49 146.13,167.39 145.82,167.08 145.82,166.15 146.13,165.84 146.13,164.39 146.13,163.83 144.64,162.34 141.6,162.34 138.38,159.12 138.38,158.4 138.46,158.31 138.58,158.31 v2(138.82,158.55) ; v2(297.94,22.48) 297.74,22.28 281.73,22.28 279.62,24.39 273.04,24.39 270.93,26.5 266.77,26.5 266,25.73 261.57,25.73 259.96,24.12 257.56,24.12 256.02,25.67 247.46,25.67 246.44,24.66 245.32,24.66 244.71,24.05 244.71,21.77 244.32,21.38 242.75,21.38 238.93,17.56 238.93,16.13 237.62,14.82 220.81,14.82 220.77,14.78 218.25,14.78 218.25,14.78 209.43,14.78 208.91,14.26 204.52,14.26 204.42,14.36 203.51,14.36 203.08,13.94 200.99,13.94 200.57,14.35 200.57,14.48 200.08,14.98 196.86,14.98 196.41,14.53 196.41,14.09 196.22,13.9 193.75,13.9 191.27,16.37 190.13,16.37 189.97,16.53 187.79,16.53 187.19,17.14 185.43,17.14 182.55,20.02 182.55,25.52 183.02,25.98 183.02,27.5 182.51,28 v2(182.51,28.23)
  IN3 w0.127: v2(205.13,152.33) 204.94,152.52 204.73,152.52 204.52,152.31 204.52,149.17 204.52,144.42 206.34,142.6 206.34,135.19 205.62,134.47 205.62,130.16 205.52,130.07 205.52,129.05 204.42,127.94 204.42,127.56 202.07,125.21 202.07,124.39 200.99,123.31 200.67,123.31 199.87,122.51 199.87,118.95 198.6,117.68 196.48,117.68 195.58,116.78 194.16,116.78 192.64,115.26 192.24,115.26 189.82,112.84 189.82,112.61 189.43,112.22 189.43,111.58 187.58,109.73 187.58,108.88 186.73,108.04 186.73,107.13 184.91,105.3 184.91,101.47 184.72,101.28 184.72,95.36 185.06,95.02 185.06,90.42 184.01,89.36 184.01,72.67 180.03,68.69 180.03,62.26 181.87,60.42 181.87,54.66 182.41,54.12 182.41,52.13 183.14,51.4 183.14,46.14 183.41,45.87 183.41,34.42 181.56,32.57 181.56,28.95 182.27,28.23 v2(182.51,28.23)
  IN4 w0.127: v2(142.79,21.61) 142.63,21.45 142.63,21.27 142.76,21.14 142.94,21.14 147.01,25.21 177.94,25.21 181.43,28.69 181.84,28.69 182.3,28.23 v2(182.51,28.23) 182.51,28.07 182.52,28.07 182.72,27.87 183.52,27.87 183.9,28.25 183.9,29.2 185.68,30.98 185.68,31.17 v2(186,31.49)
  IN6 w0.081: v2(129.47,27.58) 129.61,27.71 129.63,27.73 129.63,28.18 128.76,29.06 108.72,29.06 108.72,29.06 108.45,29.06 102.18,35.33 102.18,41.65 97.61,46.22 94.18,46.22 92.57,47.83 91.39,47.83 91.34,47.87 64.99,47.87 64.74,48.12 57.69,48.12 57.07,48.74 53.21,48.75 52.78,48.31 52.78,47.74 51.87,46.84 50.63,46.84 48.81,48.66 37.97,48.66 37.62,48.31 34.03,48.31 32.52,46.8 32.52,45.43 32.01,44.92 31.83,44.92 31.31,44.4 31.31,43.13 29.24,41.06 28,41.06 25.24,38.3 23.6,38.3 22.41,39.48 22.41,43.96 23.04,44.59 23.04,46.96 21.96,48.04 21.33,48.04 20.95,48.43 20.95,49.45 18.63,51.77 17.95,51.77 16.71,53.01 15.31,53.01 15.12,53.2 14.84,53.2 v2(14.3,52.66)
  BOTTOM w0.114: QG6.6 205.38,151.71 205.49,151.82 205.49,152.14 205.3,152.33 v2(205.13,152.33) 204.61,152.85 RT59.1 ; QH5.4 186.18,31.66 v2(186,31.49) ; UM8.49 137.51,158.48 137.57,158.41 138.68,158.41 v2(138.82,158.55) ; JPK.17 140.58,4.04 139.65,3.1 139.65,2.97 v2(139.64,2.97) ; U2407.9 186.39,42.33 183.25,39.19 183.25,34.62 182.13,33.49 182.13,30.81 182.13,30.65 182.13,28.39 182.28,28.23 v2(182.51,28.23)
EC_SRTCRST: length 74.3
  TOP w0.102: UE10.20 314.52,60.32 v2(314.44,60.24) 314.28,60.24 v1(313.99,59.95) ; v2(287.41,22.79) 287.41,22.74 287.49,22.66 287.49,22.28 287.36,22.15 RE658.1 287.03,22.15 286.83,22.36 286.83,23.73 286.72,23.83 QE5.5
  IN2 w0.102: v2(287.41,22.79) 287.41,22.48 289.33,20.55 290.52,20.55 291.03,20.04 293.05,20.04 293.22,19.88 296.29,19.88 296.77,19.4 296.77,19.4 297.11,19.05 301.73,19.05 302.07,19.4 302.07,19.83 302.2,19.96 302.44,20.2 302.97,20.2 303.1,20.07 303.2,19.97 303.24,19.97 303.35,20.08 303.54,20.08 305.34,20.08 305.57,20.31 306.66,20.31 310.03,23.68 v2(311.54,23.68)
  IN3 w0.102: v2(314.44,60.24) 314.44,60.23 314.05,59.85 314.05,57.71 314.11,57.66 314.11,52.92 317.53,49.49 317.53,47.46 316.49,46.42 316.49,45.39 315.2,44.1 315.2,40.16 314.87,39.83 314.87,37.62 315.48,37.01 315.48,32.31 313.76,30.6 313.76,28.31 313.19,27.74 313.19,25.33 v2(311.54,23.68)
EC_TX: length 40.9
  TOP w0.102: v1(310.85,45.51) RM31.1 309.83,45.23 310.14,44.91 310.14,44.5 v2(309.7,44.06)
  TOP w0.107: UE5.30 293.94,26.62 294.43,27.11 294.43,29.33 292.91,30.85 292.91,34.61 290.39,37.13 v2(290.39,38.54)
  IN1 w0.102: v2(290.39,38.54) 291.23,39.37 302.15,39.37 304.68,41.9 308.43,41.9 309.7,43.17 v2(309.7,44.06)
  BOTTOM w0.102: v2(309.7,44.06) 309.57,43.94 JWLAN.30
ECAGND: length 257.7
  TOP w0.254: LE2.2 288.22,11.67 288.43,11.88 CE35.1 288.71,12.26 288.36,12.61 CE33.2 288.36,13.26 288.04,13.58 285.19,13.58 284.93,13.83 v2(284.93,14.21) 284.93,15.83 282.7,18.06 v1(282.7,18.43) 282.7,18.47 280.15,21.02 280.15,28.2 280.29,28.34 280.29,29.9 v2(280.17,30.02) ; v2(153.94,111.43) 153.81,111.3 PH1.2
  IN1 w0.254: v2(294.76,11.23) 294.52,11.23 294.01,11.74 289.24,11.74 287.32,13.66 285.49,13.66 v2(284.93,14.21)
  IN2 w0.254: v2(280.17,30.02) 280.17,30.25 279.67,30.75 276.52,30.75 274.67,32.6 271.95,32.6 271.74,32.39 269.09,32.39 268.44,33.04 261.63,33.04 261.21,33.46 251.92,33.46 251.52,33.86 251.41,33.86 249.34,35.94 249.34,37.18 247.28,39.23 240.68,39.23 238.71,41.2 238.06,41.2 237.83,41.43 235.82,41.43 235.5,41.75 229.93,41.75 228.99,40.81 225.34,40.81 223.04,43.11 213.06,43.11 212.76,42.8 211.39,42.8 210.06,44.13 206.01,44.13 204.65,42.76 204.11,42.76 203.85,42.5 203.85,42.17 203.51,41.83 199.89,41.83 199.79,41.74 197.04,41.74 196.78,41.47 194.97,41.47 194.21,40.71 193.01,40.71 192.72,40.42 192.72,40.14 191.34,38.75 190.72,38.75 189.51,39.97 185.16,39.97 179.89,34.7 165.26,34.7 v2(163.9,36.06)
  IN3 w0.254: v2(163.9,36.06) 163.9,40 164.47,40.57 164.47,47.55 165.24,48.31 165.24,52.06 168.22,55.05 168.22,59.93 169.05,60.76 169.05,83.65 166.19,86.5 155.85,86.5 153.19,89.17 153.19,98.57 152.94,98.82 152.94,103.38 153.35,103.79 153.35,107.39 154.24,108.28 154.24,109.73 153.65,110.32 153.65,111.14 v2(153.94,111.43)
EDP_AUXN: length 126.9
  TOP w0.107: CV13.2 151.72,168.54 151.72,167.24 151.84,167.12 151.84,165.78 151.72,165.66 151.72,164.72 151.26,164.26 v2(150.12,164.26)
  IN1 w0.089: v2(225.56,113.78) 225.56,113.47 225.36,113.26 224.75,113.26 224.38,113.63 224.38,117.63 219.98,122.02 214.17,122.02 213.9,121.75 213.83,121.75 212.64,121.75 212.1,122.29 209.82,122.29 209.6,122.51 207.29,122.51 206.77,123.03 205.61,123.03 204.94,123.7 202.45,123.7 202.18,123.97 198.65,123.97 197.87,124.74 197.87,125.83 197.56,126.14 197.28,126.14 v2(197,126.42) ; v2(150.12,164.26) 150.12,164.51 150.22,164.61 152.69,164.61 152.81,164.73 155.95,164.73 157,163.68 157,163.31 157.57,162.75 157.57,161.35 158.93,159.98 161.27,159.98 162.85,158.41 162.85,154.71 166.43,151.12 171.01,151.12 171.03,151.1 183.92,151.1 184.16,150.86 184.68,150.86 187.68,147.86 187.68,145.12 188.75,144.05 188.75,139.76 190.95,137.56 192.55,137.56 v2(192.95,137.16)
  BOTTOM w0.089: v2(225.56,113.78) 225.7,113.78 UG9.BF11
  BOTTOM w0.107: v2(197,126.42) 197,126.41 196.69,126.1 192.76,126.1 192.03,126.83 192.03,126.87 191.61,127.3 191.57,127.3 190.51,128.36 190.51,133.29 190.62,133.4 190.91,133.4 191.02,133.29 191.02,132.86 RV670.1 191.4,132.81 191.4,133.15 191.59,133.34 191.84,133.34 193.05,134.55 193.05,135.6 192.16,136.49 192.16,137.31 192.39,137.54 192.57,137.54 v2(192.95,137.16)
EDP_AUXN_C: length 15.8
  TOP w0.107: CV13.1 151.77,169.59 151.77,169.71 152.28,170.22 153,170.22 153.64,170.86 153.64,173.27 156.03,175.67 156.03,178.73 157.95,180.65 157.95,181.21 158.12,181.38 JEDP.14
EDP_AUXP: length 126.9
  TOP w0.107: CV12.2 151.52,168.62 151.52,167.16 151.63,167.04 151.63,165.86 151.52,165.75 151.52,164.8 151.17,164.46 150.5,164.46 150.12,164.83 v2(149.88,164.83)
  IN1 w0.089: v2(192.95,137.74) 192.93,137.72 191.02,137.72 188.91,139.83 188.91,144.11 187.84,145.19 187.84,147.93 184.75,151.02 184.23,151.02 183.99,151.26 171.1,151.26 171.08,151.29 166.5,151.29 163.01,154.77 163.01,158.48 161.34,160.15 159,160.15 157.73,161.42 157.73,162.82 157.17,163.38 157.17,163.75 156.02,164.89 152.75,164.89 152.63,164.77 149.94,164.77 v2(149.88,164.83) ; v2(197,125.83) 197.14,125.97 197.49,125.97 197.71,125.76 197.71,124.68 198.58,123.8 202.12,123.8 202.38,123.54 204.87,123.54 205.54,122.86 206.7,122.86 207.22,122.34 209.53,122.34 209.75,122.13 212.03,122.13 212.57,121.59 213.76,121.59 213.97,121.59 214.24,121.86 214.93,121.86 214.95,121.85 219.91,121.85 224.2,117.55 224.2,113.56 224.67,113.08 225.5,113.08 v2(225.62,112.96)
  BOTTOM w0.089: v2(225.62,112.96) 225.62,113 UG9.BE11
  BOTTOM w0.107: v2(197,125.83) 196.93,125.9 192.68,125.9 v4(191.66,126.92) 190.31,128.27 190.31,133.38 190.53,133.6 190.85,133.6 190.95,133.71 190.95,134.08 RV669.1 191.4,134.19 191.4,133.73 191.59,133.54 191.76,133.54 192.85,134.63 192.85,135.51 191.96,136.4 191.96,137.39 192.31,137.74 v2(192.95,137.74)
EDP_AUXP_C: length 15.8
  TOP w0.107: JEDP.13 157.62,181.38 157.75,181.25 157.75,180.73 155.83,178.81 155.83,175.75 153.44,173.36 153.44,170.94 152.92,170.42 152.19,170.42 151.53,169.76 151.53,169.59 151.52,169.57 151.52,169.56 CV12.1
EDP_HPD: length 25
  IN1 w0.089: 217.19,119.58 216.82,119.58 215.74,118.5 215.74,118.06 216.86,116.93 217.8,116.93 218.64,116.09 v2(218.64,115.74)
  IN1 w0.102: 217.19,119.58 218.26,119.58 218.51,119.84 218.51,120.81 218.28,121.03 214.64,121.03 v2(214.45,121.22)
  BOTTOM w0.089: UG9.BH1 218.93,115.45 v2(218.64,115.74)
  BOTTOM w0.102: RG500.2 206.19,125.25 207.84,125.25 208.79,124.3 208.79,123.94 QG500.3 209,123.75 209.1,123.86 209.1,124.2 209.37,124.47 210.88,124.47 211.86,123.49 211.86,122.91 212.61,122.16 v1(213.51,122.16) v2(214.45,121.22)
EDP_HPD_CPU: length 2
  TOP w0.122: RH9.1 209.51,38.66 v2(209.51,38.23)
  BOTTOM w0.122: UH1.AN6 209.51,38.48 v2(209.51,38.23)
EDP_HPD_R: length 100.3
  TOP w0.102: v2(158.81,180.72) 159.12,181.03 JEDP.16
  IN1 w0.102: v2(158.81,180.72) 160.82,178.72 171.17,178.72 171.67,178.21 174.76,178.21 175.37,177.6 179.02,177.6 179.25,177.83 180.59,177.83 181.31,177.12 183.68,177.12 184.09,176.71 186.98,176.71 187.51,176.17 187.84,176.17 188.39,175.62 190.37,175.62 193.41,172.58 201.62,172.58 203.87,170.34 203.87,168.61 202.97,167.72 202.97,161.68 203.81,160.85 203.81,158.22 204.2,157.83 204.2,157.18 205.93,155.45 206.07,155.31 207.52,155.31 207.86,154.97 207.86,151.94 204.3,148.38 204.3,144.31 205.14,143.47 205.14,131.47 205.43,131.18 205.43,129.47 v2(205.94,128.96)
  BOTTOM w0.102: v2(205.94,128.96) v1(204.89,128.96) 204.4,128.96 203.86,129.51 RG508.2
EDP_RCOMP: length 8.1
  BOTTOM w0.152: 172.36,122.8 171.93,122.37 171.42,122.37 171.28,122.23 171.28,121.65 171,121.38 UC1.D37
  BOTTOM w0.381: 172.36,122.8 172.75,123.19 RC30.1 v1(177.62,123.19)
EDP_TXN0: length 127.1
  TOP w0.107: v2(147.71,167.88) 147.65,167.88 147.52,168.01 147.52,168.33 147.67,168.48 CV2.2
  IN1 w0.089: v2(227.59,121.28) 227.4,121.46 227.4,122.37 224.75,125.03 216.85,125.03 216.48,125.41 212.68,125.41 212.17,125.92 209.84,125.92 209.06,126.69 204.42,126.69 204.25,126.86 202.13,126.86 v2(201.86,127.14) ; v2(192.71,144.81) 192.38,145.14 191.77,145.14 191.58,145.32 191.58,147.55 185.74,153.4 185.22,153.4 184.63,153.98 182.76,153.98 182.35,154.39 168.98,154.39 167.64,155.72 166.25,155.72 165.43,156.54 165.43,159.42 163.42,161.43 163.42,163 162.47,163.96 162.47,168.27 160.15,170.59 156.24,170.59 155.45,171.38 154.24,171.38 152.84,169.98 148.93,169.98 147.3,168.35 147.3,168.22 147.64,167.88 v2(147.71,167.88)
  BOTTOM w0.089: UG9.BM17 230.23,118.19 230.45,118.19 230.56,118.3 230.56,118.38 230.69,118.51 230.69,118.88 230.2,119.37 230.2,120.64 v4(229.6,121.24) 228.76,122.08 227.38,122.08 227.29,121.99 227.29,121.54 227.55,121.28 v2(227.59,121.28)
  BOTTOM w0.107: v2(192.71,144.81) 192.79,144.73 193.02,144.73 193.13,144.84 193.13,145.06 193.23,145.16 194.34,145.16 196.51,142.99 198.41,142.99 199.57,141.84 199.57,141.8 199.97,141.4 200.01,141.4 200.41,140.99 200.41,134.42 202.05,132.78 202.05,129.64 202.43,129.26 202.43,127.03 202.33,126.93 202.05,126.93 201.86,127.12 v2(201.86,127.14)
EDP_TXN0_C: length 15
  TOP w0.107: CV2.1 147.53,169.24 147.53,169.52 148.99,170.98 148.99,171.48 149.33,171.82 149.33,176.14 150.22,177.03 150.22,179.07 151.95,180.79 151.95,181.2 152.12,181.38 JEDP.2
EDP_TXN1: length 121
  TOP w0.107: CV4.2 148.81,168.57 148.81,168.05 v2(148.98,167.88)
  IN1 w0.089: v2(201.84,127.73) 202.01,127.73 202.1,127.82 202.1,128.01 202.21,128.12 202.57,128.12 203.32,127.37 204.35,127.37 204.54,127.56 207.44,127.56 207.68,127.32 210.57,127.32 211.43,126.46 212.29,126.46 212.85,125.9 216.7,125.9 217.07,125.53 225.12,125.53 228.43,122.22 228.43,121.5 228.27,121.34 v2(228.21,121.28) ; v2(193.02,143.01) 192.62,143.4 191.96,143.4 190.89,144.47 190.89,147.35 185.47,152.76 184.95,152.76 184.56,153.15 182.19,153.15 181.59,153.75 175.42,153.75 174.82,153.15 173.68,153.15 173.08,153.75 168.34,153.75 167.2,154.89 166.17,154.89 164.79,156.27 164.79,159.16 162.72,161.23 162.72,162.8 162.44,163.09 162.01,163.09 161.81,162.89 160.68,162.89 160,163.57 160,165.15 157.05,168.1 153.99,168.1 152.78,169.31 149.58,169.31 148.64,168.37 148.64,168.21 148.96,167.88 v2(148.98,167.88)
  BOTTOM w0.089: UG9.BK17 230.17,117.03 229.8,117.4 229.8,117.88 229.66,118.02 229.66,120.01 229.1,120.57 228.68,120.57 228.21,121.05 v2(228.21,121.28)
  BOTTOM w0.107: v2(201.84,127.73) 201.7,127.88 201.12,127.88 200.83,128.17 200.83,132.44 199.21,134.06 199.21,140.31 197.37,142.15 195.28,142.15 194.05,143.39 193.49,143.39 193.35,143.25 193.35,143.04 193.25,142.94 193.09,142.94 v2(193.02,143.01)
EDP_TXN1_C: length 14.7
  TOP w0.107: JEDP.5 153.62,181.38 153.41,181.17 153.41,180.79 152.2,179.58 152.2,178.91 151.05,177.77 151.05,174.56 150.03,173.53 150.03,171.54 149.68,171.2 149.68,170.69 148.87,169.88 148.87,169.56 CV4.1
EDP_TXN2: length 126.2
  TOP w0.107: v2(149.61,165.73) 149.4,165.94 149.4,166.59 149.68,166.87 149.68,167.91 150.03,168.27 150.03,168.6 CV6.2
  IN1 w0.089: v2(199.49,127.2) 199.5,127.2 199.86,126.84 200.13,126.84 200.64,126.33 200.64,126.13 201.46,125.31 202.9,125.31 203.02,125.19 203.95,125.19 204.04,125.28 206.74,125.28 207.68,124.34 211.18,124.34 212.84,122.67 220.31,122.67 220.67,123.03 223.34,123.03 223.9,122.47 223.92,122.47 224.85,121.54 224.85,120.02 225.31,119.56 227.08,119.56 227.53,119.11 228.61,119.11 228.79,119.3 228.79,119.72 v2(228.42,120.09) ; v2(191.91,141.71) 191.7,141.91 191.37,141.91 191.03,142.25 191.03,143.25 190.09,144.19 190.09,147.25 185.21,152.13 184.69,152.13 184.43,152.39 172.51,152.39 171.81,153.09 167.07,153.09 164.16,156.01 164.16,158.9 161.8,161.25 159.74,161.25 158.9,162.09 158.9,164.88 156.34,167.44 153.68,167.44 152.45,168.67 151.27,168.67 149.2,166.6 149.2,166.13 149.6,165.73 v2(149.61,165.73)
  BOTTOM w0.089: UG9.BL15 228.68,117.46 228.51,117.46 228.42,117.55 228.42,117.82 228.51,117.91 228.94,117.91 229.08,118.05 229.08,119.62 228.99,119.71 228.52,119.71 228.35,119.89 228.35,120.02 v2(228.42,120.09)
  BOTTOM w0.107: v2(191.91,141.71) 192.15,141.71 192.26,141.82 192.26,141.98 192.37,142.09 193.76,142.09 194.45,141.41 197.14,141.41 198.38,140.17 198.38,133.5 200.08,131.8 200.08,127.14 199.95,127 199.69,127 199.5,127.2 v2(199.49,127.2)
EDP_TXN2_C: length 14.9
  TOP w0.107: CV6.1 150.05,169.57 150.05,170.05 150.77,170.77 150.77,172.8 153.28,175.32 153.28,178.78 154.95,180.46 154.95,181.21 155.12,181.38 JEDP.8
EDP_TXN3: length 113.7
  TOP w0.107: v2(151.12,166.36) 150.96,166.52 150.96,166.86 150.86,166.96 150.86,167.21 CV11.2
  IN1 w0.089: v2(151.12,166.36) 151.1,166.36 150.78,166.68 150.78,166.84 150.87,166.93 151.48,166.93 152.94,165.47 156.99,165.47 157.64,164.83 157.64,163.58 158.2,163.02 158.2,161.61 159.19,160.62 161.54,160.62 163.48,158.67 163.48,154.97 166.7,151.76 184.16,151.76 184.43,151.49 184.95,151.49 188.31,148.13 188.31,145.38 189.38,144.31 189.38,144 190.15,143.23 190.15,141.7 191.23,140.63 191.56,140.63 191.91,140.28 v2(191.91,140.26) ; v2(199.47,127.79) 199.5,127.79 199.86,128.15 200.05,128.15 200.53,127.66 200.53,127.14 201.11,126.57 201.11,126.35 201.68,125.78 202.4,125.78 202.47,125.84 203.95,125.84 204.02,125.78 207.19,125.78 207.72,125.25 209.28,125.25 209.48,125.05 211.81,125.05 212.67,124.19 214.11,124.19 214.23,124.07 224.35,124.07 226.19,122.24 226.2,122.24 226.32,122.12 226.32,121.02 226.69,120.65 227.33,120.65 227.52,120.47 227.52,120.39 v2(227.22,120.1)
  BOTTOM w0.089: UG9.BM14 228.22,118.4 228.22,118.54 227.48,119.27 227.48,119.88 227.26,120.1 v2(227.22,120.1)
  BOTTOM w0.107: v2(191.91,140.26) 192.29,140.64 194.19,140.64 195.67,139.17 195.67,139.13 196.07,138.73 196.1,138.73 196.21,138.62 196.21,137.96 196.8,137.37 196.8,133.62 198.57,131.85 198.57,128.09 198.8,127.87 199.4,127.87 v2(199.47,127.79)
EDP_TXN3_C: length 16.5
  TOP w0.107: JEDP.11 156.62,181.38 156.46,181.22 156.46,180.72 154.96,179.22 154.96,176.02 151.47,172.53 151.47,170.45 150.83,169.82 150.83,168.56 150.91,168.48 150.91,168.23 CV11.1
EDP_TXP0: length 127.1
  TOP w0.107: CV1.2 147.28,168.28 147.28,168.02 147.14,167.88 v2(147.07,167.88)
  IN1 w0.089: v2(227.04,121.28) 227.22,121.46 227.22,122.27 224.66,124.83 216.77,124.83 216.39,125.21 212.6,125.21 212.09,125.72 209.75,125.72 208.98,126.49 204.34,126.49 204.14,126.7 202,126.7 v2(201.86,126.55) ; v2(192.71,145.39) 192.62,145.3 191.83,145.3 191.75,145.39 191.75,147.62 185.81,153.56 185.29,153.56 184.7,154.14 182.83,154.14 182.42,154.55 169.04,154.55 167.71,155.88 166.32,155.88 165.59,156.61 165.59,159.49 163.58,161.5 163.58,163.07 162.63,164.03 162.63,168.34 160.22,170.75 156.31,170.75 155.52,171.55 154.17,171.55 152.77,170.15 148.87,170.15 147.14,168.42 147.14,168.14 147.19,168.08 147.19,168 v2(147.07,167.88)
  BOTTOM w0.089: v2(227.04,121.28) 227.11,121.35 227.11,122.06 227.3,122.25 228.83,122.25 229.45,121.64 229.51,121.64 229.99,121.15 229.99,121.1 230.37,120.72 230.37,119.45 230.87,118.95 UG9.BM18
  BOTTOM w0.107: v2(192.71,145.39) 192.74,145.37 194.42,145.37 196.59,143.2 198.5,143.2 v4(199.93,141.76) 200.62,141.07 200.62,134.5 202.26,132.87 202.26,129.72 202.64,129.34 202.64,126.95 202.41,126.72 202.03,126.72 v2(201.86,126.55)
EDP_TXP0_C: length 15
  TOP w0.107: CV1.1 147.33,169.32 147.33,169.6 148.79,171.07 148.79,171.57 149.13,171.91 149.13,176.22 150.02,177.11 150.02,179.15 151.74,180.87 151.74,181.26 151.62,181.38 JEDP.1
EDP_TXP1: length 121
  TOP w0.107: CV3.2 148.61,168.6 148.61,168.1 v2(148.4,167.88)
  IN1 w0.089: v2(201.84,128.32) 201.85,128.31 202.65,128.31 203.4,127.57 204.27,127.57 204.46,127.76 207.52,127.76 207.76,127.52 210.65,127.52 211.52,126.66 212.38,126.66 212.94,126.1 216.73,126.1 217.13,125.7 225.19,125.7 228.41,122.47 228.43,122.47 228.61,122.29 228.61,121.42 228.7,121.33 v2(228.97,121.33) ; v2(148.4,167.88) 148.47,167.96 148.47,168.01 148.47,168.44 149.51,169.47 152.85,169.47 154.06,168.27 157.12,168.27 160.17,165.22 160.17,163.64 160.75,163.06 161.74,163.06 161.94,163.25 162.51,163.25 162.89,162.87 162.89,161.3 164.96,159.23 164.96,156.34 166.24,155.06 167.27,155.06 168.41,153.92 173.15,153.92 173.75,153.32 174.76,153.32 175.35,153.92 181.81,153.92 182.25,153.47 182.25,153.41 182.34,153.32 184.63,153.32 185.02,152.93 185.54,152.93 191.05,147.41 191.05,144.54 192.03,143.56 192.99,143.56 v2(193.02,143.59)
  BOTTOM w0.089: v2(228.97,121.33) 228.66,121.33 228.57,121.25 228.57,120.96 228.77,120.77 229.18,120.77 229.86,120.09 229.86,118.12 230.06,117.92 230.32,117.92 230.45,117.8 230.45,117.67 230.32,117.55 UG9.BL17
  BOTTOM w0.107: v2(193.02,143.59) 194.14,143.59 195.37,142.36 197.46,142.36 199.42,140.4 199.42,134.15 201.04,132.53 201.04,128.25 201.21,128.08 201.61,128.08 201.66,128.14 201.66,128.14 v2(201.84,128.32)
EDP_TXP1_C: length 14.7
  TOP w0.107: JEDP.4 153.12,181.38 153.21,181.29 153.21,180.88 151.99,179.66 151.99,179 150.85,177.85 150.85,174.64 149.82,173.62 149.82,171.62 149.48,171.28 149.48,170.78 148.67,169.97 148.67,169.64 CV3.1
EDP_TXP2: length 126.2
  TOP w0.107: CV8.2 149.83,168.57 149.83,168.35 149.48,167.99 149.48,166.95 149.19,166.67 149.19,165.89 v2(149.03,165.73)
  IN1 w0.089: v2(199.5,126.61) 199.61,126.73 199.73,126.73 199.79,126.67 200.06,126.67 200.47,126.26 200.47,126.07 201.4,125.14 202.84,125.14 202.95,125.02 204.01,125.02 204.11,125.12 206.67,125.12 207.61,124.17 211.11,124.17 212.77,122.51 220.38,122.51 220.73,122.86 223.28,122.86 224.67,121.47 224.67,119.94 225.23,119.38 227.01,119.38 227.46,118.94 228.68,118.94 228.97,119.23 v2(228.97,120.09) ; v2(191.91,142.29) 191.69,142.08 191.44,142.08 191.19,142.32 191.19,143.32 190.25,144.26 190.25,147.32 185.28,152.29 184.76,152.29 184.49,152.56 172.58,152.56 171.88,153.26 167.14,153.26 164.32,156.08 164.32,158.97 161.87,161.42 159.81,161.42 159.06,162.16 159.06,164.95 156.41,167.61 153.75,167.61 152.52,168.84 151.2,168.84 149.03,166.67 v2(149.03,165.73)
  BOTTOM w0.089: UG9.BK15 228.77,117.11 229.12,117.46 229.12,117.83 229.26,117.98 229.26,118.03 229.26,119.8 v2(228.97,120.09)
  BOTTOM w0.107: v2(191.91,142.29) 193.84,142.29 194.53,141.61 197.23,141.61 198.59,140.25 198.59,133.58 200.29,131.88 200.29,127.05 200.03,126.8 199.68,126.8 v2(199.5,126.61)
EDP_TXP2_C: length 14.9
  TOP w0.107: JEDP.7 154.62,181.38 154.75,181.25 154.75,180.54 153.08,178.87 153.08,175.4 150.57,172.89 150.57,170.86 149.84,170.13 149.84,169.62 CV8.1
EDP_TXP3: length 113.8
  TOP w0.107: v2(150.54,166.36) 150.76,166.58 150.76,166.77 150.66,166.87 150.66,167.26 CV7.2
  IN1 w0.089: v2(150.54,166.36) 150.62,166.44 150.62,166.91 150.8,167.1 151.55,167.1 153.01,165.64 157.06,165.64 157.8,164.9 157.8,163.65 158.37,163.08 158.37,161.68 159.26,160.78 161.6,160.78 163.65,158.74 163.65,155.04 166.77,151.92 184.23,151.92 184.49,151.66 185.02,151.66 188.48,148.2 188.48,145.45 189.55,144.38 189.55,144.07 190.32,143.3 190.32,141.77 191.3,140.8 191.86,140.8 v2(191.91,140.85) ; v2(227.77,120.1) 227.69,120.18 227.69,120.54 227.4,120.83 226.76,120.83 226.5,121.1 226.5,122.19 226.33,122.36 226.33,122.38 224.44,124.27 214.31,124.27 214.19,124.39 212.75,124.39 211.89,125.25 209.56,125.25 209.36,125.44 207.8,125.44 207.27,125.97 204.1,125.97 204.03,126.04 202.38,126.04 202.32,125.97 201.77,125.97 201.3,126.44 201.3,126.65 200.73,127.22 200.73,127.74 200.13,128.35 199.5,128.35 v2(199.47,128.38)
  BOTTOM w0.089: UG9.BM15 228.47,118.55 228.47,118.57 227.68,119.36 227.68,120.01 v2(227.77,120.1)
  BOTTOM w0.107: v2(199.47,128.38) 199.16,128.07 198.88,128.07 198.78,128.18 198.78,131.93 197,133.71 197,137.46 196.41,138.04 196.41,138.71 v4(196.03,139.09) 194.28,140.85 v2(191.91,140.85)
EDP_TXP3_C: length 16.6
  TOP w0.107: CV7.1 150.71,168.28 150.71,168.4 150.63,168.47 150.63,169.9 151.27,170.54 151.27,172.61 154.76,176.1 154.76,179.3 156.26,180.8 156.26,181.25 156.12,181.38 JEDP.10
ELC_BOOT_MODE: length 155.5
  TOP w0.102: RE5.1 307.82,28.58 v1(307.36,28.11) 307.01,27.77 v2(306.65,27.77) ; UE1.44 313.01,14.58 313.27,14.32 313.27,13.69 313.51,13.45 315.06,13.45 315.16,13.55 315.16,16.06 v2(314.11,17.11) ; RE657.2 313.39,26.39 v2(314.27,25.52)
  IN2 w0.089: 219.18,27.77 219.02,27.93 217.88,27.93 217.81,28 217.44,28 217.39,27.95 214.9,27.95 v2(214.72,28.13)
  IN2 w0.102: v2(314.27,25.52) 313.17,24.41 313.17,22.99 312.92,22.75 311.52,22.75 309.75,20.98 309.57,20.98 309.57,20.99 308.31,20.99 308.07,20.75 308.07,20.03 306.1,18.06 305.55,18.06 305.22,17.73 301.64,17.73 301.4,17.49 301.4,17.47 301.39,17.46 301.39,17.16 301.38,17.15 301.38,17.14 301.13,16.88 300.18,16.88 299.36,16.05 298.85,16.05 298.52,16.39 297.84,16.39 297.21,15.76 296.71,15.76 295.92,16.55 293.84,16.55 293.58,16.81 292.92,17.47 280.74,17.47 277.22,20.98 276.49,20.98 276.27,21.2 275.87,21.61 274.18,21.61 270.94,24.83 269.86,24.83 269.67,24.83 268.47,23.63 266.43,23.63 266.04,24.02 266.04,24.21 266.04,24.95 265.33,25.66 261.47,25.66 260.5,24.69 260.5,24.69 260.09,24.28 258.2,24.28 256,26.48 248.25,26.48 248.18,26.41 247,25.23 247,24.9 246.72,24.62 246.72,24.38 246.72,24.38 246.72,20.82 246.41,20.51 246.41,19.62 246.26,19.47 246.26,19.36 246.26,19.17 245.48,18.39 237.01,18.39 235.93,17.32 230.47,17.32 228,19.79 228,19.79 226.95,20.85 226.95,21.71 225.07,23.59 225.07,24.99 222.59,27.46 219.75,27.46 219.52,27.69 219.26,27.69 219.18,27.77
  IN4 w0.102: v2(314.11,17.11) 314.12,17.11 314.36,17.35 314.36,18.76 313.44,19.68 313.44,24.69 v2(314.27,25.52)
  IN6 w0.102: v2(314.27,25.52) 314.14,25.64 312.3,25.64 312.02,25.37 308.5,25.37 306.65,27.22 v2(306.65,27.77)
  BOTTOM w0.122: UH1.BD29 214.88,27.97 v2(214.72,28.13)
ELC_EC#: length 309.3
  TOP w0.102: 202.59,172.38 204.96,172.38 205.06,172.48 QE22.5 ; 202.59,172.38 QE13.5 ; 202.59,172.38 202.56,172.35 201.26,172.35 v2(201.05,172.14) 200.11,173.08 QE21.5 ; UE10.6 318.76,57.03 v2(319.1,56.7)
  IN4 w0.102: v2(201.05,172.14) 200.47,172.72 198.32,172.72 197.79,172.19 197.79,166.21 196.55,164.98 196.55,164.15 191.93,159.52 191.93,155.02 193.32,153.64 193.32,151.54 196.4,148.46 196.67,148.19 196.8,148.05 196.8,128.34 196.17,127.71 196.17,126.91 195.61,126.36 195.61,125.76 195.47,125.61 195.47,125.61 192.85,122.99 192.85,120.84 191.33,119.33 191.33,116.43 189.21,114.31 189.21,114.06 189.21,111.99 187.64,110.42 187.64,108.88 186.91,108.15 186.91,107.1 187.27,106.75 187.27,100.56 186.89,100.18 186.89,99.28 189.7,96.47 189.7,82.27 189,81.58 189,79.25 189.56,78.69 189.56,71.24 192.43,68.37 192.43,67.5 193.15,66.78 198,66.78 200.72,64.06 200.72,62.25 201.85,61.12 201.85,55.34 203.02,54.17 207.61,54.17 208.82,52.96 208.82,48.99 210.04,47.77 210.04,47.07 211.48,45.63 213.45,45.63 214.25,44.83 225.48,44.83 225.75,44.55 228.5,44.55 228.86,44.19 235.78,44.19 236.29,44.69 239.68,44.69 240.27,44.1 258.7,44.1 259.5,43.3 266.09,43.3 272.93,36.45 273.3,36.45 273.53,36.22 277.49,36.22 278.31,35.4 281.54,35.4 282.83,36.69 291.03,36.69 292.36,35.36 319.29,35.36 319.79,35.87 322.4,35.87 322.59,35.68 v2(322.59,35.32)
  BOTTOM w0.102: v2(319.1,56.7) 319.26,56.53 319.26,56.4 320.37,55.3 320.37,52.05 320.55,51.86 320.55,50.97 316.24,46.66 316.24,45.9 317.72,44.42 318.89,44.42 320.72,42.59 321.46,42.59 321.47,42.57 322.09,41.95 v1(322.09,41.29) 322.09,39.9 321.29,39.1 321.29,38.52 322.59,37.22 v2(322.59,35.32)
ELC_RESET: length 301.2
  TOP w0.102: v2(325.83,9.83) 325.83,9.45 325.7,9.33 322.84,9.33 322.51,9.66 RE4.1 322.51,10.04 321.95,10.6 321.51,10.6 320.3,9.39 319.66,9.39 319.24,8.97 CE8.1 318.28,9.9 316.9,9.9 316.79,10 UE1.7
  IN3 w0.089: v2(219.03,26) 219.14,25.89 219.14,25 217.81,23.68 215.72,23.68 214.96,24.44 212.29,24.44 211.72,23.87 210.38,23.87 210,24.25 209.69,24.25 208.78,23.34 208.72,23.34 207.72,22.34 198.7,22.34 197.18,20.82 196.54,20.82 196.16,21.2 194.76,21.2 194.45,21.52 194.45,23.8 195.27,24.63 195.72,24.63 v2(195.91,24.82)
  IN4 w0.089: v2(195.91,24.82) 195.91,25.39 196.54,26.03 196.54,26.79 197.08,27.33 197.08,29.49 195.58,30.99 195.2,30.99 194.92,31.27 192.31,31.27 192.1,31.49
  IN4 w0.102: v2(325.83,9.83) 325.7,9.96 325.7,11.13 325.6,11.23 323.8,11.23 322.97,12.06 322.97,13.24 323.35,13.62 323.35,14.21 323.1,14.47 321.19,14.47 320.94,14.21 317.83,14.21 316.32,15.73 313.38,15.73 312.2,16.91 309.07,16.91 308.67,16.51 307.3,16.51 305.72,14.94 304.53,14.94 302.81,16.65 301.28,16.65 301.13,16.5 301.13,15.89 299.92,14.68 295.32,14.68 290.18,19.83 284.83,19.83 282.84,17.83 279.75,17.83 277.92,19.66 272.67,19.66 271.51,18.51 271.13,18.51 267.95,18.51 267.24,17.8 266.3,17.8 265.75,17.25 264.15,17.25 264,17.4 260.31,17.4 258.52,15.62 251.54,15.62 250.69,14.76 241.65,14.76 240.99,15.42 237.44,15.42 236.17,16.69 232.55,16.69 232.23,16.37 225.4,16.37 224.06,17.71 222.84,17.71 222.69,17.55 221.6,17.55 221.24,17.2 221.24,14.79 220.42,13.96 217.95,13.96 215.43,11.45 210.21,11.45 209.41,12.25 207.13,12.25 206.87,12.51 206.73,12.64 202.99,12.64 202.72,12.37 192.79,12.37 191.32,10.9 191.05,10.63 187.26,10.63 182.68,15.21 180.64,15.21 178.08,15.21 v2(177,16.29) ; 192.1,31.49 190.32,33.26 189.2,33.26 188.97,33.04 188.82,33.04 185.52,33.04 184.67,32.19 182.06,32.19 177.17,27.3 v2(168.98,27.3)
  BOTTOM w0.089: UH1.BD30 214.9,27.13 215.05,27.27 215.36,27.27 215.51,27.13 215.92,27.13 215.96,27.08 216.55,27.08 216.71,26.91 217.05,26.91 217.46,26.5 v1(218.35,26.5) 218.37,26.5 218.77,26.1 218.93,26.1 v2(219.03,26)
  BOTTOM w0.102: v2(177,16.29) 169,24.28 169,27.28 v2(168.98,27.3) 169,27.31 JELC1.4 169,31.21 166.86,33.35 154.75,33.35 154.15,32.76 154.15,27.87 153.58,27.3 JELC2.10
