# Allegro board LAF551PR10-0221.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
NCP81215MNTXG_QFN52_6X6
  oval 0.838x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 27(6.15,-4.8) 28(6.15,-4.4) 29(6.15,-4) 30(6.15,-3.6) 31(6.15,-3.2) 32(6.15,-2.8) 33(6.15,-2.4) 34(6.15,-2) 35(6.15,-1.6) 36(6.15,-1.2) 37(6.15,-0.8) 38(6.15,-0.4) 39(6.15,0)
  oval 0.203x0.838 smd: 14(0.675,-5.475) 15(1.075,-5.475) 16(1.475,-5.475) 17(1.875,-5.475) 18(2.275,-5.475) 19(2.675,-5.475) 20(3.075,-5.475) 21(3.475,-5.475) 22(3.875,-5.475) 23(4.275,-5.475) 24(4.675,-5.475) 25(5.075,-5.475) 26(5.475,-5.475) 40(5.475,0.675) 41(5.075,0.675) 42(4.675,0.675) 43(4.275,0.675) 44(3.875,0.675) 45(3.475,0.675) 46(3.075,0.675) 47(2.675,0.675) 48(2.275,0.675) 49(1.875,0.675) 50(1.475,0.675) 51(1.075,0.675) 52(0.675,0.675)
  rect 4.699x4.699 smd: 53(3.075,-2.4)
NCP302045MNTXG_PQFN33_5X5
  oval 0.305x0.711 smd: 1(0,-0.051) 2(0.5,-0.051) 3(1,-0.051) 4(1.5,-0.051) 5(2,-0.051) 6(2.5,-0.051) 7(3,-0.051) 8(3.5,-0.051)
  custom 0.32x0.32 smd: 9(3.135,1.215)
  custom 0.543x0.543 smd: 10(2.225,3.215)
  rect 3.81x0.711 smd: 11(1.75,4.851)
  rect 0.711x1.295 smd: 12(-0.701,3.65)
  oval 0.711x0.305 smd: 13(-0.701,2.65) 14(-0.701,2.15) 15(-0.701,1.65) 16(-0.701,1.15) 17(-0.701,0.65)
  rect 1.422x1.118 smd: 18(0.7,1.215)
  rect 0.584x0.356 smd: 19(0.09,2.625)
NL17SZ08DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PI5A3158BZAEX_TDFN12_1X3
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(2.5,1.2) 8(2,1.2) 9(1.5,1.2) 10(1,1.2) 11(0.5,1.2) 12(0,1.2)
PI6CEQ20200LIEX_TSSOP20
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(5.85,5.8) 12(5.2,5.8) 13(4.55,5.8) 14(3.9,5.8) 15(3.25,5.8) 16(2.6,5.8) 17(1.95,5.8) 18(1.3,5.8) 19(0.65,5.8) 20(0,5.8)
R0201_0OHM
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
R_2512_4P
  custom 0.826x0.826 smd: 1(0,0) 4(0,-8.687)
  rect 0.508x3.2 smd: 2(0,-2.108) 3(0,-6.579)
RB520SM-30T2R_EMD2-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RHU002N06_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
RL-3264-9W-R005-FNH_2512_2512
  rect 2.108x2.489 smd: 1(0,0) 4(1.35,-4.3)
  rect 1.041x2.489 smd: 2(1.875,0) 3(-0.525,-4.3)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8207PGQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT8812AGQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9059GSP_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.157) 6(2.54,5.157) 7(1.27,5.157) 8(0,5.157)
  rect 2.311x2.311 smd: 9(1.905,2.579)
RT9193-18GB_SOT23-5
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0,2.6)
SANTA_130456-512_13P
  round 1.295 hole 0.889: 1(0,0) 2(1.02,1.1) 3(2.04,0) 4(3.06,1.1) 5(4.08,0) 6(5.1,1.1) 7(6.12,0) 8(7.14,1.1)
  round 1.397 hole 0.991: 9(-3.395,1.1) 10(-1.105,2.6) 11(8.245,2.6) 12(9.39,1.1) 13(10.535,2.6)
  oval 1.473x3.15 hole 0.711x2.388: 14(13.095,-6.42) 16(-5.955,-6.42)
  rect 0.889x1.803 smd: 15(12.32,-9.92) 17(-5.18,-9.92)
SDAN_608015-010232_10P
  round 1.168 hole 0.914: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-8,-1.5) 6(-5.75,-1.5) 7(-3.5,-1.5) 8(-1.25,-1.5) 9(1,-1.5)
  round 1.016 hole 0.762: 10(-8.2,-2.77)
  oval 1.372x3.15 hole 0.61x2.388: 11(-9.9,-1.59) 12(2.9,-1.59)
  oval 1.372x2.667 hole 0.61x1.905: 13(-11.4,-10.35) 14(4.4,-10.35)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI2301CDS-T1-GE3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
SI3456DDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI3457CDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SIC632CDT1GE3_POWERPAK31_5X5
  oval 0.889x0.305 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 11(5,-3.5) 12(5,-3) 13(5,-2.5) 14(5,-2) 15(5,-1.5) 16(5,-1) 17(5,-0.5) 18(5,0)
  custom 0.337x0.337 smd: 9(1.25,-3.185)
  custom 0.549x0.549 smd: 10(3.327,-2.275)
  oval 0.305x0.889 smd: 19(4.25,0.75) 20(3.75,0.75) 21(3.25,0.75) 22(2.75,0.75) 23(2.25,0.75) 24(1.75,0.75) 25(1.25,0.75) 26(0.75,0.75)
  rect 0.406x0.559 smd: 27(2.6,-0.275)
  rect 1.118x1.422 smd: 28(1.315,-0.71)
SLG4U41821VTR_STQFN20_2X3
  oval 0.813x0.203 smd: 1(0,0) 2(0,-0.4) 6(0,-2) 7(0,-2.4) 11(2.175,-2.4) 12(2.175,-2) 16(2.175,-0.4) 17(2.175,0)
  oval 1.295x0.203 smd: 3(0.238,-0.8)
  oval 1.092x0.203 smd: 4(0.138,-1.2) 5(0.138,-1.6) 13(2.038,-1.6) 14(2.038,-1.2) 15(2.038,-0.8)
  oval 0.203x1.092 smd: 8(0.688,-2.65) 9(1.088,-2.65) 10(1.488,-2.65) 18(1.488,0.25) 19(1.088,0.25) 20(0.688,0.25)
SN74CBT3257CPWR_TSSOP16
  oval 0.381x1.651 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(4.55,5.775) 10(3.9,5.775) 11(3.25,5.775) 12(2.6,5.775) 13(1.95,5.775) 14(1.3,5.775) 15(0.65,5.775) 16(0,5.775)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
STARC_111H30-000000-G4-R_30P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0)
  rect 1.194x2.692 smd: 31(-2.4,1.95) 35(16.9,1.95)
  rect 2.311x1.295 smd: 32(0.85,3.9) 33(7.25,3.9) 34(13.65,3.9)
STM32F070CBT6TR_LQFP48_7X7
  oval 1.753x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 9(0,-4) 10(0,-4.5) 11(0,-5) 12(0,-5.5) 25(8.654,-5.5) 26(8.654,-5) 27(8.654,-4.5) 28(8.654,-4) 29(8.654,-3.5) 30(8.654,-3) 31(8.654,-2.5) 32(8.654,-2) 33(8.654,-1.5) 34(8.654,-1) 35(8.654,-0.5) 36(8.654,0)
  oval 0.254x1.753 smd: 13(1.577,-7.077) 14(2.077,-7.077) 15(2.577,-7.077) 16(3.077,-7.077) 17(3.577,-7.077) 18(4.077,-7.077) 19(4.577,-7.077) 20(5.077,-7.077) 21(5.577,-7.077) 22(6.077,-7.077) 23(6.577,-7.077) 24(7.077,-7.077) 37(7.077,1.577) 38(6.577,1.577) 39(6.077,1.577) 40(5.577,1.577) 41(5.077,1.577) 42(4.577,1.577) 43(4.077,1.577) 44(3.577,1.577) 45(3.077,1.577) 46(2.577,1.577) 47(2.077,1.577) 48(1.577,1.577)
SW_TST71-N-220-T170-S017_2P
  rect 0.61x1.499 smd: 1(0,0) 2(3.2,0)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8286RAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
TAI-T_UHP252010BF-3R3M_2P
  rect 0.889x2.108 smd: 1(0,0) 2(1.7,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TC7SZ14FU_SSOP5
  oval 0.381x1.448 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.675) 5(0,1.675)
TE_2260531-1_46P
  oval 0.508x1.803 smd: 1(0,0) 2(0.8,0) 45(18.6,0) 46(19.4,0)
  oval 0.203x1.803 smd: 3(1.55,0) 4(1.95,0) 5(2.35,0) 6(2.75,0) 7(3.15,0) 8(3.55,0) 9(3.95,0) 10(4.35,0) 11(4.75,0) 12(5.15,0) 13(5.55,0) 14(5.95,0) 15(6.35,0) 16(6.75,0) 17(7.15,0) 18(7.55,0) 19(7.95,0) 20(8.35,0) 21(8.75,0) 22(9.15,0) 23(9.55,0) 24(9.95,0) 25(10.35,0) 26(10.75,0) 27(11.15,0) 28(11.55,0) 29(11.95,0) 30(12.35,0) 31(12.75,0) 32(13.15,0) 33(13.55,0) 34(13.95,0) 35(14.35,0) 36(14.75,0) 37(15.15,0) 38(15.55,0) 39(15.95,0) 40(16.35,0) 41(16.75,0) 42(17.15,0) 43(17.55,0) 44(17.95,0)
  custom 0.688x0.688 hole 0.889x2.007: 47(-6.7,0) 49(25.8,0)
  oval 1.651x2.769 hole 0.889x2.007: 48(-6.7,-4.6) 50(25.8,-4.6)
TLC59116FIRHBR_VQFN32_5X5
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 17(3.5,5.1) 18(3,5.1) 19(2.5,5.1) 20(2,5.1) 21(1.5,5.1) 22(1,5.1) 23(0.5,5.1) 24(0,5.1)
  oval 0.889x0.254 smd: 9(4.3,0.8) 10(4.3,1.3) 11(4.3,1.8) 12(4.3,2.3) 13(4.3,2.8) 14(4.3,3.3) 15(4.3,3.8) 16(4.3,4.3) 25(-0.8,4.3) 26(-0.8,3.8) 27(-0.8,3.3) 28(-0.8,2.8) 29(-0.8,2.3) 30(-0.8,1.8) 31(-0.8,1.3) 32(-0.8,0.8)
  rect 3.454x3.454 smd: 33(1.75,2.55)
TP0610K-T1-E3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
TPC12
  round 0.305 smd: 1(0,0)
TPS2546RTER_QFN16_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.651x1.651 smd: 17(0.75,1.55)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS25810RVCR_QFN20_4X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 11(2.5,3.1) 12(2,3.1) 13(1.5,3.1) 14(1,3.1) 15(0.5,3.1) 16(0,3.1)
  oval 0.889x0.254 smd: 7(3.3,0.8) 8(3.3,1.3) 9(3.3,1.8) 10(3.3,2.3) 17(-0.8,2.3) 18(-0.8,1.8) 19(-0.8,1.3) 20(-0.8,0.8)
  rect 2.591x1.6 smd: 21(1.25,1.55)
TPS51212DSCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51225CRUKR_QFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
TPS65982_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TVWDF1004AD0_DFN9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
UP1666QQKF_WQFN20_3X3
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 11(3.1,-1.6) 12(3.1,-1.2) 13(3.1,-0.8) 14(3.1,-0.4) 15(3.1,0)
  oval 0.203x0.889 smd: 6(0.75,-2.35) 7(1.15,-2.35) 8(1.55,-2.35) 9(1.95,-2.35) 10(2.35,-2.35) 16(2.35,0.75) 17(1.95,0.75) 18(1.55,0.75) 19(1.15,0.75) 20(0.75,0.75)
  rect 1.6x1.6 smd: 21(1.55,-0.8)
UP9511PQGJ_VQFN40_5X5
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 21(5.1,-3.6) 22(5.1,-3.2) 23(5.1,-2.8) 24(5.1,-2.4) 25(5.1,-2) 26(5.1,-1.6) 27(5.1,-1.2) 28(5.1,-0.8) 29(5.1,-0.4) 30(5.1,0)
  oval 0.203x0.889 smd: 11(0.75,-4.35) 12(1.15,-4.35) 13(1.55,-4.35) 14(1.95,-4.35) 15(2.35,-4.35) 16(2.75,-4.35) 17(3.15,-4.35) 18(3.55,-4.35) 19(3.95,-4.35) 20(4.35,-4.35) 31(4.35,0.75) 32(3.95,0.75) 33(3.55,0.75) 34(3.15,0.75) 35(2.75,0.75) 36(2.35,0.75) 37(1.95,0.75) 38(1.55,0.75) 39(1.15,0.75) 40(0.75,0.75)
  rect 3.505x3.505 smd: 41(2.55,-1.8)
W25Q80DVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q80EWSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q128FVSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
Y_5YEA27000163IF50Q5_4P
  rect 1.295x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_CM31532768DZFT_2P
  rect 1.092x1.905 smd: 1(0,0) 2(2.5,0)
Y_FSX3M-25PM20FDO_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_XRCGB25M000F2P18R0_4P
  rect 0.762x0.711 smd: 1(0,0) 2(1.35,0) 3(1.35,1) 4(0,1)
YUQIU_PJ741-F07J1BE-C_6P-T
  oval 0.991x1.803 hole 0.61x1.397: 1(0,0) 2(9.5,-5.5) 3(0,-5.2) 4(0,-7.8) 5(9.5,0) 6(9.5,-2.75) 7(0,-2.65)

## Nets
1.2V_B+: PC200.1 PC201.1 PC202.1 PC203.1 PC208.1 PC216.1 PJP203.2 PQ200.5 PR206.1
1.8VS_PGOOD: PR820.1 PU802.9
1V8_AON_EN: CG487.1 QG503.2 RG70.2 RG576.1 UG12.3 UG25.4 UG31.14
1V8_ENP: PC811.1 PR807.1 PR808.1 PR817.2 PU802.11
1V8_MAIN_EN: DG3.2 DG6.1 DG7.2 QG504.2 RG71.2 RG549.1 RG550.1 RG571.2 UG12.5 UG26.2 UG31.16
1V8_MAIN_NVVDD2_EN: CG482.1 DG6.2 RG550.2 UG28.2
3/5V_B+: PC100.1 PC102.1 PC103.1 PC104.1 PC113.1 PC114.1 PC118.1 PC119.1 PL100.2 PQ100.5 PQ102.5 PU100.12
3V3_SYS_EN: CG240.1 QG505.2 RG515.2 RG545.2 UG14.4 UG31.15
3V_5V_EN: PC112.1 PR100.2 PR112.2 PR113.2 PR114.2 PR115.2 PR116.1
3V_5V_EN2: PD101.1 PR115.1
3V_ELC_ON: RE83.1 UE5.128 UE9.4
3V_EN: PR100.1 PU100.6
3VS: C2524.1 J5.2 U17.8 U17.9
3VS_GATE: C258.1 R174.2 U17.5
5V_EN: PR112.1 PU100.20
5VCC: PC6014.1 PR6032.1 PR6035.2 PR6070.1 PU6000.12
5VS: C2523.1 J4.2 U17.13 U17.14
5VS_GATE: R182.2 U17.3
+0.6VS: CD12.1 CD13.1 CD14.1 CD15.1 CD32.1 CD88.1 CD89.1 CD90.1 JDIMM1.258 JDIMM2.258 PJP202.2
+0.6VSP: PC205.1 PC206.1 PJP202.1 PU201.2 PU201.20
+0.9V_CIO: CT78.1 CT79.1 CT80.1 UT1.R8 UT1.R9 UT1.R11 UT1.R12
+0.9V_DP: CT54.1 CT57.1 CT58.1 CT59.1 CT60.1 CT61.1 CT62.1 UT1.L6 UT1.L8 UT1.L11 UT1.L12 UT1.M6 UT1.M8 UT1.T11 UT1.T12 UT1.V11 UT1.V12 UT1.V13
+0.9V_LVR_OUT: CT81.1 CT82.1 CT83.1 CT84.1 UT1.F18 UT1.H11 UT1.H18 UT1.J11
+0.9V_PCIE: CT55.1 CT70.1 CT71.1 CT72.1 UT1.L18 UT1.L19 UT1.M13 UT1.M15 UT1.M16 UT1.M18 UT1.N18 UT1.N19
+0.9V_SVR: CT63.1 CT64.1 CT65.1 CT66.1 CT67.1 CT68.1 CT69.1 CT73.1 CT74.1 CT75.1 LT1.2 UT1.E12 UT1.E13 UT1.F11 UT1.F12 UT1.F13 UT1.F15 UT1.J9 UT1.L9 UT1.M9
+0.9V_USB: CT56.1 CT77.1 UT1.R15 UT1.R16
+1.0VS_VGA_PGOOD: PR821.1 PU800.9 UG27.2
+1.0VS_VGAP: PC804.1 PC805.1 PC809.1 PC815.1 PC816.1 PJP801.1 PL800.2 PR804.1
+1.2V_DDR: C2518.1 CD1.1 CD2.1 CD5.1 CD6.1 CD7.1 CD8.1 CD11.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD24.1 CD25.1 CD26.1 CD33.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 CD81.1 CD82.1 CD83.1 CD84.1 CD85.1 CD86.1 CD87.1 CH118.1 CH119.1 CH120.1 CH121.1 CH122.1 CH123.1 CH124.1 CH125.1 CH126.1 CH127.1 CH128.1 CH129.1 CH130.1 CH131.1 CH132.1 CH197.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 PJP200.2 PJP201.2 RD35.1 RH206.1 RH207.1 RH530.2 UC1.AA6 UC1.AE12 UC1.AF5 UC1.AF6 UC1.AG5 UC1.AG9 UC1.AJ12 UC1.AL11 UC1.AP6 UC1.AP7 UC1.AR6 UC1.AR12 UC1.AT12 UC1.AW6 UC1.AY6 UC1.J5 UC1.J6 UC1.K6 UC1.K12 UC1.L6 UC1.L12 UC1.R6 UC1.T6 UC1.W6 UC1.Y12 UC2.5 UZ21.1 UZ21.2
+1.2V_VCCPLL_OC: C11.1 CC36.1 CC37.1 RH530.1 UC1.BH13 UC1.BJ13 UC1.G11 UZ21.7 UZ21.8
+1.2VP: PC209.1 PC215.1 PJP200.1 PJP201.1 PL201.1 PR205.2 PU201.5 PU201.19
+1.5VS_SNB1: PC8210.1 PR8204.2
+1.8V_PRIM: CH176.1 CH233.1 RH218.2 RH595.2 RH599.1 UH1.AG19 UH1.AG20 UH1.AN15 UH1.AR15 UH1.BB11
+1.8VA_TBTA_LDO: CT100.1 UT4.K1
+1.8VALW: CG288.1 CU78.1 CV20.1 CV1056.1 PJP803.2 PR6037.2 PR6406.2 RG70.1 RH180.1 RH181.1 RH182.1 RH599.2 RH603.1 UG12.1 UG12.2 UU8.1 UU8.2 UX1.5 UX2.5
+1.8VD_TBTA_LDO: CT99.1 UT4.A2
+1.8VS_AUDIO: CA58.1 CA59.1 CA60.1 JIO.7 LA3.2 LA4.2 LA5.2 PJP9001.2 UA4.17 UA4.21
+1.8VSP: PC812.1 PC813.1 PC819.1 PC820.1 PC824.1 PJP803.1 PL801.2 PR810.1
+1.8VSP_AUDIO: PC9003.1 PJP9001.1 PU9000.5
+1.35VS_B+: PC8201.1 PC8202.1 PC8203.1 PC8204.1 PC8212.1 PC8214.1 PC8220.1 PC8221.1 PJP8200.1 PQ8200.2 PQ8201.2 PR8201.2
+1.35VS_VGA: CG80.1 CG81.1 CG82.1 CG83.1 CG84.1 CG85.1 CG86.1 CG87.1 CG88.1 CG89.1 CG90.1 CG91.1 CG97.1 CG98.1 CG99.1 CG100.1 CG101.1 CG102.1 CG103.1 CG104.1 CG105.1 CG106.1 CG115.1 CG116.1 CG117.1 CG118.1 CG119.1 CG120.1 CG121.1 CG122.1 CG123.1 CG124.1 CG125.1 CG126.1 CG132.1 CG133.1 CG134.1 CG135.1 CG136.1 CG137.1 CG138.1 CG139.1 CG140.1 CG141.1 CG150.1 CG151.1 CG152.1 CG153.1 CG154.1 CG155.1 CG156.1 CG157.1 CG158.1 CG159.1 CG160.1 CG161.1 CG167.1 CG168.1 CG169.1 CG170.1 CG171.1 CG172.1 CG173.1 CG174.1 CG175.1 CG176.1 CG184.1 CG185.1 CG186.1 CG187.1 CG188.1 CG189.1 CG190.1 CG191.1 CG192.1 CG193.1 CG194.1 CG195.1 CG196.1 CG197.1 CG198.1 CG199.1 CG200.1 CG201.1 CG202.1 CG203.1 CG204.1 CG205.1 CG206.1 CG207.1 CG208.1 CG209.1 CG210.1 CG211.1 CG212.1 CG213.1 CG214.1 CG215.1 CG216.1 CG217.1 CG218.1 CG219.1 CG220.1 CG221.1 CG222.1 CG223.1 CG224.1 CG225.1 CG226.1 CG227.1 CG228.1 CG242.1 CG243.1 CG266.1 CG267.1 CG268.1 CG269.1 CG270.1 CG271.1 CG272.1 CG273.1 CG274.1 CG275.1 CG276.1 CG277.1 CG278.1 CG279.1 CG280.1 CG281.1 CG282.1 CG283.1 CG284.1 CG285.1 CG286.1 CG287.1 CG324.1 CG325.1 CG326.1 CG327.1 CG328.1 CG329.1 CG330.1 CG331.1 CG332.1 CG333.1 CG334.1 CG335.1 CG336.1 CG337.1 CG338.1 CG339.1 CG340.1 CG341.1 CG342.1 CG343.1 CG344.1 CG345.1 CG346.1 CG347.1 CG348.1 CG349.1 CG350.1 CG351.1 CG352.1 CG353.1 CG354.1 CG355.1 CG356.1 CG357.1 CG358.1 CG359.1 CG360.1 CG361.1 CG362.1 CG363.1 CG364.1 CG365.1 CG366.1 CG367.1 CG368.1 CG369.1 CG370.1 CG371.1 CG372.1 CG373.1 CG374.1 CG375.1 CG376.1 CG377.1 CG378.1 CG379.1 CG380.1 CG381.1 CG382.1 CG383.1 CG389.1 CG390.1 CG391.1 CG392.1 CG393.1 CG394.1 CG395.1 CG396.1 CG397.1 CG398.1 CG399.1 CG400.1 CG401.1 CG402.1 CG403.1 CG404.1 CG405.1 CG406.1 CG407.1 CG408.1 CG410.1 CG411.1 CG412.1 CG413.1 CG414.1 CG415.1 CG416.1 CG417.1 CG418.1 CG419.1 CG420.1 CG421.1 CG422.1 CG423.1 CG424.1 CG425.1 CG426.1 CG427.1 CG428.1 CG429.1 CG430.1 CG431.1 CG432.1 CG433.1 CG434.1 CG435.1 CG436.1 CG437.1 CG438.1 CG439.1 CG440.1 CG441.1 CG442.1 CG443.1 CG444.1 CG445.1 CG446.1 CG447.1 CG448.1 CG449.1 CG450.1 CG451.1 CG452.1 CG453.1 CG454.1 CG455.1 CG456.1 CG457.1 CG458.1 CG459.1 CG460.1 CG461.1 CG462.1 CG463.1 CG464.1 CG465.1 CG466.1 CG467.1 CG468.1 CG469.1 CG470.1 CG471.1 CG472.1 CG473.1 PJP8201.2 PJP8202.2 RG47.1 RG48.1 RG49.1 RG50.1 RG51.1 RG52.1 RG67.2 RG104.2 RG110.1 RG115.2 RG121.1 RG126.2 RG132.1 RG155.1 RG158.2 RG451.1 RG452.1 UG1.B1 UG1.B3 UG1.B12 UG1.B14 UG1.C5 UG1.C10 UG1.D1 UG1.D3 UG1.D11 UG1.D12 UG1.D14 UG1.E5 UG1.E10 UG1.F1 UG1.F3 UG1.F12 UG1.F14 UG1.G1 UG1.G2 UG1.G4 UG1.G11 UG1.G13 UG1.G14 UG1.H3 UG1.H12 UG1.K3 UG1.K12 UG1.L1 UG1.L2 UG1.L4 UG1.L11 UG1.L13 UG1.L14 UG1.M1 UG1.M3 UG1.M12 UG1.M14 UG1.N5 UG1.N10 UG1.P1 UG1.P3 UG1.P11 UG1.P12 UG1.P14 UG1.R5 UG1.R10 UG1.T1 UG1.T3 UG1.T12 UG1.T14 UG2.B1 UG2.B3 UG2.B12 UG2.B14 UG2.C5 UG2.C10 UG2.D1 UG2.D3 UG2.D11 UG2.D12 UG2.D14 UG2.E5 UG2.E10 UG2.F1 UG2.F3 UG2.F12 UG2.F14 UG2.G1 UG2.G2 UG2.G4 UG2.G11 UG2.G13 UG2.G14 UG2.H3 UG2.H12 UG2.K3 UG2.K12 UG2.L1 UG2.L2 UG2.L4 UG2.L11 UG2.L13 UG2.L14 UG2.M1 UG2.M3 UG2.M12 UG2.M14 UG2.N5 UG2.N10 UG2.P1 UG2.P3 UG2.P11 UG2.P12 UG2.P14 UG2.R5 UG2.R10 UG2.T1 UG2.T3 UG2.T12 UG2.T14 UG3.B1 UG3.B3 UG3.B12 UG3.B14 UG3.C5 UG3.C10 UG3.D1 UG3.D3 UG3.D11 UG3.D12 UG3.D14 UG3.E5 UG3.E10 UG3.F1 UG3.F3 UG3.F12 UG3.F14 UG3.G1 UG3.G2 UG3.G4 UG3.G11 UG3.G13 UG3.G14 UG3.H3 UG3.H12 UG3.K3 UG3.K12 UG3.L1 UG3.L2 UG3.L4 UG3.L11 UG3.L13 UG3.L14 UG3.M1 UG3.M3 UG3.M12 UG3.M14 UG3.N5 UG3.N10 UG3.P1 UG3.P3 UG3.P11 UG3.P12 UG3.P14 UG3.R5 UG3.R10 UG3.T1 UG3.T3 UG3.T12 UG3.T14 UG4.B1 UG4.B3 UG4.B12 UG4.B14 UG4.C5 UG4.C10 UG4.D1 UG4.D3 UG4.D11 UG4.D12 UG4.D14 UG4.E5 UG4.E10 UG4.F1 UG4.F3 UG4.F12 UG4.F14 UG4.G1 UG4.G2 UG4.G4 UG4.G11 UG4.G13 UG4.G14 UG4.H3 UG4.H12 UG4.K3 UG4.K12 UG4.L1 UG4.L2 UG4.L4 UG4.L11 UG4.L13 UG4.L14 UG4.M1 UG4.M3 UG4.M12 UG4.M14 UG4.N5 UG4.N10 UG4.P1 UG4.P3 UG4.P11 UG4.P12 UG4.P14 UG4.R5 UG4.R10 UG4.T1 UG4.T3 UG4.T12 UG4.T14 UG5.B1 UG5.B3 UG5.B12 UG5.B14 UG5.C5 UG5.C10 UG5.D1 UG5.D3 UG5.D11 UG5.D12 UG5.D14 UG5.E5 UG5.E10 UG5.F1 UG5.F3 UG5.F12 UG5.F14 UG5.G1 UG5.G2 UG5.G4 UG5.G11 UG5.G13 UG5.G14 UG5.H3 UG5.H12 UG5.K3 UG5.K12 UG5.L1 UG5.L2 UG5.L4 UG5.L11 UG5.L13 UG5.L14 UG5.M1 UG5.M3 UG5.M12 UG5.M14 UG5.N5 UG5.N10 UG5.P1 UG5.P3 UG5.P11 UG5.P12 UG5.P14 UG5.R5 UG5.R10 UG5.T1 UG5.T3 UG5.T12 UG5.T14 UG6.B1 UG6.B3 UG6.B12 UG6.B14 UG6.C5 UG6.C10 UG6.D1 UG6.D3 UG6.D11 UG6.D12 UG6.D14 UG6.E5 UG6.E10 UG6.F1 UG6.F3 UG6.F12 UG6.F14 UG6.G1 UG6.G2 UG6.G4 UG6.G11 UG6.G13 UG6.G14 UG6.H3 UG6.H12 UG6.K3 UG6.K12 UG6.L1 UG6.L2 UG6.L4 UG6.L11 UG6.L13 UG6.L14 UG6.M1 UG6.M3 UG6.M12 UG6.M14 UG6.N5 UG6.N10 UG6.P1 UG6.P3 UG6.P11 UG6.P12 UG6.P14 UG6.R5 UG6.R10 UG6.T1 UG6.T3 UG6.T12 UG6.T14 UG7.B1 UG7.B3 UG7.B12 UG7.B14 UG7.C5 UG7.C10 UG7.D1 UG7.D3 UG7.D11 UG7.D12 UG7.D14 UG7.E5 UG7.E10 UG7.F1 UG7.F3 UG7.F12 UG7.F14 UG7.G1 UG7.G2 UG7.G4 UG7.G11 UG7.G13 UG7.G14 UG7.H3 UG7.H12 UG7.K3 UG7.K12 UG7.L1 UG7.L2 UG7.L4 UG7.L11 UG7.L13 UG7.L14 UG7.M1 UG7.M3 UG7.M12 UG7.M14 UG7.N5 UG7.N10 UG7.P1 UG7.P3 UG7.P11 UG7.P12 UG7.P14 UG7.R5 UG7.R10 UG7.T1 UG7.T3 UG7.T12 UG7.T14 UG8.B1 UG8.B3 UG8.B12 UG8.B14 UG8.C5 UG8.C10 UG8.D1 UG8.D3 UG8.D11 UG8.D12 UG8.D14 UG8.E5 UG8.E10 UG8.F1 UG8.F3 UG8.F12 UG8.F14 UG8.G1 UG8.G2 UG8.G4 UG8.G11 UG8.G13 UG8.G14 UG8.H3 UG8.H12 UG8.K3 UG8.K12 UG8.L1 UG8.L2 UG8.L4 UG8.L11 UG8.L13 UG8.L14 UG8.M1 UG8.M3 UG8.M12 UG8.M14 UG8.N5 UG8.N10 UG8.P1 UG8.P3 UG8.P11 UG8.P12 UG8.P14 UG8.R5 UG8.R10 UG8.T1 UG8.T3 UG8.T12 UG8.T14 UG9.AA10 UG9.AA11 UG9.AA42 UG9.AA43 UG9.AC10 UG9.AC11 UG9.AC42 UG9.AC43 UG9.AD10 UG9.AD11 UG9.AD42 UG9.AD43 UG9.AF10 UG9.AF43 UG9.AG10 UG9.AG11 UG9.AG42 UG9.AG43 UG9.AJ10 UG9.AJ11 UG9.AJ42 UG9.AJ43 UG9.AK10 UG9.AK11 UG9.AK42 UG9.AK43 UG9.AM42 UG9.AM43 UG9.AN43 UG9.AR42 UG9.AR43 UG9.AT43 UG9.K12 UG9.K14 UG9.K15 UG9.K17 UG9.K18 UG9.K20 UG9.K21 UG9.K23 UG9.K24 UG9.K26 UG9.K27 UG9.K29 UG9.K30 UG9.K32 UG9.K33 UG9.K35 UG9.K36 UG9.K38 UG9.K39 UG9.K41 UG9.L14 UG9.L15 UG9.L18 UG9.L20 UG9.L21 UG9.L23 UG9.L24 UG9.L26 UG9.L27 UG9.L30 UG9.L32 UG9.L33 UG9.L35 UG9.L36 UG9.L39 UG9.M10 UG9.M43 UG9.P10 UG9.P11 UG9.P42 UG9.P43 UG9.R10 UG9.R11 UG9.R42 UG9.R43 UG9.U10 UG9.U11 UG9.U43 UG9.V10 UG9.V42 UG9.V43 UG9.Y10 UG9.Y11 UG9.Y42 UG9.Y43
+1.35VS_VGA_PGOOD: PR8203.1 PU8200.13 UG25.1 UG29.1
+1.35VS_VGAP: PC8207.1 PC8208.1 PC8218.1 PJP8201.1 PJP8202.1 PL8200.2 PL8201.2 PR8209.2
+1V8_AON: CG1.1 CG66.1 CG241.1 CG246.1 CG289.1 CG291.1 CG292.1 CG293.1 CG294.1 CG320.1 CG476.1 CG478.1 CG479.1 CG483.1 PR8203.2 QG511.2 RG2.2 RG8.2 RG9.2 RG11.1 RG12.1 RG13.2 RG14.2 RG15.2 RG16.2 RG17.2 RG18.2 RG19.2 RG20.2 RG21.2 RG71.1 RG74.1 RG78.2 RG79.2 RG80.2 RG81.2 RG82.2 RG83.2 RG84.2 RG85.2 RG86.2 RG147.1 RG500.1 RG502.1 RG503.2 RG504.2 RG510.1 RG516.1 RG522.2 RG530.1 RG573.2 RG574.2 RG581.1 RV648.1 RV652.1 RX5.1 RX7.1 UG9.BA10 UG9.BB14 UG9.BC14 UG10.5 UG12.6 UG12.7 UG12.13 UG12.14 UG13.3 UG13.7 UG13.8 UG15.3 UG15.7 UG15.8 UG22.5 UG26.5 UG27.5 UG28.5 UG29.5
+1V8_MAIN: CG11.1 CG12.2 CG17.1 CG18.1 CG19.1 CG20.1 CG21.2 CG23.1 CG24.1 CG290.1 CG295.1 CG296.1 CG297.1 CG298.1 CG299.1 CG300.1 CG301.1 CG302.1 CG303.1 CG304.1 CG305.1 CG306.1 CG307.1 CG312.1 LG1.2 LG2.2 LG3.1 LG4.1 LG5.1 LG6.2 RG512.1 RG515.1 RG533.1 RX3.1 UG9.AM10 UG9.AM11 UG9.AN10 UG9.AN11 UG9.AR10 UG9.AR11 UG9.AT10 UG9.AT11 UG9.AV10 UG9.AV11 UG9.AW10 UG9.AW11 UG9.BB26 UG9.BB27 UG9.BB29 UG9.BB32 UG9.BC26 UG9.BC27 UG9.BC29 UG9.BC30 UG9.BC32 UG9.BD21 UG9.BD27 UG9.BD30 UG12.8 UG12.9
+1V_MPHY: CH82.1 CH187.1 RH12.2 UH1.B1 UH1.B2 UH1.B3 UH1.C1 UH1.C2 UH1.C49 UH1.D49 UH1.E49 UH1.P2 UH1.P3 UH1.V19 UH1.W19 UH1.W20 UH1.W31
+1V_PCH: JP1.2 RH71.1 UH1.W22 UH1.W23
+1V_VCCDSW: UH1.BG45 UH1.BG46
+1VALW: C4.1 C7.1 CH180.1 CH181.1 CH188.1 JP1.1 JPCMC.22 PJP300.2 PJP302.2 RC353.1 RH12.1 U19.1 U19.2 U19.7 U20.1 U20.2 U20.7 UH1.AA22 UH1.AA23 UH1.AB20 UH1.AB22 UH1.AB23 UH1.AB27 UH1.AB28 UH1.AB30 UH1.AD20 UH1.AD23 UH1.AD27 UH1.AD28 UH1.AD30 UH1.AD31 UH1.AE17 UH1.AF23 UH1.AF27 UH1.AF30 UH1.AF31 UH1.AG31 UH1.D1 UH1.E1 UH1.U26 UH1.U29 UH1.V25 UH1.V27 UH1.V28 UH1.V30 UH1.V31
+1VALWP: PC306.1 PC307.1 PJP300.1 PJP302.1 PL300.2 PR307.2
+1VALWP_B+: PC301.1 PC302.1 PC303.1 PC304.1 PC310.1 PC311.1 PJP301.1 PQ300.5
+1VALWP_PGOOD: PR301.2 PU300.1 UE5.122
+2.5V_MEM: CD3.1 CD4.1 CD9.1 CD10.1 CD27.1 CD28.1 CD30.1 CD31.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PJP1300.2
+2.5V_MEMP: PC1303.1 PC1304.1 PC1305.1 PJP1300.1 PR1304.1 PU1300.6
+2.5VOUT: CM9.1 CM32.1 CM34.1 CM35.1 CM36.1 UM8.9 UM8.14 UM8.36 UM8.41 UM8.51
+2.5VSP_ADJ: PC1305.2 PR1304.2 PR1305.1 PU1300.7
+2.5VSP_ON: PC1301.1 PR1301.1 PR1302.1 PU1300.2
+2.5VSP_PGOOD: PR1300.2 PU1300.1
+2.5VSP_VIN: PC1300.1 PC1306.1 PJP1301.2 PU1300.3
+3.3V_1.8V_DVDD: CA12.1 CA13.1 CA64.1 CA65.1 LA5.1 RA11.1 RA21.1 RA24.1 RA32.1 RA50.1 RA53.1 RA66.1 RA70.1 UA1.7 UA4.16
+3.3V_1.8V_DVDD_IO: CA1.1 CA2.1 LA3.1 RA5.1 UA1.19
+3.3V_ANA_PCIE: CT85.1 UT1.L16
+3.3V_ANA_USB2: CT86.1 UT1.J16
+3.3V_ELC: CE1.1 CE6.1 CE19.1 CE24.1 CE25.1 CE59.1 CE60.1 CE64.1 CE65.1 CE168.1 CE170.1 JELC1.1 JELC2.1 LE4.1 RE1.1 RE2.1 RE4.2 RE6.2 RE7.2 RE8.1 RE12.1 RE13.1 RE14.1 RE15.1 RE16.1 RE17.1 RE21.1 RE23.1 RE25.1 RE26.1 RE32.1 RE40.1 RE43.1 RE165.1 RE166.1 RE657.1 UE1.1 UE1.24 UE1.36 UE1.48 UE2.8 UE3.27 UE4.27 UE8.27 UE9.1
+3.3V_FLASH: CT45.1 CT103.1 RT48.1 RT49.1 RT50.1 RT51.1 RT66.1 RT67.1 RT74.1 RT124.1 UT2.8 UT4.B1 UT4.G1
+3.3V_LC: CT46.1 RT6.1 RT7.1 RT8.1 RT9.1 UT1.R6
+3.3V_TBT_SX: CT47.1 RT26.1 RT27.1 RT28.1 RT29.1 RT30.1 RT31.1 RT32.1 RT33.1 RT36.1 RT61.2 RT70.1 RT86.1 RT94.1 RT97.2 UT1.F8
+3.3V_TBT_SX_R: CT102.1 RT61.1 UT4.H2
+3V3_SYS: CG61.1 CG323.1 CG385.1 PR821.2 PR6408.2 PR6436.2 QX1.2 RG60.1 RG61.1 RG514.1 RV655.1 RX1.1 UG11.4 UG14.6
+3V_PCH: C266.1 C267.1 CH49.1 CH182.1 CH186.1 CH190.1 CH192.1 CH231.1 J6.1 PR817.1 R367.2 RC9.1 RG555.1 RG556.1 RH7.2 RH21.2 RH25.2 RH27.2 RH29.2 RH63.1 RH75.1 RH78.1 RH95.1 RH99.2 RH100.1 RH130.1 RH453.2 RH460.1 RH461.1 RH493.1 RH506.2 RH515.2 RH524.1 RH533.2 RH545.2 RH558.2 RH571.2 RH594.1 RPH6.5 RPH6.6 RPH6.7 RPH6.8 UH1.AC35 UH1.AC36 UH1.AE35 UH1.AE36 UH1.AN21 UH1.AN24 UH1.AN26 UH1.AN32 UH1.AN44 UH1.AP26 UH1.AT44 UH1.AW9 UH1.AY8 UH1.BB7 UH1.BB14 UH1.V23 UH4.8
+3VALW: C262.1 C263.1 C269.1 C270.1 C2514.1 C2515.1 CE22.1 CE29.1 CE30.1 CE31.2 CE32.2 CE56.1 CE62.1 CL40.1 CL41.1 CM23.1 CM70.1 CU68.1 CU72.1 JIO.8 LE1.1 PC817.1 PC821.1 PC5003.1 PJP102.2 PJP104.2 PJP9000.1 PR3.2 PR16.2 PR24.2 PR32.1 PR210.1 PR301.1 PR709.2 PR710.1 PR718.2 PR812.2 PR814.2 PR1300.1 PR5033.2 PR6069.1 PR8220.1 PU509.15 PU800.15 PU802.15 R307.1 R325.1 RA13.1 RA84.2 RE24.2 RE64.2 RE70.1 RE79.1 RE90.5 RE90.6 RE91.1 RE102.2 RE300.2 RE398.1 RE400.1 RE451.1 RE452.1 RE457.1 RE459.1 RE463.1 RE464.1 RE469.1 RE470.1 RE475.1 RE477.1 RE481.1 RE483.1 RE487.1 RE489.1 RE493.1 RE494.1 RE499.1 RE500.1 RE505.1 RE506.1 RE530.1 RE642.1 RE643.1 RE644.2 RE652.1 RE672.2 RH2.1 RH6.2 RM5.1 RM41.1 RT53.1 RT88.1 RT95.1 RT97.1 RT111.1 RU15.2 RU16.2 RU17.2 RU18.2 RU19.2 RU20.2 RU26.1 RU27.1 RU31.1 U16.1 U16.2 U16.7 U17.6 U17.7 U18.5 UE5.9 UE5.22 UE5.33 UE5.96 UE5.125 UE6.24 UE9.5 UE10.24 UL2.5 UM3.5 UM7.5 UU2.47
+3VALW_PD: CT88.1 CT101.1 RT53.2 UT4.H1
+3VALWP: PC116.1 PC117.1 PJP102.1 PJP104.1 PL101.1 PR101.1
+3VLP: CU26.1 DU8.1 PC101.1 PR11.2 PR25.2 PU100.3 RA85.2 RE63.2 RU1.1 RU4.1 RU5.1 RU7.1 UE5.111 UU5.5
+3VS: C260.1 C261.1 C2498.1 CD16.1 CD17.1 CD34.1 CD35.1 CG322.1 CG474.1 CG475.1 CG480.1 CH201.1 CM10.1 CM11.1 CM12.1 CM13.1 CM14.1 CM15.1 CM18.1 CM19.1 CM20.1 CM21.1 CM29.1 CM30.1 CM31.1 CM33.1 CM100.1 CS2.1 CS7.1 CV5.1 CV21.1 CV37.1 CV372.1 FV2.1 J5.1 JDIMM1.255 JDIMM2.255 JEDP.24 JEDP.32 JHDD.21 JHDD.22 JHDD.23 JHDD.24 JHDD.25 JHDD.26 JIO.6 JWLAN.2 JWLAN.4 JWLAN.64 JWLAN.66 PR516.1 PR820.2 PR5016.1 PR6036.1 PR6042.1 PR8219.1 QH5.2 QH5.5 QS3.2 QX2.1 QX3.1 R181.1 R366.2 RA5.2 RA11.2 RC62.2 RC63.2 RD1.1 RD2.1 RD3.1 RD4.1 RD5.1 RD6.1 RE20.2 RE84.1 RE90.7 RE90.8 RE656.1 RF1.2 RF2.2 RF4.2 RF5.2 RG200.1 RG506.1 RG517.1 RG534.1 RG535.1 RG536.1 RG561.1 RG566.1 RG567.1 RH5.1 RH85.2 RH111.2 RH462.1 RH463.1 RH501.1 RH502.1 RH512.2 RH516.1 RH517.1 RH518.2 RH520.1 RH521.1 RH525.1 RH537.2 RH584.2 RH588.1 RH600.2 RH601.1 RH602.1 RH604.1 RH605.1 RH606.1 RH607.1 RL5.2 RM14.1 RM18.1 RM20.1 RM26.1 RM66.2 RM76.1 RM79.1 RM81.1 RM85.1 RM86.1 RM96.1 RN5.1 RN16.1 RP3.1 RP3.2 RP3.3 RP3.4 RP5.1 RP5.2 RP5.3 RP5.4 RPC7.5 RPC7.6 RPC7.7 RPC7.8 RS2.2 RT57.1 RT58.1 RT107.1 RT110.1 RT130.2 RV16.1 RV81.1 RV671.2 RV672.2 U2407.1 UA3.B2 UG14.1 UG14.2 UG14.7 UG16.9 UG16.12 UG25.5 UH3.5 UM4.5 UM4.9 UM4.12 UM4.16 UM8.24 US1.1 US1.7 US1.8 US1.14 UV17.1 UV17.2 UV17.7 UX3.5
+3VS_DP: CV34.1 CV35.1 FV2.2 JDP.20 RX9.2 UX3.1
+3VS_SSD: C617.1 C618.1 C620.1 C621.1 C622.1 C623.1 C624.1 C625.1 C627.1 C628.1 C629.1 C630.1 C631.1 C632.1 C633.1 C634.1 C635.1 C636.1 C637.1 C638.1 C639.1 C640.1 C641.1 C2512.1 C2513.1 JSSD1.2 JSSD1.4 JSSD1.12 JSSD1.14 JSSD1.16 JSSD1.18 JSSD1.70 JSSD1.72 JSSD1.74 JSSD2.2 JSSD2.4 JSSD2.12 JSSD2.14 JSSD2.16 JSSD2.18 JSSD2.70 JSSD2.72 JSSD2.74 JSSD3.2 JSSD3.4 JSSD3.12 JSSD3.14 JSSD3.16 JSSD3.18 JSSD3.70 JSSD3.72 JSSD3.74 R363.2 R364.2 R365.2 U16.6
+3VS_TBT: CT48.1 CT49.1 CT50.1 CT51.1 CT52.1 CT53.1 LT4.2 RT20.1 RT21.1 RT76.2 RT77.2 RT95.2 UT1.A2 UT1.A3 UT1.B3 UT1.H9
+3VS_TOUCH: C2.1 CT116.1 CT118.1 JTP.11 RE33.1 RE100.1 RE101.1 RE661.1 RE663.1 RT89.1 UT5.7 UT5.8
+5V_HDD: CS1.1 CS5.1 CS6.1 CS16.1 JHDD.27 JHDD.28 JHDD.29 JHDD.30 JP3.2
+5V_PVDD: CA5.1 CA6.1 CA9.1 CA10.1 RA3.1 RA68.2 RA69.2
+5V_TOBII: JTOBII.2 UE12.1
+5V_USB_PWR1: CU2.1 CU3.1 CU6.1 CU47.1 JUSB1.1 UU1.12
+5V_USB_PWR2: CU10.1 CU11.1 CU45.1 JIO.3 JIO.4 JIO.5 UU3.1
+5V_USBC_VBUS: CU18.1 CU19.1 CU20.1 CU21.1 CU32.1 CU37.1 CU40.1 JUSBC2.A4 JUSBC2.A9 JUSBC2.B4 JUSBC2.B9 RU24.1 UU7.14 UU7.15
+5VA: CA14.1 CA15.1 RA8.1 UA1.45
+5VALW: C264.1 C265.1 C2516.1 C2519.1 C2520.1 C2521.1 C2525.1 CE61.1 CE80.1 CE81.1 CE82.1 CG384.1 CT90.1 CT91.1 CT92.1 CT93.1 CU7.1 CU33.1 CU34.1 CU42.1 CU44.1 CU46.1 CU48.1 CU77.1 CV36.1 JKB.1 JLOGO.1 JLOGO.2 JWDB.1 PC308.1 PC1307.1 PC5002.1 PC5005.1 PC5006.1 PC5007.1 PC5008.1 PC5009.1 PJP100.2 PJP101.2 PJP1301.1 PR8.1 PR14.2 PR203.1 PR204.1 PR545.1 PR553.1 PR577.1 PR5004.1 PR5020.1 PR5022.1 PR5024.1 PR5025.1 PR8200.2 PU300.7 PU502.2 PU502.15 PU503.2 PU503.15 PU504.2 PU504.15 PU507.2 PU507.15 PU510.2 PU510.15 PU511.15 PU1300.4 QE8.3 QE54.1 QE54.4 QE55.1 QE55.4 QE56.1 RE28.1 RE154.1 RE156.1 RE158.1 RE161.2 RE449.1 RE517.1 RE521.1 RE525.1 RE529.1 RG509.1 RG511.1 RG513.1 RG541.1 RG543.1 RM91.1 RM92.1 RM93.1 RM94.1 RU21.1 RU23.1 U16.3 U17.1 U17.2 U17.4 U19.3 U20.3 UE12.5 UG14.3 UT4.A11 UT4.B11 UT4.C11 UT4.D11 UT4.H10 UU1.1 UU3.5 UU7.2 UU7.3 UU7.4 UU7.5 UU8.4 UV17.3 UZ21.4
+5VALW_LED: JPWR.1 QE8.1
+5VALWP: PC108.1 PC115.1 PJP100.1 PJP101.1 PL102.2 PR102.2 PU100.14
+5VS: C29.1 C256.1 C257.1 CE84.1 CE85.1 CE86.1 CE87.1 CF4.1 CF5.1 CG386.1 CV23.1 FV3.1 J4.1 JFAN1.1 JFAN2.1 JKB3.5 JKB3.6 JKBBL.15 JKBBL.16 JP3.1 JPK.1 JPK.2 JPK.3 JPK.4 JPK.5 JTRONL.1 JTRONL.2 JTRONL.11 JTRONL.12 JTRONR.1 JTRONR.2 JTRONR.11 JTRONR.12 PC6101.1 PC6114.1 PC6201.1 PC6214.1 PR6035.1 PR6046.2 PR6047.2 PR6048.2 PR6050.2 PR6051.2 PR6052.2 PR6102.2 PR6103.2 PR6104.2 PR6106.1 PR6109.2 PR6110.2 PR6111.2 PR6113.1 PR6200.2 PR6201.2 PR6202.2 PR6204.1 PR6207.2 PR6208.2 PR6209.2 PR6211.1 PR6400.1 PU6100.3 PU6101.3 PU6200.3 PU6201.3 Q2409.1 Q2409.2 Q2409.5 Q2409.6 RA3.2 RA8.2 RF3.2 RF6.2 RS1.1 RX39.1 UG12.4 UV3.16
+5VS_TP_LED: C2508.1 JTP.1 JTP.2 Q2409.4 R144.1 R145.1 R146.1 R147.1 R150.1 R154.1
+AVDD09: CU86.1 CU87.1 CU93.1 LU18.1 UU2.1 UU2.42 UU2.46
+AVDDH: CL5.1 CL6.1 CL7.1 UL1.9 UL1.22
+AVDDL: CL18.1 CL19.1 CL20.1 CL21.1 CL22.1 CL23.1 CL24.1 CL25.1 UL1.6 UL1.13 UL1.19 UL1.31 UL1.34
+DVDD09: CU88.1 CU89.1 LU17.1 UU2.4 UU2.34
+DVDDL: CL43.1 CL44.1 UL1.37
+PVDD: CA52.1 CA53.1 CA54.1 CA55.1 CA56.1 CA57.1 CA61.1 CA62.1 CA63.1 CA79.1 CA80.1 CA81.1 CA82.1 CA83.1 CA84.1 J7.2 UA4.1 UA4.37 UA4.42 UA4.43 UA4.48 UA4.51 UA4.56
+V18R: RE24.1 UE5.124
+VCC_CORE: PC1000.1 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1009.1 PC1010.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1055.1 PC1056.1 PC1057.1 PC1058.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PC1097.1 PC1098.1 PC1099.1 PC1100.1 PC1101.1 PC1102.1 PC1103.1 PC1104.1 PC1105.1 PC1106.1 PC1107.1 PC1108.1 PC1109.1 PC1110.1 PC1111.1 PC1123.1 PC1124.1 PC1125.1 PC1126.1 PC1127.1 PC1128.1 PC1129.1 PC1130.1 PC1131.1 PC1132.1 PC1133.1 PC1134.1 PC1135.1 PC1136.1 PC1137.1 PC1161.1 PC1162.1 PC1163.1 PC1164.1 PC1165.1 PC1166.1 PC1167.1 PC1168.1 PC1169.1 PC1170.1 PC1171.1 PC1172.1 PC1173.1 PC1174.1 PC1175.1 PC1199.1 PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1204.1 PC1205.1 PC1206.1 PC1207.1 PC1208.1 PC1209.1 PC1210.1 PC1236.1 PC1237.1 PC1238.1 PL501.2 PL502.2 PL503.2 PL506.2 PR521.1 PR559.1 PR569.1 PR579.1 PR597.1 RH197.1 UC1.AA13 UC1.AA31 UC1.AA32 UC1.AA33 UC1.AA34 UC1.AA35 UC1.AA36 UC1.AA37 UC1.AA38 UC1.AB29 UC1.AB30 UC1.AB31 UC1.AB32 UC1.AB35 UC1.AB36 UC1.AB37 UC1.AB38 UC1.AC13 UC1.AC14 UC1.AC29 UC1.AC30 UC1.AC31 UC1.AC32 UC1.AC33 UC1.AC34 UC1.AC35 UC1.AC36 UC1.AD13 UC1.AD14 UC1.AD31 UC1.AD32 UC1.AD33 UC1.AD34 UC1.AD35 UC1.AD36 UC1.AD37 UC1.AD38 UC1.AE13 UC1.AE14 UC1.AE30 UC1.AE31 UC1.AE32 UC1.AE35 UC1.AE36 UC1.AE37 UC1.AE38 UC1.AF29 UC1.AF30 UC1.AF31 UC1.AF32 UC1.AF33 UC1.AF34 UC1.AF35 UC1.AF36 UC1.AF37 UC1.AF38 UC1.AG14 UC1.AG31 UC1.AG32 UC1.AG33 UC1.AG34 UC1.AG35 UC1.AG36 UC1.AH13 UC1.AH14 UC1.AH29 UC1.AH30 UC1.AH31 UC1.AH32 UC1.AJ14 UC1.AJ29 UC1.AJ30 UC1.AJ31 UC1.AJ32 UC1.AJ33 UC1.AJ34 UC1.AJ35 UC1.AJ36 UC1.AK31 UC1.AK32 UC1.AK33 UC1.AK34 UC1.AK35 UC1.AK36 UC1.AK37 UC1.AK38 UC1.AL13 UC1.AL29 UC1.AL30 UC1.AL31 UC1.AL32 UC1.AL35 UC1.AL36 UC1.AL37 UC1.AL38 UC1.AM13 UC1.AM14 UC1.AM29 UC1.AM30 UC1.AM31 UC1.AM32 UC1.AM33 UC1.AM34 UC1.AM35 UC1.AM36 UC1.AN13 UC1.AN14 UC1.AN31 UC1.AN32 UC1.AN33 UC1.AN34 UC1.AN35 UC1.AN36 UC1.AN37 UC1.AN38 UC1.AP13 UC1.AP30 UC1.AP31 UC1.AP32 UC1.AP35 UC1.AP36 UC1.AP37 UC1.AP38 UC1.K13 UC1.K14 UC1.L13 UC1.L14 UC1.N13 UC1.N14 UC1.N30 UC1.N31 UC1.N32 UC1.N35 UC1.N36 UC1.N37 UC1.N38 UC1.P13 UC1.P14 UC1.P29 UC1.P30 UC1.P31 UC1.P32 UC1.P33 UC1.P34 UC1.P35 UC1.P36 UC1.R13 UC1.R31 UC1.R32 UC1.R33 UC1.R34 UC1.R35 UC1.R36 UC1.R37 UC1.R38 UC1.T29 UC1.T30 UC1.T31 UC1.T32 UC1.T35 UC1.T36 UC1.T37 UC1.T38 UC1.U29 UC1.U30 UC1.U31 UC1.U32 UC1.U33 UC1.U34 UC1.U35 UC1.U36 UC1.V13 UC1.V14 UC1.V31 UC1.V32 UC1.V33 UC1.V34 UC1.V35 UC1.V36 UC1.V37 UC1.V38 UC1.W13 UC1.W14 UC1.W29 UC1.W30 UC1.W31 UC1.W32 UC1.W35 UC1.W36 UC1.W37 UC1.W38 UC1.Y29 UC1.Y30 UC1.Y31 UC1.Y32 UC1.Y33 UC1.Y34 UC1.Y35 UC1.Y36
+VCCGT: PC1007.1 PC1008.1 PC1011.1 PC1012.1 PC1013.1 PC1028.1 PC1029.1 PC1030.1 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1059.1 PC1060.1 PC1061.1 PC1062.1 PC1063.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1138.1 PC1139.1 PC1140.1 PC1141.1 PC1142.1 PC1143.1 PC1144.1 PC1145.1 PC1146.1 PC1147.1 PC1148.1 PC1149.1 PL505.2 PR526.2 PR588.1 RH203.2 UC1.AT14 UC1.AT31 UC1.AT32 UC1.AT33 UC1.AT34 UC1.AT35 UC1.AT36 UC1.AT37 UC1.AT38 UC1.AU14 UC1.AU29 UC1.AU30 UC1.AU31 UC1.AU32 UC1.AU35 UC1.AU36 UC1.AU37 UC1.AU38 UC1.AV29 UC1.AV30 UC1.AV31 UC1.AV32 UC1.AV33 UC1.AV34 UC1.AV35 UC1.AV36 UC1.AW14 UC1.AW31 UC1.AW32 UC1.AW33 UC1.AW34 UC1.AW35 UC1.AW36 UC1.AW37 UC1.AW38 UC1.AY29 UC1.AY30 UC1.AY31 UC1.AY32 UC1.AY35 UC1.AY36 UC1.AY37 UC1.AY38 UC1.BA13 UC1.BA14 UC1.BA29 UC1.BA30 UC1.BA31 UC1.BA32 UC1.BA33 UC1.BA34 UC1.BA35 UC1.BA36 UC1.BB13 UC1.BB14 UC1.BB31 UC1.BB32 UC1.BB33 UC1.BB34 UC1.BB35 UC1.BB36 UC1.BB37 UC1.BB38 UC1.BC29 UC1.BC30 UC1.BC31 UC1.BC32 UC1.BC35 UC1.BC36 UC1.BC37 UC1.BC38 UC1.BD13 UC1.BD14 UC1.BD29 UC1.BD30 UC1.BD31 UC1.BD32 UC1.BD33 UC1.BD34 UC1.BD35 UC1.BD36 UC1.BE31 UC1.BE32 UC1.BE33 UC1.BE34 UC1.BE35 UC1.BE36 UC1.BE37 UC1.BE38 UC1.BF13 UC1.BF14 UC1.BF29 UC1.BF30 UC1.BF31 UC1.BF32 UC1.BF35 UC1.BF36 UC1.BF37 UC1.BF38 UC1.BG29 UC1.BG30 UC1.BG31 UC1.BG32 UC1.BG33 UC1.BG34 UC1.BG35 UC1.BG36 UC1.BH33 UC1.BH34 UC1.BH35 UC1.BH36 UC1.BH37 UC1.BH38 UC1.BJ16 UC1.BJ17 UC1.BJ19 UC1.BJ20 UC1.BJ21 UC1.BJ23 UC1.BJ24 UC1.BJ26 UC1.BJ27 UC1.BJ37 UC1.BJ38 UC1.BK16 UC1.BK17 UC1.BK19 UC1.BK20 UC1.BK21 UC1.BK23 UC1.BK24 UC1.BK26 UC1.BK27 UC1.BL15 UC1.BL16 UC1.BL17 UC1.BL23 UC1.BL24 UC1.BL25 UC1.BL26 UC1.BL27 UC1.BL28 UC1.BL36 UC1.BL37 UC1.BM15 UC1.BM16 UC1.BM17 UC1.BM36 UC1.BM37 UC1.BN15 UC1.BN16 UC1.BN17 UC1.BN36 UC1.BN37 UC1.BN38 UC1.BP15 UC1.BP16 UC1.BP17 UC1.BP37 UC1.BP38 UC1.BR15 UC1.BR16 UC1.BR17 UC1.BR37 UC1.BT15 UC1.BT16 UC1.BT17 UC1.BT37
+VCCIO: CH102.1 CH103.1 CH104.1 PJP505.2 RC2.1 RC30.2 UC1.AG12 UC1.G15 UC1.G17 UC1.G19 UC1.G21 UC1.H15 UC1.H16 UC1.H17 UC1.H19 UC1.H20 UC1.H21 UC1.H26 UC1.H27 UC1.J15 UC1.J16 UC1.J17 UC1.J19 UC1.J20 UC1.J21 UC1.J26 UC1.J27
+VCCIOP: PC596.1 PC597.1 PC598.1 PC599.1 PC818.1 PJP505.1 PL509.2 PR5014.1
+VCCPHVLDO: RH598.2
+VCCRTCEXT: UH1.BF47 UH1.BG47
+VCCSA: PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1036.1 PC1037.1 PC1038.1 PC1039.1 PC1040.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PL508.4 PR514.1 RH201.2 UC1.J30 UC1.K29 UC1.K30 UC1.K31 UC1.K32 UC1.K33 UC1.K34 UC1.K35 UC1.L31 UC1.L32 UC1.L35 UC1.L36 UC1.L37 UC1.L38 UC1.M29 UC1.M30 UC1.M31 UC1.M32 UC1.M33 UC1.M34 UC1.M35 UC1.M36
+VCCST: C6.1 C8.1 CC39.1 CH106.1 CH107.1 PC502.2 PR504.1 PR505.2 PR506.1 PR507.1 RH151.1 RH152.1 RH156.1 RH163.1 RH164.1 U19.6 UC1.H28 UC1.H30 UC1.J28
+VCCSTG: C10.1 CH105.1 RH165.1 RH494.1 RH495.1 RH496.1 U20.6 UC1.G30 UC1.H29
+VDD09: CU55.1 CU56.1 LU13.2 LU17.2 LU18.2 UU2.12
+VDD18: CU65.1 CU66.1 CU70.1 CU76.1 CU85.1 LU14.2 RU29.1 RU32.1 UU2.5 UU2.18 UU2.30 UU2.39 UU2.48 UU8.7 UU8.8
+VDD_TOUCH: CV19.1 JEDP.33 RV81.2
+VDDA: CE7.1 CE169.1 LE4.2 UE1.9
+VDDCT_L: CL32.2 CL33.1 CL34.2 CL35.1 CL36.2 CL37.1 CL38.2 CL39.1 TL1.3 TL1.4 TL1.9 TL1.10
