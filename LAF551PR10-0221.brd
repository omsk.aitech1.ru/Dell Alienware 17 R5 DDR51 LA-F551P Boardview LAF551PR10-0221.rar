# Allegro board LAF551PR10-0221.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+NVVDD1 on TOP (solid shape): 241.48,93.14 241.72,93.03 241.96,93.14 241.97,93.14 241.97,93.04 242.71,93.04 242.71,93.14 242.88,93.14 242.92,93.11 242.96,93.07 243.01,92.99 242.96,92.9 242.83,92.76 242.81,92.57 242.81,92.54 242.68,92.41 238.62,92.41 238.51,92.52 238.52,92.55 238.53,92.72 238.45,92.87 238.45,92.98 238.37,93.05 238.43,93.11 238.71,93.11 238.93,93.03 239.14,93.12 239.15,93.13 239.24,93.13 239.24,93.03 239.98,93.03 240.05,93.1 240.14,93.09 240.32,93.03 240.5,93.09 240.55,93.09 240.58,93.04 241.31,93.04 241.31,93.14
+NVVDD1 on TOP (solid shape): 230.14,95.02 230.22,94.98 230.23,94.88 230.33,94.5 230.73,94.51 231.27,94.51 231.27,93.59 230.73,93.59 230.65,93.64 230.56,93.67 230.54,93.67 230.43,93.78 230.14,93.78 230.14,93.88 229.4,93.88 229.4,93.78 229.21,93.78 229.1,93.67 229.08,93.67 228.99,93.64 228.91,93.59 228.63,93.59 228.5,93.66 228.35,93.66 228.26,93.68 228.22,93.76 228.22,94.34 228.26,94.42 228.35,94.44 228.5,94.44 228.63,94.51 228.91,94.51 229.31,94.49 229.41,94.88 229.42,94.98 229.5,95.02
+NVVDD1 on TOP (solid shape): 238.57,98.82 238.65,98.77 238.87,98.64 239.11,98.7 239.13,98.71 239.23,98.71 239.24,98.7 239.24,98.33 239.98,98.33 239.98,98.7 239.99,98.71 240.11,98.71 240.13,98.7 240.28,98.64 240.44,98.65 240.53,98.64 240.58,98.56 240.58,98.33 241.31,98.33 241.53,98.54 241.74,98.54 242,98.29 242.7,98.29 242.75,98.23 242.75,97.61 242.69,97.54 242.12,97.54 242.03,97.64 242.02,97.65 241.81,97.85 241.53,97.8 241.51,97.79 241.48,97.79 241.22,97.54 240.67,97.54 240.64,97.57 240.64,97.58 240.37,97.86 240.03,97.68 240.03,97.67 239.9,97.55 239.32,97.55 239.22,97.65 239.22,97.66 239,97.86 238.71,97.79 238.43,97.79 238.4,97.82 238.35,97.9 238.54,98.25 238.35,98.6 238.4,98.68 238.44,98.73 238.49,98.77
+NVVDD1 on TOP (solid shape): outline of 1907 points within 227.37,93.36 246.17,102.56
+NVVDD1 on TOP (solid shape): outline of 4488 points within 217.5,102.09 268.44,139.96
+NVVDD1 on BOTTOM (solid shape): 234.62,92.93 234.78,92.91 234.91,92.8 234.94,92.75 234.96,92.75 234.98,92.69 234.95,92.66 234.94,92.59 234.93,92.57 234.84,92.48 234.8,92.35 234.8,92.3 234.57,92.3 234.55,92.25 234.49,92.19 234.41,92.15 234.37,92.14 234.3,92.08 233.71,92.08 233.64,92.14 233.55,92.19 233.5,92.23 233.47,92.28 233.17,92.28 233.14,92.23 233.09,92.19 233,92.14 232.85,92 232.36,92 232.21,92.15 232.14,92.2 232.1,92.23 232.07,92.28 231.77,92.28 231.74,92.23 231.7,92.2 231.63,92.15 231.55,92.08 231.27,92.08 231.19,92.16 231.19,92.79 231.22,92.82 231.35,92.82 231.43,92.75 232.44,92.75 232.51,92.82 232.73,92.82 232.83,92.72 233.09,92.72 233.19,92.82 233.45,92.82 233.53,92.75 234.4,92.75 234.42,92.79 234.44,92.79 234.53,92.83
+NVVDD1 on BOTTOM (solid shape): 231.91,95.73 232.04,95.71 232.09,95.64 232.16,95.6 232.19,95.55 232.44,95.55 232.56,95.67 232.68,95.67 232.83,95.52 233.04,95.52 233.09,95.61 233.15,95.65 233.19,95.7 233.32,95.73 233.45,95.7 233.48,95.66 233.55,95.61 233.59,95.55 234.4,95.55 234.42,95.59 234.44,95.59 234.54,95.64 234.61,95.72 234.78,95.71 234.91,95.6 234.94,95.55 234.95,95.55 235,95.52 234.99,95.46 234.95,95.43 234.94,95.39 234.93,95.38 234.84,95.28 234.8,95.15 234.8,95.1 234.57,95.1 234.55,95.05 234.49,94.99 234.41,94.95 234.37,94.94 234.23,94.8 231.26,94.8 231.16,94.9 231.16,95.65 231.21,95.7 231.28,95.7 231.43,95.55 231.65,95.55 231.69,95.61 231.76,95.66 231.79,95.7
+NVVDD1 on BOTTOM (solid shape): 241.4,103.06 241.48,103.02 241.52,102.98 241.55,102.95 241.62,102.95 241.63,102.95 241.79,102.94 241.93,103.01 241.95,103.03 241.99,103.03 242.14,103.17 242.39,103.17 242.43,103.13 242.43,102.46 242.37,102.4 242.16,102.4 242.15,102.4 242.07,102.42 241.99,102.4 241.98,102.4 241.92,102.4 241.89,102.38 241.55,102.38 241.52,102.4 241.46,102.4 241.45,102.4 241.37,102.42 241.29,102.4 241.28,102.4 241.23,102.4 241.2,102.38 240.84,102.38 240.81,102.4 240.76,102.4 240.75,102.4 240.67,102.42 240.59,102.4 240.58,102.4 240.52,102.4 240.49,102.38 240.15,102.38 240.12,102.4 240.06,102.4 240.05,102.4 239.97,102.42 239.89,102.4 239.88,102.4 239.36,102.4 239.25,102.42 239.25,102.63 239.16,102.68 239.12,102.75 239.08,102.79 239.06,102.86 239.05,102.89 239.05,102.95 239.09,102.95 239.12,102.98 239.17,103.02 239.23,103.05 239.27,103.06 239.41,103.2 239.85,103.2 240,103.06 240.09,103.01 240.14,102.97 240.17,102.92 240.47,102.92 240.5,102.97 240.55,103.01 240.64,103.06 240.81,103.22 241.23,103.22
+NVVDD1 on BOTTOM (solid shape): 238.73,98.4 238.86,98.51 239.03,98.52 239.1,98.44 239.2,98.39 239.22,98.39 239.24,98.35 240.05,98.35 240.09,98.41 240.14,98.45 240.19,98.49 240.32,98.53 240.45,98.49 240.5,98.45 240.55,98.41 240.59,98.35 241.45,98.35 241.49,98.41 241.54,98.45 241.59,98.49 241.72,98.53 241.85,98.49 241.9,98.45 241.95,98.41 241.99,98.35 242.26,98.35 242.43,98.18 242.43,97.82 242.29,97.68 242.09,97.68 241.99,97.77 241.95,97.77 241.89,97.83 241.87,97.83 241.72,97.87 241.57,97.83 241.55,97.83 241.49,97.77 241.47,97.77 241.4,97.74 241.35,97.7 240.71,97.7 240.67,97.74 240.57,97.77 240.55,97.77 240.51,97.81 240.41,97.9 240.23,97.9 240.13,97.81 240.09,97.77 240.05,97.77 239.95,97.68 239.26,97.68 239.15,97.78 239.1,97.83 239.04,97.9 238.84,97.9 238.84,97.95 238.8,98.09 238.7,98.19 238.69,98.24 238.69,98.33
+NVVDD1 on BOTTOM (solid shape): 234.62,98.53 234.78,98.51 234.91,98.4 234.94,98.35 234.96,98.35 234.99,98.29 234.96,98.25 234.94,98.19 234.93,98.17 234.84,98.08 234.8,97.95 234.8,97.9 234.57,97.9 234.55,97.85 234.49,97.79 234.41,97.75 234.37,97.74 234.3,97.68 233.71,97.68 233.64,97.74 233.55,97.79 233.5,97.83 233.47,97.88 233.17,97.88 233.14,97.83 233.09,97.79 233,97.74 232.85,97.6 232.36,97.6 232.21,97.75 232.14,97.8 232.1,97.83 232.07,97.88 231.75,97.88 231.55,97.68 231.22,97.68 231.18,97.71 231.19,97.76 231.21,97.79 231.21,98.29 231.08,98.42 231.16,98.5 231.28,98.5 231.43,98.35 231.68,98.35 231.71,98.38 231.92,98.48 232.13,98.38 232.16,98.35 232.37,98.35 232.4,98.38 232.53,98.47 232.69,98.48 232.78,98.44 232.84,98.38 232.88,98.32 233.06,98.32 233.15,98.42 233.21,98.46 233.25,98.47 233.32,98.48 233.39,98.47 233.43,98.46 233.49,98.43 233.53,98.38 233.56,98.35 234.4,98.35 234.42,98.39 234.44,98.39 234.53,98.43
+NVVDD1 on BOTTOM (solid shape): 238.97,95.73 239.02,95.73 239.13,95.63 239.23,95.59 239.24,95.58 239.28,95.55 240.05,95.55 240.09,95.61 240.14,95.65 240.19,95.69 240.32,95.73 240.45,95.69 240.5,95.65 240.55,95.61 240.59,95.55 241.45,95.55 241.49,95.61 241.54,95.65 241.59,95.69 241.72,95.73 241.85,95.69 241.9,95.65 241.95,95.61 241.99,95.55 242.72,95.55 242.77,95.52 242.76,95.46 242.71,95.41 242.7,95.41 242.52,95.26 242.53,95.03 242.53,94.93 242.44,94.88 242.09,94.88 241.99,94.97 241.95,94.97 241.89,95.03 241.87,95.03 241.72,95.07 241.57,95.03 241.55,95.03 241.49,94.97 241.47,94.97 241.4,94.94 241.35,94.9 240.71,94.9 240.67,94.94 240.57,94.97 240.55,94.97 240.51,95.01 240.41,95.1 240.23,95.1 240.13,95.01 240.09,94.97 240.05,94.97 239.95,94.88 239.26,94.88 239.15,94.98 239.1,95.04 239.04,95.1 238.84,95.1 238.84,95.15 238.8,95.29 238.7,95.39 238.69,95.42 238.69,95.45 238.69,95.57 238.84,95.72 238.9,95.72
+NVVDD1 on BOTTOM (solid shape): 241.4,108.66 241.47,108.63 241.49,108.63 241.57,108.55 241.62,108.55 241.63,108.55 241.72,108.53 241.81,108.55 241.82,108.55 241.87,108.55 241.95,108.63 241.99,108.63 242.01,108.64 242.39,108.64 242.48,108.55 242.48,108.08 242.4,108 242.16,108 242.07,108.02 241.96,108 241.89,107.95 241.85,107.9 241.72,107.87 241.59,107.9 241.55,107.95 241.48,108 241.43,108.01 241.36,108.08 240.68,108.08 240.61,108.01 240.56,108 240.53,107.98 240.11,107.98 240.08,108 239.97,108.02 239.88,108 239.36,108 239.35,108 239.17,108 239.03,107.88 238.88,107.88 238.76,107.97 238.73,108 238.67,108 238.67,108.06 238.68,108.11 238.69,108.2 238.76,108.26 238.82,108.33 238.83,108.4 238.84,108.44 238.87,108.5 238.93,108.53 238.97,108.54 239.02,108.55 239.09,108.55 239.12,108.58 239.17,108.62 239.23,108.65 239.27,108.66 239.41,108.8 239.85,108.8 240,108.66 240.07,108.63 240.09,108.63 240.2,108.52 240.44,108.52 240.55,108.63 240.57,108.63 240.64,108.66 240.81,108.82 241.23,108.82
+NVVDD1 on BOTTOM (solid shape): 238.73,92.8 238.86,92.91 239.02,92.93 239.05,92.9 239.08,92.86 239.17,92.8 239.22,92.79 239.24,92.75 240.05,92.75 240.09,92.81 240.14,92.85 240.19,92.89 240.32,92.93 240.45,92.89 240.5,92.85 240.55,92.81 240.59,92.75 241.45,92.75 241.49,92.81 241.54,92.85 241.59,92.89 241.72,92.93 241.85,92.9 241.89,92.84 241.95,92.81 241.99,92.75 242.72,92.75 242.77,92.72 242.76,92.66 242.71,92.61 242.7,92.61 242.52,92.46 242.53,92.23 242.53,92.13 242.44,92.08 242.09,92.08 241.99,92.17 241.95,92.17 241.89,92.23 241.87,92.23 241.72,92.27 241.57,92.23 241.55,92.23 241.49,92.17 241.47,92.17 241.4,92.14 241.35,92.1 240.71,92.1 240.67,92.14 240.57,92.17 240.55,92.17 240.51,92.21 240.41,92.3 240.23,92.3 240.13,92.21 240.09,92.17 240.05,92.17 239.95,92.08 239.26,92.08 239.15,92.18 239.1,92.24 239.04,92.3 238.84,92.3 238.84,92.35 238.8,92.49 238.7,92.59 238.68,92.68 238.67,92.7
+NVVDD1 on BOTTOM (solid shape): 234.48,103.02 234.51,102.99 234.62,102.88 234.58,102.84 234.56,102.79 234.51,102.74 234.48,102.68 234.45,102.66 234.45,102.52 234.42,102.45 234.35,102.42 234.32,102.41 234.28,102.4 233.77,102.4 233.67,102.42 233.59,102.4 233.56,102.4 233.48,102.34 233.45,102.31 233.32,102.27 233.19,102.31 233.15,102.35 233.08,102.4 232.97,102.42 232.89,102.4 232.88,102.4 232.37,102.4 232.27,102.42 232.19,102.4 232.16,102.4 232.09,102.35 232.05,102.31 231.92,102.27 231.79,102.31 231.76,102.34 231.69,102.39 231.68,102.4 231.57,102.42 231.49,102.4 231.48,102.4 231.32,102.4 231.22,102.5 231.22,102.93 231.32,103.03 231.65,103.03 231.65,103.03 231.69,103.03 231.8,102.92 232.04,102.92 232.15,103.03 232.3,103.05 232.94,103.05 233.03,103.04 233.04,103.03 233.36,102.9 233.64,103.1 234.4,103.1
+NVVDD1 on BOTTOM (solid shape): 234.48,108.62 234.51,108.59 234.58,108.52 234.71,108.52 234.77,108.49 234.8,108.43 234.81,108.39 234.82,108.33 234.88,108.26 234.93,108.22 235.09,108.06 235.04,108.02 234.98,108 234.91,108 234.88,107.97 234.76,107.88 234.61,107.88 234.47,108 234.29,108 234.28,108 233.76,108 233.67,108.02 233.56,108 233.48,107.94 233.45,107.91 233.32,107.87 233.19,107.91 233.15,107.95 233.08,108 232.97,108.02 232.88,108 232.36,108 232.27,108.02 232.16,108 232.09,107.95 232.05,107.91 231.92,107.87 231.79,107.91 231.76,107.94 231.68,108 231.57,108.02 231.48,108 231.3,108 231.2,108.11 231.2,108.5 231.32,108.63 231.69,108.63 231.8,108.52 232.04,108.52 232.15,108.63 232.17,108.63 232.3,108.65 232.94,108.65 232.95,108.65 232.98,108.65 233.02,108.65 233.07,108.63 233.09,108.63 233.2,108.52 233.44,108.52 233.55,108.63 233.57,108.63 233.64,108.7 234.4,108.7
+NVVDD1 on BOTTOM (solid shape): outline of 81 points within 230.84,105.07 234.97,105.9
+NVVDD1 on BOTTOM (solid shape): outline of 85 points within 238.67,105.07 242.8,106.02
+NVVDD1 on BOTTOM (solid shape): outline of 4291 points within 213.5,90.26 262.71,138.93
+NVVDD1 on IN1 (solid shape): outline of 13308 points within 217.37,90.79 261.18,138.8
+NVVDD1 on IN3 (solid shape): outline of 40940 points within 212.73,78.6 262.01,138.55
+NVVDD1 on IN6 (solid shape): outline of 14672 points within 216.82,90.4 262,140.06
+NVVDD1 on GND3: 228.78,92.19 227.78,93.19 227.78,110.01 213.18,124.62 213.18,135.46 215.44,137.72 260.32,137.72 261.18,136.85 261.18,121.57 247.34,107.73 247.34,93.38 246.16,92.19 ; 2 cut-outs
+NVVDD1 on GND4: 214.17,69.27 210.38,73.06 210.38,133.68 213.22,136.52 289.22,136.52 289.22,102.61 288.62,102.61 288.62,76.04 281.84,69.27 ; 5 cut-outs
+NVVDD2 on TOP (solid shape): outline of 212 points within 275.09,57.65 294.2,69.84
+NVVDD2 on BOTTOM (solid shape): 242.86,102.95 242.89,102.95 242.9,102.94 243.21,102.88 243.46,103.07 244.2,103.07 244.42,102.85 244.62,102.85 244.8,103.02 244.94,103.02 245.09,102.87 245.17,102.87 245.22,102.87 245.27,102.87 245.33,102.87 245.54,103.09 245.7,103.09 245.76,103.03 245.76,102.63 245.58,102.45 242.83,102.45 242.53,102.75 242.53,103.06 242.59,103.12 242.68,103.12
+NVVDD2 on BOTTOM (solid shape): 228.23,102.9 228.27,102.9 228.28,102.89 228.42,102.87 228.56,102.89 228.57,102.9 228.61,102.9 228.73,103.02 228.76,103.02 228.88,102.9 228.97,102.9 228.98,102.89 229.12,102.87 229.26,102.89 229.27,102.9 229.33,102.9 229.48,103.05 229.58,103.05 229.6,103.06 230.14,103.06 230.33,102.87 230.47,102.87 230.52,102.87 230.57,102.87 230.64,102.87 230.8,103.03 230.95,103.03 231.05,102.93 231.05,102.72 230.78,102.45 228.15,102.45 227.85,102.75 227.85,103 227.92,103.07 228.06,103.07
+NVVDD2 on BOTTOM (solid shape): 228.66,98.27 229.66,98.27 229.76,98.37 229.96,98.37 230.06,98.27 231.01,98.27 231.05,98.31 231.11,98.25 231.11,97.83 231.01,97.73 230.93,97.73 230.73,97.93 230.57,97.93 230.52,97.93 230.47,97.93 230.33,97.93 230.16,97.75 229.41,97.75 229.24,97.93 229.17,97.93 229.12,97.93 229.07,97.93 228.96,97.93 228.81,97.78 228.76,97.78 228.61,97.93 228.47,97.93 228.42,97.93 228.37,97.93 228.21,97.93 227.97,97.69 227.82,97.69 227.73,97.78 227.73,97.98 228.05,98.3 228.28,98.3 228.38,98.4 228.53,98.4
+NVVDD2 on BOTTOM (solid shape): 245.78,98.1 245.78,97.66 245.65,97.66 245.43,97.88 245.42,97.88 245.4,97.88 245.21,97.93 245.02,97.88 244.72,97.88 244.53,97.93 244.33,97.88 244.32,97.88 244.31,97.88 244.13,97.7 243.53,97.7 243.33,97.9 243.27,97.9 243.26,97.91 243.12,97.93 242.98,97.91 242.97,97.9 242.82,97.75 242.69,97.75 242.58,97.86 242.58,98.22 242.66,98.3 245.58,98.3
+NVVDD2 on BOTTOM (solid shape): 236.66,108.45 236.98,108.45 237.18,108.65 237.83,108.65 237.98,108.5 238.07,108.5 238.08,108.49 238.22,108.47 238.36,108.49 238.37,108.5 238.44,108.57 238.48,108.61 238.63,108.61 238.72,108.52 238.72,108.37 238.6,108.25 238.59,108.2 238.59,108.15 238.56,108.08 238.49,108.05 235.62,108.05 235.52,107.95 235.34,107.95 234.92,108.37 234.92,108.51 235.03,108.61 235.18,108.61 235.32,108.47 235.37,108.47 235.42,108.47 235.47,108.47 235.61,108.47 235.79,108.65 236.45,108.65
+NVVDD2 on BOTTOM (solid shape): 236.66,105.65 236.98,105.65 237.18,105.85 237.88,105.85 238.03,105.7 238.07,105.7 238.08,105.69 238.22,105.67 238.36,105.69 238.37,105.7 238.46,105.79 238.65,105.79 238.71,105.73 238.71,105.58 238.61,105.48 238.59,105.42 238.59,105.35 238.56,105.28 238.49,105.25 235.15,105.25 235.08,105.28 235.05,105.35 235.05,105.41 235.03,105.47 234.9,105.61 234.9,105.71 235.01,105.82 235.15,105.82 235.3,105.67 235.37,105.67 235.42,105.67 235.47,105.67 235.61,105.67 235.79,105.85 236.45,105.85
+NVVDD2 on BOTTOM (solid shape): 236.66,102.85 236.98,102.85 237.18,103.04 237.84,103.04 237.98,102.9 238.07,102.9 238.08,102.89 238.22,102.87 238.36,102.89 238.37,102.9 238.77,102.9 238.85,102.87 238.92,102.87 238.95,102.85 238.97,102.82 239.02,102.68 239.12,102.58 239.15,102.57 239.15,102.45 234.55,102.45 234.55,102.61 234.62,102.68 234.66,102.78 234.67,102.79 234.75,102.87 235.37,102.87 235.42,102.87 235.47,102.87 235.61,102.87 235.78,103.04 236.46,103.04
+NVVDD2 on BOTTOM (solid shape): 235.8,100.3 236.4,100.3 236.5,100.18 236.59,100.11 236.68,100.02 236.68,99.96 236.65,99.94 236.56,99.88 236.49,99.8 235.75,99.8 235.47,99.98 235.16,99.88 235.09,99.86 235.02,99.89 234.99,99.93 234.95,99.95 234.91,100.03 234.94,100.1 235.04,100.18 235.13,100.3 235.13,100.39 235.32,100.58 235.52,100.58
+NVVDD2 on BOTTOM (solid shape): 242.76,101.01 243.1,100.77 243.46,100.97 243.47,101 244.17,101 244.18,100.97 244.48,100.77 244.82,100.91 244.83,100.93 244.91,100.93 244.92,100.91 245.26,100.77 245.56,100.98 245.71,100.98 245.78,100.91 245.78,100.51 245.67,100.4 243.33,100.4 243.21,100.28 243.03,100.28 242.88,100.43 242.75,100.43 242.55,100.63 242.55,101.02 242.57,101.04 242.75,101.04
+NVVDD2 on BOTTOM (solid shape): 238.59,92.61 238.62,92.5 238.69,92.39 238.71,92.32 238.68,92.26 238.63,92.2 238.51,92.2 238.38,92.33 238.27,92.33 238.22,92.33 238.17,92.33 238.06,92.33 237.91,92.18 237.16,92.18 237.03,92.3 236.97,92.3 236.96,92.31 236.82,92.33 236.68,92.31 236.66,92.3 236.55,92.22 236.48,92.13 235.78,92.13 235.58,92.33 235.47,92.33 235.42,92.33 235.37,92.33 235.23,92.33 235.08,92.18 235.03,92.18 234.96,92.26 234.93,92.32 234.95,92.39 235.01,92.47 235.04,92.55 235.31,92.83 235.52,92.83 235.65,92.7 236.58,92.7 236.72,92.83 236.92,92.83 237.06,92.7 237.94,92.7 238.13,92.88 238.32,92.88
+NVVDD2 on BOTTOM (solid shape): 237.11,95.5 237.95,95.5 238.14,95.68 238.31,95.68 238.59,95.4 238.62,95.29 238.69,95.19 238.71,95.12 238.68,95.05 238.63,95 238.51,95 238.38,95.13 238.27,95.13 238.22,95.13 238.17,95.13 238.06,95.13 237.91,94.98 237.16,94.98 237.03,95.1 236.97,95.1 236.96,95.11 236.82,95.13 236.68,95.11 236.66,95.1 236.55,95.02 236.48,94.93 235.78,94.93 235.58,95.13 235.47,95.13 235.42,95.13 235.37,95.13 235.23,95.13 235.08,94.98 235.03,94.98 234.96,95.05 234.93,95.12 234.95,95.19 235.01,95.27 235.04,95.36 235.05,95.38 235.35,95.68 235.49,95.68 235.67,95.5 236.53,95.5 236.72,95.68 236.93,95.68
+NVVDD2 on BOTTOM (solid shape): 228.58,100.4 228.96,100.4 229.03,100.47 229.18,100.47 229.28,100.37 229.63,100.37 229.76,100.5 229.86,100.5 229.96,100.4 230.38,100.4 230.46,100.47 230.58,100.47 230.66,100.4 231.15,100.4 231.18,100.37 231.18,99.95 231.05,99.82 230.86,99.82 230.54,100.03 230.19,99.85 229.45,99.85 229.16,100.03 228.84,99.91 228.77,99.88 228.7,99.91 228.36,100.03 228.07,99.81 227.89,99.81 227.8,99.9 227.8,100.1 228.05,100.35 228.21,100.35 228.38,100.52 228.46,100.52
+NVVDD2 on BOTTOM (solid shape): 289.62,72.47 289.62,71.13 290.08,70.67 291.35,70.67 292.3,69.71 292.3,61.8 292.21,61.71 289.7,61.71 289.25,61.27 289.25,57.9 289.06,57.71 277.63,57.71 274.1,61.24 274.1,68.24 274.98,69.12 276.92,69.12 276.99,69.05 276.99,67.05 277.39,66.65 281.86,66.65 282.06,66.45 282.06,65.78 282.13,65.75 282.17,65.68 282.19,65.58 282.25,65.49 282.27,65.42 282.25,65.36 282.52,64.78 282.79,65.36 282.77,65.42 282.79,65.49 282.85,65.58 282.88,65.68 282.91,65.75 282.98,65.78 284.87,65.78 285.63,66.54 285.63,70.92 287.43,72.72 289.37,72.72
+NVVDD2 on BOTTOM (solid shape): 231.06,108.53 231.06,108.37 230.69,107.99 230.64,107.95 230.4,107.95 230.21,108.05 230,108 229.64,108 229.43,108.05 229.24,107.95 229,107.95 228.77,108.06 228.54,107.95 228.3,107.95 228.27,107.98 228.22,108.02 227.87,108.36 227.87,108.52 227.99,108.64 228.13,108.64 228.41,108.49 228.7,108.63 228.84,108.63 228.88,108.59 228.95,108.53 229.19,108.5 229.39,108.62 230.25,108.62 230.44,108.5 230.65,108.52 230.69,108.54 230.75,108.58 230.81,108.64 230.95,108.64
+NVVDD2 on BOTTOM (solid shape): 238.31,98.48 238.36,98.43 238.41,98.39 238.59,98.21 238.59,98.2 238.62,98.09 238.69,97.99 238.71,97.92 238.68,97.86 238.63,97.8 238.51,97.8 238.38,97.93 238.22,97.93 238.06,97.93 237.91,97.78 237.16,97.78 237.03,97.9 236.97,97.9 236.96,97.91 236.82,97.93 236.68,97.91 236.66,97.9 236.55,97.82 236.48,97.73 235.78,97.73 235.58,97.93 235.42,97.93 235.23,97.93 235.08,97.78 235.03,97.78 234.96,97.86 234.93,97.92 234.95,97.99 235.01,98.08 235.05,98.18 235.05,98.2 235.31,98.46 235.53,98.46 235.57,98.42 235.62,98.39 235.71,98.3 236.52,98.3 236.6,98.37 236.67,98.42 236.72,98.48 236.92,98.48 236.96,98.43 237.01,98.39 237.1,98.3 237.94,98.3 238.09,98.43 238.13,98.48
+NVVDD2 on BOTTOM (solid shape): 229.22,92.88 229.26,92.83 229.3,92.79 229.35,92.74 229.39,92.74 229.4,92.72 229.64,92.72 229.66,92.74 230.06,92.74 230.08,92.72 230.23,92.72 230.27,92.76 230.28,92.77 230.36,92.81 230.42,92.88 230.61,92.88 230.67,92.82 231.05,92.44 231.05,92.27 230.95,92.17 230.8,92.17 230.77,92.2 230.74,92.23 230.68,92.29 230.64,92.29 230.63,92.29 230.52,92.31 230.41,92.29 230.39,92.29 230.38,92.28 230.29,92.22 230.24,92.17 229.4,92.17 229.35,92.22 229.3,92.26 229.26,92.29 229.12,92.31 228.98,92.29 228.95,92.26 228.89,92.22 228.84,92.17 228.7,92.17 228.65,92.22 228.6,92.26 228.56,92.29 228.42,92.31 228.27,92.29 228.22,92.24 228.17,92.21 228.13,92.16 227.96,92.16 227.88,92.24 227.88,92.45 228.21,92.78 228.27,92.82 228.32,92.88 228.51,92.88 228.55,92.83 228.58,92.81 228.66,92.73 228.86,92.73 228.9,92.77 228.97,92.82 229.02,92.88
+NVVDD2 on BOTTOM (solid shape): 228.5,95.7 228.75,95.55 229.02,95.67 229.22,95.67 229.29,95.61 229.36,95.56 229.38,95.56 229.4,95.52 229.64,95.52 229.73,95.62 229.97,95.62 230.01,95.59 230.08,95.52 230.23,95.52 230.25,95.56 230.27,95.56 230.36,95.61 230.42,95.68 230.62,95.68 230.66,95.63 230.72,95.58 230.75,95.54 230.96,95.33 230.96,95.29 231.03,95.14 230.94,95 230.91,94.99 230.9,94.97 230.8,94.97 230.74,95.03 230.69,95.06 230.67,95.08 230.52,95.11 230.37,95.08 230.35,95.07 230.33,95.05 230.28,95.01 230.24,94.97 229.4,94.97 229.35,95.02 229.3,95.06 229.23,95.13 229.02,95.13 228.95,95.07 228.89,95.02 228.84,94.97 228.7,94.97 228.6,95.08 228.56,95.08 228.55,95.08 228.42,95.11 228.29,95.08 228.27,95.08 228.19,95.02 228.14,94.97 227.97,94.97 227.88,95.06 227.88,95.26 228.2,95.57 228.2,95.58 228.28,95.63 228.34,95.7
+NVVDD2 on BOTTOM (solid shape): 245.98,108.98 246.03,108.96 246.06,108.93 246.1,108.9 246.14,108.77 246.09,108.64 246.07,108.61 246.07,108.58 245.53,108.04 244.76,108.04 244.74,108.03 244.67,107.98 244.61,107.91 244.43,107.91 244.37,107.98 244.29,108.03 244.18,108.14 242.9,108.14 242.76,108.28 242.72,108.29 242.61,108.4 242.64,108.55 242.66,108.59 242.68,108.63 242.68,108.67 242.8,108.67 242.88,108.58 242.98,108.52 243.21,108.51 243.4,108.64 244.25,108.64 244.3,108.6 244.34,108.55 244.37,108.5 244.67,108.5 244.69,108.55 244.73,108.59 244.77,108.62 244.79,108.64 244.93,108.64 245.12,108.51 245.35,108.52 245.37,108.52 245.45,108.58 245.56,108.69 245.63,108.82 245.67,108.86 245.68,108.87 245.76,108.91 245.82,108.97 245.82,108.98 245.87,109
+NVVDD2 on BOTTOM (solid shape): 242.83,105.84 243.11,105.69 243.4,105.83 244.25,105.83 244.27,105.83 244.29,105.83 244.42,105.7 244.67,105.7 244.69,105.75 244.73,105.8 244.79,105.83 244.94,105.83 245.21,105.69 245.49,105.82 245.5,105.83 245.66,105.83 245.75,105.74 245.75,105.54 245.42,105.22 245.36,105.17 245.31,105.12 245.12,105.12 245.09,105.17 244.99,105.25 244.87,105.26 244.77,105.25 244.75,105.23 244.67,105.18 244.61,105.12 244.43,105.12 244.39,105.17 244.33,105.22 244.3,105.22 244.17,105.26 244.04,105.22 244.02,105.22 243.62,105.22 243.6,105.22 243.39,105.25 243.22,105.13 243.02,105.13 242.96,105.19 242.89,105.23 242.9,105.28 242.9,105.39 242.81,105.48 242.76,105.49 242.62,105.58 242.64,105.75 242.66,105.79 242.71,105.84
+NVVDD2 on BOTTOM (solid shape): 243.21,95.69 243.29,95.61 243.38,95.56 243.39,95.55 243.5,95.55 244.14,95.55 244.27,95.55 244.28,95.56 244.29,95.57 244.37,95.62 244.43,95.68 244.44,95.69 244.6,95.69 244.61,95.68 244.68,95.61 244.75,95.57 244.76,95.56 244.78,95.55 244.95,95.55 244.95,95.56 244.97,95.56 245.06,95.61 245.13,95.69 245.29,95.69 245.76,95.22 245.76,95.06 245.66,94.97 245.5,94.97 245.28,95.1 245.04,95.06 245.02,95.05 245.01,95.05 244.93,94.97 244.8,94.97 244.63,95.09 244.41,95.09 244.38,95.09 244.29,95.02 244.23,94.96 243.41,94.96 243.35,95.02 243.28,95.07 243.22,95.13 243,95.13 242.83,94.96 242.7,94.96 242.64,95.02 242.62,95.07 242.62,95.22 242.72,95.31 242.76,95.32 242.83,95.39 242.87,95.45 242.88,95.51 242.87,95.53 242.9,95.57 242.91,95.58 242.98,95.63 243.03,95.69
+NVVDD2 on BOTTOM (solid shape): 243.23,92.86 243.29,92.81 243.35,92.77 243.36,92.76 243.38,92.75 243.47,92.74 243.52,92.75 244.12,92.75 244.17,92.74 244.26,92.75 244.28,92.76 244.29,92.77 244.35,92.81 244.41,92.86 244.63,92.86 244.69,92.8 244.76,92.77 244.77,92.76 244.78,92.75 244.87,92.74 244.94,92.75 244.96,92.76 245.04,92.8 245.11,92.86 245.33,92.86 245.37,92.82 245.42,92.79 245.45,92.76 245.76,92.46 245.76,92.26 245.65,92.16 245.51,92.16 245.5,92.18 245.23,92.31 244.95,92.19 244.79,92.19 244.52,92.31 244.25,92.19 243.39,92.19 243.34,92.23 243.3,92.26 243.26,92.3 243.12,92.31 242.98,92.3 242.95,92.26 242.89,92.22 242.84,92.16 242.7,92.16 242.64,92.22 242.62,92.27 242.62,92.41 242.72,92.51 242.76,92.52 242.83,92.59 242.87,92.65 242.88,92.72 242.87,92.74 242.9,92.77 242.96,92.81 243.01,92.86
+NVVDD2 on BOTTOM (solid shape): 228.12,105.85 228.17,105.79 228.27,105.71 228.32,105.71 228.42,105.69 228.52,105.71 228.57,105.71 228.65,105.78 228.7,105.83 228.84,105.83 229.12,105.69 229.4,105.83 230.24,105.83 230.43,105.71 230.65,105.72 230.69,105.74 230.76,105.78 230.81,105.84 230.94,105.84 231.01,105.77 231.03,105.7 231.01,105.56 230.88,105.49 230.83,105.48 230.74,105.39 230.74,105.28 230.75,105.23 230.67,105.18 230.61,105.12 230.43,105.12 230.36,105.19 230.28,105.23 230.26,105.25 230.17,105.26 230.1,105.25 229.54,105.25 229.47,105.26 229.34,105.25 229.24,105.15 229,105.15 228.77,105.26 228.54,105.15 228.3,105.15 228.25,105.19 228.19,105.23 227.88,105.54 227.88,105.75 227.98,105.85
+NVVDD2 on IN4 (solid shape): outline of 69086 points within 227.97,52.76 296.43,124.89
+NVVDD2 on IN5: 234.49,51.74 233.82,52.42 233.82,57.44 232.59,58.66 214.87,58.66 211.21,62.33 211.21,92.6 227.44,108.83 276.19,108.83 276.76,108.26 279.01,108.26 279.09,108.34 279.09,95.58 282.27,92.4 282.27,71.13 283.75,69.65 290.42,69.65 294.71,65.35 294.71,51.74 ; 5 cut-outs
+PEX_VDD on TOP (solid shape): outline of 193 points within 240.29,109.12 243.98,115.66
+PEX_VDD on TOP (solid shape): outline of 202 points within 228.16,109.4 235.14,120.77
+PEX_VDD on BOTTOM (solid shape): 233.43,53.33 233.43,52 233.82,51.62 235.47,51.62 235.78,51.3 235.78,48.62 235.26,48.09 234.79,48.09 234.79,48.64 234.28,48.64 234.28,48.09 233.99,48.09 233.99,48.64 233.48,48.64 233.48,48.09 233.01,48.09 233.01,48.09 232.32,48.09 231.96,48.46 231.96,50.22 234.92,50.22 234.92,50.19 234.93,50.14 234.94,50.09 234.97,50.04 235,50 235.03,49.96 235.08,49.92 235.12,49.9 235.17,49.88 235.22,49.87 235.28,49.86 235.33,49.87 235.38,49.88 235.43,49.9 235.48,49.92 235.52,49.96 235.56,50 235.59,50.04 235.61,50.09 235.62,50.14 235.63,50.19 235.63,50.25 235.62,50.3 235.61,50.35 235.59,50.4 235.56,50.44 235.52,50.48 235.48,50.51 235.43,50.54 235.38,50.56 235.33,50.57 235.28,50.58 235.22,50.57 235.17,50.56 235.12,50.54 235.08,50.51 235.03,50.48 235,50.44 234.97,50.4 234.94,50.35 234.93,50.3 234.92,50.25 234.92,50.22 231.96,50.22 231.96,50.66 231.02,51.6 231.02,53.97 231.21,54.16 232.61,54.16
+PEX_VDD on BOTTOM (solid shape): 233.31,112.12 233.39,112.08 233.41,112 233.42,111.86 233.49,111.75 233.49,111.51 233.67,110.93 233.85,111.51 233.85,111.75 233.92,111.86 233.93,112 233.93,112.02 234.1,112.03 234.24,112.12 234.53,112.12 234.64,112.01 234.64,110.87 234.47,110.7 232.84,110.7 232.44,110.7 231.92,111.21 231.89,111.41 231.75,111.56 231.75,111.75 231.81,111.83 231.84,111.94 231.87,112.01 231.95,112.03 232.08,112.05 232.19,112.12
+PEX_VDD on BOTTOM (solid shape): 241.45,112.82 241.68,112.73 241.9,112.83 242.53,112.83 242.53,112.77 242.51,112.71 242.47,112.67 242.45,112.67 242.23,112.56 242.15,112.33 242.13,112.25 242.06,112.22 241.82,112.04 241.89,111.75 241.89,111.51 242.07,110.93 242.25,111.51 242.25,111.75 242.31,111.83 242.34,111.94 242.37,112.01 242.45,112.03 242.68,112.11 242.79,112.33 242.79,112.35 242.83,112.39 242.84,112.39 243,112.51 243.03,112.71 243.05,112.79 243.13,112.83 243.54,112.83 243.66,112.75 243.79,112.73 243.82,112.73 243.98,112.58 243.98,112.13 243.9,111.95 243.98,111.77 243.98,111.5 243.85,111.25 243.98,111 243.98,110.86 243.79,110.67 241.37,110.67 241.18,110.86 241.18,112.64 241.37,112.83 241.44,112.83
+PEX_VDD on IN5: 227.23,109.34 225.98,108.08 225.73,107.98 225.64,107.74 210.7,92.81 210.7,62.12 214.66,58.16 232.38,58.16 233.31,57.23 233.31,50.9 232.82,50.41 215.13,50.41 206.38,59.15 206.38,95.01 207.34,95.96 207.34,105.06 207.31,105.08 214.55,105.08 218.32,108.85 218.32,112.34 219.27,113.3 219.27,116.09 220.14,116.96 242.98,116.96 243.98,115.96 243.98,109.34
+RTC_CELL on BOTTOM (solid shape): 215.15,17.63 215.15,17.15 216.26,16.03 216.26,15.24 215.96,14.94 215.71,14.94 215.55,15.09 215.55,15.73 214.35,16.93 214.35,16.95 214.33,17.08 214.26,17.19 214.26,17.63 214.36,17.73 215.05,17.73
+TBTA_VBUS on TOP (solid shape): outline of 213 points within 202.51,160.12 206.38,166.72
+TBTA_VBUS on TOP (solid shape): outline of 203 points within 190.22,176.7 194.34,181.9
+TBTA_VBUS on BOTTOM (solid shape): 194.28,180.73 194.28,178.97 193.92,178.62 193.92,178.55 193.9,178.43 193.92,178.3 193.92,178 193.79,177.86 193.59,177.86 193.45,178.01 193.45,178.81 193.96,179.32 193.96,180.74 194.02,180.81 194.2,180.81
+TBTA_VBUS on BOTTOM (solid shape): 202.79,162.47 202.79,161.58 202.81,161.57 202.81,161.51 203.04,161.27 203.04,161.15 203.3,160.9 203.3,160.6 203.22,160.52 203.05,160.52 202.88,160.68 202.83,160.68 202.54,160.98 202.54,161.07 202.54,161.08 202.56,161.2 202.54,161.33 202.54,161.34 202.54,161.48 202.57,161.52 202.57,162.45 202.62,162.5 202.77,162.5
+TBTA_VBUS on BOTTOM (solid shape): 191.41,180.79 191.41,180.75 191.39,180.65 191.41,180.55 191.41,180.51 191.43,180.49 191.5,180.4 191.58,180.33 191.74,180.18 191.74,179.71 191.74,179.7 191.74,179.2 191.92,179.03 191.92,178.12 191.79,178 191.56,178 191.42,178.14 191.42,180.2 191.23,180.39 191.05,180.39 190.96,180.48 190.96,180.73 191.11,180.87 191.33,180.87
+TBTA_VBUS on BOTTOM (solid shape): 209.11,167.76 209.11,166.67 208.52,166.07 206.1,166.07 205.96,166.21 205.51,166.21 205.33,166.03 205.01,166.22 204.78,165.93 204.45,165.6 203.58,165.6 203.26,165.28 203.01,165.28 202.97,165.32 202.97,165.55 202.84,165.68 202.61,165.68 202.55,165.74 202.56,165.75 202.56,166.04 202.6,166.08 202.84,166.08 202.98,166.22 202.98,166.42 203.11,166.54 203.23,166.54 203.4,166.71 204.1,166.71 204.19,166.8 204.6,166.87 204.67,167.28 205.04,167.65 205.05,167.65 205.34,167.95 208.92,167.95
+TBTA_VBUS on IN2 (solid shape): outline of 2862 points within 190.33,160.52 206.46,181.3
ADPIN on BOTTOM (solid shape): outline of 83 points within 76.38,33.76 86.37,49.58
AMP_ASEL on BOTTOM (solid shape): 35.37,17.14 35.89,17.14 35.96,17.08 35.96,16.57 35.89,16.5 35.64,16.5 35.51,16.38 35.51,15.93 35.38,15.81 35.13,15.81 35,15.93 35,16.38 34.88,16.5 34.55,16.5 34.42,16.63 34.42,17.08 34.48,17.14 35.37,17.14
AMP_LDO_A1.5V on BOTTOM (solid shape): 34.23,16.19 34.23,15.81 34.43,15.61 35.51,15.61 35.55,15.56 35.55,15.09 35.51,15.05 34.04,15.05 33.72,15.37 33.72,16.19 33.85,16.32 34.1,16.32
B+ on TOP (solid shape): 249.1,41.49 249.1,39.4 248.61,38.91 247.97,38.91 247.55,39.33 247.55,41.54 247.75,41.75 248.85,41.75
B+ on TOP (solid shape): 119.83,125.44 119.83,123.88 117.29,121.34 117.29,112.25 117.04,111.99 113.93,111.99 113.69,112.23 113.69,125.34 113.94,125.59 119.68,125.59
B+ on TOP (solid shape): 258.63,15.77 259.95,15.77 260.09,15.63 260.09,14.63 259.88,14.43 256.74,14.43 253.87,11.56 251.95,11.56 251.71,11.8 251.71,14.6 253.04,15.92 258.47,15.92
B+ on TOP (solid shape): outline of 560 points within 132.81,136.33 140.65,158.52
B+ on TOP (solid shape): outline of 933 points within 80.34,25.52 100.97,57.27
B+ on BOTTOM (solid shape): 235.23,38.86 235.23,36.89 234.93,36.6 233.43,36.6 233.16,36.88 233.16,37.43 233.7,37.43 233.7,37.86 233.16,37.86 233.16,38.83 233.5,39.18 234.91,39.18
B+ on BOTTOM (solid shape): 140.14,143.67 140.14,139.32 138.92,138.1 138.92,133.82 137.68,132.58 135.84,132.58 135.24,133.18 135.24,144.88 135.47,145.12 138.69,145.12
B+ on BOTTOM (solid shape): 249.48,42.11 249.48,40.39 249.21,40.12 247.15,40.12 246.96,40.31 246.96,41.28 246.96,41.28 246.96,41.56 247.48,41.56 247.48,41.99 246.96,41.99 246.96,42.54 247.02,42.6 248.99,42.6
B+ on BOTTOM (solid shape): 58.36,35.82 59.13,35.82 59.13,39.15 60.37,39.15 60.4,39.13 60.4,35.42 59.64,34.66 59.64,33.46 57.98,31.8 57.98,29.52 57.54,29.07 55.51,29.07 55.13,29.45 55.13,31.93 53.92,33.14 51.89,33.14 51.44,33.58 51.44,35.36 52.14,36.06 54.36,36.06 55.83,37.52 55.83,38.54 56.4,39.11 56.4,39.11 56.45,39.15 58.36,39.15
B+ on BOTTOM (solid shape): 104.25,64.16 104.25,61.83 100.33,57.91 100.33,56.62 96.97,53.26 96.97,52.25 96.4,51.68 94.69,51.68 94.37,52 94.37,53.78 97.25,56.66 97.25,57.45 97.42,57.62 97.42,59.94 100.03,62.54 100.03,62.68 100.7,63.35 100.7,64.36 100.88,64.55 103.87,64.55
B+ on BOTTOM (solid shape): 156.8,170.92 158.05,170.92 158.17,170.8 158.17,170.63 158.16,170.62 158.16,170.49 158.02,170.36 156.74,170.36 156.63,170.25 156.5,170.25 156.25,170 156.25,169.81 155.98,169.54 155.98,168.64 155.95,168.61 155.2,168.61 154.14,169.67 151.52,169.67 151.35,169.84 151.35,170.46 151.47,170.58 153.28,170.58 153.69,171 154.38,171 154.92,171.54 156.18,171.54
B+ on BOTTOM (solid shape): 123.6,129.27 123.6,127.44 123.02,126.86 122.06,126.86 119.68,124.49 119.68,123.5 119.13,122.95 119.13,122.72 118.88,122.47 118.56,122.47 118.56,123.04 118.06,123.04 118.06,122.47 117.77,122.47 117.77,122.47 117.66,122.47 117.1,121.91 117.1,117.59 116.21,116.7 113.69,116.7 113.69,126.64 118.21,126.64 118.21,126.58 118.22,126.53 118.23,126.48 118.25,126.43 118.28,126.39 118.32,126.35 118.36,126.31 118.41,126.29 118.46,126.27 118.51,126.26 118.56,126.25 118.62,126.26 118.67,126.27 118.72,126.29 118.76,126.31 118.81,126.35 118.84,126.39 118.87,126.43 118.9,126.48 118.91,126.53 118.92,126.58 118.92,126.64 118.91,126.69 118.9,126.74 118.87,126.79 118.84,126.83 118.81,126.87 118.76,126.9 118.72,126.93 118.67,126.95 118.62,126.96 118.56,126.97 118.51,126.96 118.46,126.95 118.41,126.93 118.36,126.9 118.32,126.87 118.28,126.83 118.25,126.79 118.23,126.74 118.22,126.69 118.21,126.64 113.69,126.64 113.69,127.71 116.34,130.36 122.51,130.36
B+ on IN1 (solid shape): 106.5,24.25 106.5,22.72 107.32,21.9 107.32,19.61 107.07,19.36 105.42,19.36 102.05,22.72 102.05,24.76 102.94,25.64 105.1,25.64
B+ on IN1 (solid shape): outline of 265 points within 183.73,4.25 203.59,9.93
B+ on IN1 (solid shape): outline of 433 points within 223.4,4.37 254.39,13.04
B+ on IN2 (solid shape): outline of 1861 points within 138.79,152 160.44,171.08
B+ on IN2 (solid shape): outline of 2577 points within 54.62,27.66 91.89,44.89
B+ on IN3 (solid shape): 120.32,125.36 120.32,123.68 120.11,123.47 117.53,123.47 116.77,122.71 116.77,117.84 116.4,117.47 113.98,117.47 113.69,117.76 113.69,124.38 115.04,125.73 119.95,125.73
B+ on IN3 (solid shape): outline of 462 points within 81.91,30.03 99.81,57.98
B+ on IN6 (solid shape): outline of 3238 points within 53.54,23.04 105.36,44.19
B+_1.0VS_VGAP on BOTTOM (solid shape): 244.68,42.87 246.4,42.87 246.81,42.46 246.81,41.28 246.79,41.25 246.25,41.25 246.19,41.31 243.31,41.31 243.19,41.44 243.19,41.58 242.89,41.88 242.89,43.4 242.95,43.46 244.09,43.46
B+_+1.8VGS on BOTTOM (solid shape): 232.99,41.51 232.99,39.11 233,39.09 233,36.95 232.55,36.49 231.19,36.49 230.88,36.8 230.88,39.66 231.02,39.94 230.88,40.23 230.88,41.15 230.72,41.32 230.72,42.78 230.83,42.89 231.61,42.89
B+_BIAS on TOP (solid shape): 69.75,15.71 69.75,12.14 69.54,11.92 68.02,11.92 67.88,11.78 66.65,11.78 66.49,11.93 66.49,15.58 66.8,15.88 69.58,15.88
B+_BIAS on TOP (solid shape): 324.91,11.79 326.01,11.79 326.11,11.69 326.11,11.27 326.06,11.23 324.53,11.23 324.35,11.4 324.35,11.77 324.49,11.91 324.79,11.91
B+_BIAS on BOTTOM (solid shape): 28.43,6.59 28.43,6.22 28.43,6.13 28.44,6.12 28.97,6.12 28.98,6.11 28.98,5.86 28.97,5.85 28.45,5.85 28.43,5.84 28.43,5.32 28.44,5.31 28.97,5.31 28.98,5.31 28.98,5.05 28.98,5.05 28.47,5.05 28.43,5.01 28.43,4.44 28.39,4.4 28.39,3.71 28.39,3.71 28.11,3.43 27.25,3.43 27.12,3.55 27.12,4.82 27.5,5.2 27.71,5.2 27.82,5.31 27.94,5.39 28.03,5.51 28.05,5.66 28.01,5.81 28.01,6.51 28.09,6.59 28.43,6.59
B+_BIAS on IN2 (solid shape): 30.93,6.59 30.93,4.94 30.43,4.44 29.44,4.44 29.43,4.44 29.28,4.47 29.13,4.44 29.12,4.44 29.03,4.44 28.84,4.25 28.84,3.99 28.2,3.36 27.25,3.36 27.06,3.55 27.06,4.63 27.19,4.75 27.76,4.75 28.39,5.39 29.54,5.39 29.66,5.52 29.66,5.96 28.84,6.79 28.84,7.23 30.3,7.23
B+_BIAS on IN2 (solid shape): 69.92,10.09 69.67,9.83 67.2,9.83 67.19,9.86 66.86,10.08 66.53,9.86 66.52,9.83 65.92,9.83 65.73,10.02 65.73,11.69 65.77,11.7 65.98,11.88 66,12.16 66.02,12.25 66.1,12.3 69.92,12.3
B+_BIAS on IN2 (solid shape): 41.66,9.52 41.66,8.88 40.71,7.93 37.92,7.93 37.6,7.61 35.7,7.61 35.7,8.86 39.21,8.86 39.21,8.8 39.22,8.75 39.24,8.7 39.26,8.65 39.29,8.61 39.33,8.57 39.37,8.54 39.41,8.51 39.46,8.49 39.52,8.48 39.57,8.47 39.62,8.48 39.67,8.49 39.72,8.51 39.77,8.54 39.81,8.57 39.85,8.61 39.88,8.65 39.9,8.7 39.92,8.75 39.92,8.8 39.92,8.86 39.92,8.91 39.9,8.96 39.88,9.01 39.85,9.05 39.81,9.09 39.77,9.12 39.72,9.15 39.67,9.17 39.62,9.18 39.57,9.19 39.52,9.18 39.46,9.17 39.41,9.15 39.37,9.12 39.33,9.09 39.29,9.05 39.26,9.01 39.24,8.96 39.22,8.91 39.21,8.86 35.7,8.86 35.7,9.07 35.76,9.13 36.46,9.13 37.35,10.02 40.65,10.02 40.84,10.21 40.97,10.21
B+_VCCIO on BOTTOM (solid shape): 120.44,123.13 120.44,120.92 120.25,120.93 120.07,120.87 119.76,120.13 120.44,119.72 120.44,119.19 120.53,119.1 120.53,117.6 120.45,117.52 119.57,117.52 119.17,117.92 118.34,117.92 118.19,118.07 118.19,121.32 117.74,121.78 117.74,122.26 117.81,122.33 118.22,122.33 118.22,122.88 118.41,122.88 118.41,122.33 118.93,122.33 119.31,122.71 119.31,122.89 119.62,123.19 120.38,123.19
BATT+ on BOTTOM (solid shape): 87,28.88 88.65,28.88 88.72,28.82 88.72,24.95 88.34,24.57 83,24.57 82.11,23.68 81.52,23.68 81.36,23.52 81.36,22.92 81.23,22.79 78.81,22.79 78.56,23.04 78.56,25.14 78.62,25.2 79.47,25.2 79.47,25.2 79.47,24.58 79.83,24.22 80.18,24.58 80.18,25.2 81.03,25.2 81.42,25.58 81.42,28.95 81.73,29.26 86.62,29.26
BATT++ on TOP (solid shape): 85.67,22.28 85.67,20.95 85.35,20.63 82.94,20.63 82.81,20.76 82.81,22.34 83,22.53 85.42,22.53
BATT++ on BOTTOM (solid shape): 89.32,23.01 93.39,23.01 93.93,22.47 93.93,12.22 93.81,12.11 87.02,12.11 86.81,12.31 86.81,19.14 86.81,19.18 87.03,19.39 87.03,19.96 86.77,20.23 84.54,20.23 84.15,20.63 82.05,20.63 81.64,21.03 81.64,23.3 81.75,23.4 82.03,23.4 82.5,23.87 88.46,23.87
BATT++ on IN4 (solid shape): 85.86,21.36 85.86,20.91 85.63,20.68 83.6,20.68 83.35,20.93 83.35,21.19 83.75,21.59 85.63,21.59
BOOT_1.2V on BOTTOM (solid shape): 90.05,45.9 91.55,45.9 91.6,45.85 91.6,45.73 91.56,45.7 90.31,45.7 89.69,45.08 89.29,45.08 89.23,45.14 89.23,46.03 89.29,46.09 89.86,46.09
BS2_1.0VS_VGAP on BOTTOM (solid shape): 249.05,45.15 249.05,43.11 248.98,43.05 248.3,43.05 248.24,43.11 248.24,45.17 248.28,45.21 248.98,45.21
BS2_+1.8VGS on BOTTOM (solid shape): 234.48,44.69 234.48,44.44 234.49,44.42 234.49,42.42 234.37,42.31 233.71,42.31 233.54,42.48 233.54,44.66 233.7,44.82 234.35,44.82
BS_1.0VS_VGAP on BOTTOM (solid shape): 246.78,44.09 247.49,44.09 247.63,43.94 247.63,43.08 247.55,43 244.74,43 244.16,43.59 243.02,43.59 242.92,43.69 242.92,43.82 243.24,44.14 246.73,44.14
BS_+1.8VGS on BOTTOM (solid shape): 233.07,43.3 233.07,42.43 233,42.37 232.34,42.37 231.68,43.03 230.82,43.03 230.7,43.15 230.7,43.25 231,43.54 232.83,43.54
BST2_3V on BOTTOM (solid shape): 59,47.74 59,45.96 58.87,45.84 58.37,45.84 58.05,46.16 58.05,47.74 58.17,47.87 58.87,47.87
BST2_5V on BOTTOM (solid shape): 49.67,47.49 49.67,46.03 49.54,45.9 48.9,45.9 48.78,46.03 48.78,47.55 48.97,47.74 49.41,47.74
BST2_+1VALWP on TOP (solid shape): 248.77,24.09 248.77,21.42 248.74,21.39 247.85,21.39 247.76,21.48 247.76,22.25 247.56,22.44 247.56,24.15 247.66,24.25 248.61,24.25
BST2_VCCIO on BOTTOM (solid shape): 119.85,115.38 119.85,114.52 119.71,114.38 118.11,114.38 117.85,114.63 117.85,115.5 117.93,115.58 119.65,115.58
BST_1.2V on BOTTOM (solid shape): 88.71,46.05 88.71,43.41 88.53,43.23 87.83,43.23 87.72,43.35 87.72,46.05 87.77,46.1 88.65,46.1
BST_3V on BOTTOM (solid shape): 56.4,46.99 57.48,46.99 57.6,46.86 57.6,46.03 57.54,45.97 56.9,45.97 55.95,46.92 55.06,46.92 54.93,47.05 54.93,47.11 55,47.18 56.2,47.18
BST_5V on BOTTOM (solid shape): 52.76,47.15 52.76,47.01 52.73,46.97 51.65,46.97 51.2,46.53 51.2,45.97 51,45.77 50.43,45.77 50.36,45.84 50.36,46.74 50.81,47.19 52.73,47.19
BST_+1VALWP on TOP (solid shape): 247.02,24.06 247.02,22.91 246.71,22.6 246.71,21.77 246.58,21.64 245.88,21.64 245.75,21.77 245.75,24.12 245.88,24.25 246.83,24.25
BST_VCCIO on BOTTOM (solid shape): 120.52,117.26 120.52,117.17 119.36,116.01 117.95,116.01 117.84,116.12 117.84,116.89 117.87,116.92 119.09,116.92 119.51,117.33 120.45,117.33
BTST_CHG on TOP (solid shape): 60.53,23.97 61.68,23.97 61.74,23.92 61.74,23.04 61.68,22.99 61.11,22.99 61.06,23.04 61.06,23.5 60.91,23.65 60.53,23.65 60.26,23.92 59.11,23.92 59.04,23.98 59.04,24.09 59.08,24.13 60.36,24.13
BTST_CHG2 on TOP (solid shape): 63.13,25.14 63.13,23.04 63,22.91 62.43,22.91 62.37,22.98 62.37,23.93 62.56,24.12 62.56,24.57 62.37,24.76 62.37,25.33 62.43,25.39 62.87,25.39
CHG_B+ on TOP (solid shape): 75,28.69 75,23.42 74.41,22.83 69.63,22.83 69.29,23.17 69.29,27.8 68.62,28.47 65,28.47 64.72,28.76 61.41,28.76 61.22,28.95 61.22,30.92 62.18,31.87 71.83,31.87
CHG_B+ on BOTTOM (solid shape): 62.81,31.87 64.84,31.87 65.16,31.55 65.16,29.26 64.59,28.69 59.64,28.69 59,29.33 59,31.87 59.76,32.63 62.05,32.63
CORE_SW1 on BOTTOM (solid shape): 149.35,146.59 149.35,145.45 149.51,145.29 153.3,145.29 153.4,145.19 153.4,141.45 153.2,141.24 151.62,141.24 151.42,141.44 150.62,141.44 150.42,141.24 148.98,141.24 148.93,141.29 148.93,141.3 148.75,141.48 148.75,143.79 148.65,143.89 148.65,146.66 148.75,146.76 149.17,146.76
CORE_SW2 on BOTTOM (solid shape): 157.22,143.53 157.22,142.38 157.35,142.26 161.1,142.26 161.22,142.13 161.22,140.31 160.58,139.66 160.58,139.13 159.22,137.77 157.59,137.77 157.23,137.42 157.23,137.04 157.59,136.68 157.59,135.66 157.41,135.49 155.1,135.49 154.92,135.66 154.92,140.64 155.6,141.32 155.82,141.32 156.41,141.91 156.41,143.63 156.44,143.66 157.09,143.66
CORE_SW3 on BOTTOM (solid shape): 164.88,143.51 164.88,142.32 165,142.2 168.74,142.2 168.97,141.97 168.97,140.08 169.55,139.5 172.35,139.5 172.86,138.99 172.86,135.64 172.76,135.54 169.02,135.54 168.66,135.9 168.66,136.5 169.05,136.88 170.67,136.88 170.75,136.96 170.75,137.42 170.57,137.6 167.6,137.6 167.51,137.68 167.51,139.21 167.07,139.66 164.32,139.66 164.09,139.88 164.09,143.56 164.14,143.61 164.78,143.61
CORE_SW4 on BOTTOM (solid shape): 173.59,143.25 173.59,142 173.81,141.79 177.43,141.79 177.81,141.41 177.81,140.34 178.01,140.14 178.6,140.14 178.67,140.06 178.67,137.82 178.6,137.75 177.68,137.75 177.22,138.2 176.56,138.2 175.87,137.52 174.86,137.52 172.78,139.6 172.78,143.23 172.86,143.31 173.53,143.31
CPU_B+ on TOP (solid shape): 169.31,147.31 171.91,147.31 172.17,147.06 172.17,145.06 172.14,145.02 172.11,144.98 171.95,144.82 170.06,144.82 169.87,144.63 167.83,144.63 167.77,144.68 167.77,147.34 168.16,147.73 168.89,147.73
CPU_B+ on TOP (solid shape): 163.58,147.18 163.58,145.22 163.03,144.66 159.52,144.66 159.33,144.85 159.33,146.23 159.14,146.42 158.57,146.42 158.5,146.49 158.5,146.99 158.57,147.06 159.06,147.06 159.08,147.05 159.39,146.74 160.92,146.74 160.98,146.68 162,146.68 162.31,146.99 162.31,147.18 162.57,147.44 163.33,147.44
CPU_B+ on TOP (solid shape): 155.2,150.74 155.2,150.04 155.33,149.91 155.94,149.91 156.04,149.81 156.04,149.08 156.88,148.24 156.88,147.42 156.8,147.35 154.21,147.35 153.76,147.81 151.42,147.81 151.37,147.86 151.37,148.71 151.6,148.94 153.15,148.94 153.42,149.22 153.42,150.8 153.49,150.87 155.08,150.87
CPU_B+ on TOP (solid shape): 145.8,150.49 145.8,150.34 146.11,150.04 146.13,150.04 147.61,150.04 147.94,149.71 147.94,147.91 148.03,147.82 148.03,147.54 148,147.47 146.47,147.47 146.06,147.88 143.2,147.88 143.14,147.95 143.14,148.39 143.14,148.4 143.18,148.54 143.16,148.68 143.15,148.72 143.33,148.9 144.28,148.9 144.53,149.15 144.53,150.42 144.66,150.55 145.74,150.55
CPU_B+ on TOP (solid shape): 182.04,149.2 182.13,149.14 182.11,149.03 182.36,148.42 182.6,149.03 182.58,149.14 182.67,149.2 185.51,149.2 187.26,147.45 187.26,146.18 188.2,145.24 188.2,144.28 188.08,144.15 185.12,144.15 184.84,144.29 184.55,144.15 183.82,144.15 183.54,144.29 183.25,144.15 182.66,144.15 182.33,144.48 182.33,146.19 183.04,146.9 183.15,147.38 182.68,147.52 182.61,147.51 182.55,147.56 182.25,147.76 181.93,147.58 181.88,147.54 181.81,147.54 181.49,147.51 181.32,147.23 181.29,147.16 181.22,147.13 180.62,147.13 180.32,146.84 180.32,145.9 179.77,145.34 179.33,145.34 179.33,145.06 179.33,145.05 179.33,144.86 179.42,144.69 179.45,144.65 179.21,144.4 176.21,144.4 176.09,144.52 176.09,144.64 175.9,144.83 175.7,144.83 175.7,144.83 175.33,144.83 175.27,144.9 175.27,146.33 175.97,147.03 178.1,147.03 178.26,147.19 178.26,147.89 178.32,147.95 179.8,147.95 180.77,148.91 180.81,148.88 181.19,148.79 181.42,149.11 181.45,149.18 181.52,149.2
CPU_B+ on BOTTOM (solid shape): 140.08,149.04 140.08,146.8 140.09,146.8 140.09,145.22 139.9,145.02 139.01,145.02 138.69,145.34 136.09,145.34 135.46,145.98 135.46,148.56 135.55,148.65 136.21,148.65 136.58,149.03 136.59,149.03 136.75,149.2 139.92,149.2
CPU_B+ on BOTTOM (solid shape): 155.96,149.94 155.96,148.31 155.94,148.29 155.94,147.63 155.69,147.37 154.9,147.37 154.29,147.98 151.57,147.98 151.44,148.11 151.44,149.05 151.55,149.15 152.89,149.15 153.07,149.33 153.07,150.09 153.12,150.14 155.76,150.14
CPU_B+ on BOTTOM (solid shape): 172.35,147.68 172.35,146.33 172.07,146.05 172.07,145.52 171.89,145.34 170.04,145.34 169.81,145.11 169.81,144.98 169.63,144.8 166.95,144.8 166.89,144.87 166.89,145.94 166.92,145.96 168.32,145.96 168.42,146.05 168.42,146.79 168.91,147.28 169.55,147.28 169.66,147.39 169.66,147.84 169.86,148.03 171.99,148.03
CPU_B+ on BOTTOM (solid shape): 146.95,149.96 147.76,149.96 147.89,149.84 147.89,149.78 147.9,149.72 147.9,147.41 147.76,147.27 147.13,147.27 146.57,147.83 146.57,147.84 143.93,147.84 143.87,147.9 143.87,149.05 143.87,149.05 143.87,149.1 143.93,149.15 145.37,149.15 145.47,149.26 145.47,150.04 145.75,150.32 146.6,150.32
CPU_B+ on BOTTOM (solid shape): 163.47,147.99 163.47,145.06 163.41,144.99 163.36,144.92 163.36,144.91 163.31,144.85 159.42,144.85 159.29,144.98 159.29,146.01 159.34,146.06 160.7,146.06 160.84,146.21 160.84,146.89 160.99,147.04 161.3,147.04 161.53,147.27 162.21,147.27 162.51,147.56 162.51,147.88 162.76,148.14 163.33,148.14
CPU_B+ on BOTTOM (solid shape): 186.19,150.01 186.19,148.64 186.03,148.48 186.03,147.73 186.17,147.59 186.46,147.59 187.44,146.61 187.44,145.09 186.97,144.63 183.04,144.63 182.97,144.71 182.97,145.77 183.02,145.82 184.44,145.82 184.51,145.9 184.51,146.74 185.24,147.46 185.24,150.02 185.28,150.06 186.14,150.06
CPU_B+ on BOTTOM (solid shape): 178.83,148.75 178.83,147.31 178.9,147.24 179.06,147.24 179.12,147.18 179.12,145.49 178.9,145.21 178.9,144.59 178.7,144.39 175.78,144.39 175.52,144.64 175.52,145.53 175.65,145.66 177.07,145.66 177.2,145.79 177.2,146.76 177.43,146.99 177.84,146.99 177.89,146.99 178,147.1 178,148.75 178.18,148.93 178.65,148.93
CPU_B+ on BOTTOM (solid shape): 163.98,157.22 163.98,154.65 163.97,154.64 163.97,154.08 162.98,153.09 156.88,153.09 156.2,153.77 151,153.77 150.46,154.31 150.46,157.05 158.84,157.05 158.84,157 158.84,156.95 158.86,156.9 158.88,156.85 158.91,156.8 158.95,156.76 158.99,156.73 159.04,156.7 159.09,156.69 159.14,156.67 159.19,156.67 159.24,156.67 159.3,156.69 159.35,156.7 159.39,156.73 159.43,156.76 159.47,156.8 159.5,156.85 159.52,156.9 159.54,156.95 159.55,157 159.55,157.05 159.54,157.11 159.52,157.16 159.5,157.2 159.47,157.25 159.43,157.29 159.39,157.32 159.35,157.35 159.3,157.37 159.24,157.38 159.19,157.38 159.14,157.38 159.09,157.37 159.04,157.35 158.99,157.32 158.95,157.29 158.91,157.25 158.88,157.2 158.86,157.16 158.84,157.11 158.84,157.05 150.46,157.05 150.46,158.12 151.19,158.85 155.46,158.85 156.17,158.14 158.23,158.14 158.96,158.88 162.31,158.88
CPU_B+ on IN3 (solid shape): outline of 7060 points within 138.63,134.77 186.5,155.41
CPU_B+ on IN4 (solid shape): outline of 6423 points within 138.63,134.93 186.29,155.58
DH_1.2V on TOP (solid shape): 90.2,40.57 90.2,39.76 90.04,39.61 89.67,39.61 89.07,40.21 89.07,41.14 89.15,41.22 89.55,41.22
DH_1.2V on BOTTOM (solid shape): 91.59,45.45 91.59,45.34 91.53,45.28 90.72,45.28 90.5,45.06 90.5,44.89 90.14,44.53 89.96,44.53 89.95,44.52 89.81,44.52 89.7,44.63 89.7,44.9 89.81,45 89.98,45 90.12,45.15 90.12,45.32 90.31,45.51 91.53,45.51
DH_1.2V on IN4 (solid shape): 90.56,45.38 90.56,45.12 89.99,44.55 87.96,44.55 88.91,45.51 90.43,45.51
DH_1.2V on IN4 (solid shape): 88.78,41.84 89.61,41.01 89.61,40.19 89.48,40.06 89.23,40.06 89.04,40.25 89.04,40.5 87.77,41.77 87.77,42.22 87.83,42.28 88.78,42.28
DH_CHG on TOP (solid shape): 75.13,22.28 75.13,21.07 74.81,20.76 73.29,20.76 73.1,20.95 73.1,22.22 73.35,22.47 74.94,22.47
DH_CHG on TOP (solid shape): 62.18,24.57 62.3,24.57 62.37,24.5 62.37,24.25 62.23,24.11 60.59,24.11 60.38,24.32 59.08,24.32 59.03,24.37 59.03,24.49 59.08,24.54 60.57,24.54 60.61,24.58 62.16,24.58
DH_CHG on IN1 (solid shape): 62.81,23.99 62.81,23.55 62.49,23.23 61.92,23.23 61.22,23.93 61.22,24.41 61.42,24.6 62.2,24.6
DH_CHG on IN1 (solid shape): 75.07,22.22 75.07,21.2 74.94,21.07 72.97,21.07 72.72,21.33 72.72,21.96 73.1,22.34 74.94,22.34
DL_1.2V on TOP (solid shape): 95.89,37.93 95.89,37.65 95.92,37.62 95.92,35.58 95.77,35.42 95.45,35.42 95.32,35.55 95.32,36.57 95.45,36.69 95.45,37.91 95.49,37.95 95.87,37.95
DL_1.2V on BOTTOM (solid shape): 92,44.6 92,43.83 91.51,43.35 91.21,43.35 91.07,43.49 91.07,44.12 91.64,44.69 91.91,44.69
DL_1.2V on IN4 (solid shape): 96.47,37.46 96.47,35.8 96.08,35.42 95.51,35.42 95.39,35.55 95.39,36.88 95.07,37.2 95.07,37.58 95.51,38.03 95.89,38.03
DL_1.2V on IN4 (solid shape): 91.7,44.31 91.7,42.85 91.83,42.73 91.83,42.15 91.77,42.09 91.07,42.09 90.85,42.31 90.85,44.05 91.23,44.44 91.58,44.44
DL_CHG on TOP (solid shape): 65.35,23.55 65.35,22.66 65.22,22.53 64.4,22.53 64.21,22.72 64.21,23.3 64.59,23.68 65.22,23.68
DL_CHG on TOP (solid shape): 61.08,22.42 61.08,22.19 60.99,22.1 60.67,22.1 60.16,22.61 60.16,22.84 59.87,23.13 59.07,23.13 59.03,23.17 59.03,23.29 59.08,23.35 60.15,23.35
DL_CHG on IN4 (solid shape): 65.35,22.98 65.35,22.47 65.11,22.23 63.72,22.23 63.34,22.61 63.34,23.23 63.59,23.47 64.86,23.47
DL_CHG on IN4 (solid shape): 62.58,23.36 62.58,22.66 62.42,22.5 61.72,22.5 61.29,22.06 60.8,22.06 60.78,22.09 60.59,22.09 60.53,22.14 60.52,22.14 60.14,22.53 60.14,22.79 60.33,22.98 60.52,22.98 60.65,22.85 60.92,22.85 61.49,23.42 62.52,23.42
ECAGND on TOP (solid shape): 295.04,11.4 295.04,11.12 294.89,10.97 294.89,9.15 294.82,9.08 294.68,9.08 294.61,9.16 294.61,10.95 294.47,11.09 294.47,11.42 294.56,11.52 294.93,11.52
