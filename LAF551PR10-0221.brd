# Allegro board LAF551PR10-0221.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CTX_GRX_N2: length 62.5
  IN6 w0.089: v2(176.58,102.92) 176.82,102.68 176.82,102.39 176.98,102.23 177.87,102.23 182.22,106.57 185.35,106.57 187.83,109.05 188.96,109.05 190.46,110.55 191.81,110.55 192.63,111.37 193.21,111.37 193.64,111.8 193.79,111.8 194.85,112.87 195.14,112.87 196.34,114.07 197.16,114.07 198.85,115.76 198.85,116.22 201.27,118.64 201.27,119.29 202.13,120.15 202.13,120.51 203.31,121.69 203.31,123.48 206.26,126.42 206.26,127.06 207.2,128 211.86,128 212.25,127.62 212.45,127.62 214.7,125.37 215.38,125.37 215.46,125.28 215.46,125.19 v2(215.08,124.81)
  BOTTOM w0.076: v2(176.58,102.92) 176.66,102.92 176.99,102.59 176.99,102.42 176.92,102.35 173.44,102.35 173.23,102.55 172.02,102.55 171.95,102.63 171.95,102.77 172.08,102.9 172.29,102.9 UC1.B12
  BOTTOM w0.107: CC3.1 215.52,125.4 215.08,124.96 v2(215.08,124.81)
PEG_CTX_GRX_N3: length 60.1
  IN6 w0.089: v2(213.66,124.81) 213.89,125.04 213.89,125.28 212.25,126.91 212.05,126.91 211.6,127.37 208.1,127.37 203.95,123.21 203.95,120.41 199.48,115.94 199.48,115.5 198.07,114.09 198.07,113.78 194.21,109.92 190.72,109.92 189.22,108.42 188.1,108.42 185.61,105.93 182.51,105.93 178.12,101.54 176.01,101.54 175.08,102.48 175.08,102.72 v2(174.88,102.92)
  BOTTOM w0.076: v2(174.88,102.92) 175.01,103.06 175.01,103.24 174.89,103.37 173.44,103.37 173.21,103.14 172.79,103.14 172.59,103.34 172.59,103.56 172.52,103.64 UC1.B13
  BOTTOM w0.107: v2(213.66,124.81) 213.73,124.88 213.73,125.95 214.2,126.42 CC4.1
PEG_CTX_GRX_N4: length 62.4
  IN6 w0.089: v2(212.21,128.45) 212.42,128.65 212.42,128.86 212.12,129.15 207.4,129.15 205.75,127.5 204.68,127.5 204.44,127.26 204.44,125.5 202.68,123.74 202.68,122.88 200.35,120.55 200.35,118.86 198.91,117.43 197.93,117.43 197.54,117.05 197.54,116.44 197.13,116.02 197.13,115.26 196.64,114.77 195.89,114.77 194.83,113.72 192.57,113.72 188.53,109.69 187.57,109.69 185.09,107.2 181.75,107.2 178.19,103.65 175.21,103.65 175.03,103.83 175.03,104.18 v2(174.78,104.43)
  BOTTOM w0.076: v2(174.78,104.43) 174.96,104.43 175.06,104.34 175.06,104.29 175.13,104.21 175.13,104.15 175,104.01 173.27,104.01 173.16,104.13 172.04,104.13 171.96,104.21 171.96,104.31 171.96,104.31 171.96,104.42 172.02,104.47 172.16,104.47 172.17,104.49 172.28,104.49 UC1.B14
  BOTTOM w0.107: CC5.1 216.19,126.99 214.07,126.99 213.9,126.83 212.99,126.83 212.21,127.6 v2(212.21,128.45)
PEG_CTX_GRX_N5: length 60.9
  IN6 w0.089: v2(214.13,128.45) 214.13,129.21 213.39,129.95 208.44,129.95 207.84,130.55 206.15,130.55 204.66,129.06 203.91,129.06 203.2,128.35 203.2,126.27 202.61,125.68 202.61,125.22 199.54,122.16 199.54,119.22 198.56,118.23 195.94,118.23 194.79,117.07 194.07,117.07 191.69,114.69 191.69,113.97 188.2,110.49 187.24,110.49 184.75,108 180.02,108 177.65,105.63 177.06,105.63 176.6,105.17 v2(176.6,104.38)
  BOTTOM w0.076: v2(176.6,104.38) 176.8,104.59 176.8,104.73 176.72,104.8 173.31,104.8 173.26,104.75 172.75,104.75 172.57,104.93 172.57,105.14 172.49,105.22 UC1.B15
  BOTTOM w0.107: v2(214.13,128.45) 213.98,128.45 213.84,128.3 213.84,128.13 213.95,128.02 214.46,128.02 214.64,128.19 214.64,128.26 214.77,128.39 CC6.1
PEG_CTX_GRX_N6: length 63.1
  IN6 w0.089: v2(174.22,105.89) 174.22,106.52 174.41,106.71 175.5,106.71 175.73,106.48 177.51,106.48 179.71,108.68 184.53,108.68 188.21,112.36 188.85,112.36 190.69,114.2 190.69,114.65 193.59,117.56 193.59,119.48 193.87,119.76 194.77,119.76 195.28,120.27 195.28,120.76 195.9,121.38 197.8,121.38 199.79,123.37 199.86,123.37 201.24,124.75 201.24,125.37 202.26,126.39 202.26,128.63 203.33,129.7 204.09,129.7 205.71,131.31 208.99,131.31 209.24,131.05 v2(209.24,130.41)
  BOTTOM w0.076: UC1.B16 172.27,106.07 172.15,106.07 171.98,105.91 171.98,105.79 172.1,105.68 173.16,105.68 173.46,105.38 174.56,105.38 174.65,105.47 174.65,105.61 174.54,105.72 174.4,105.72 v2(174.22,105.89)
  BOTTOM w0.107: CC7.1 215.85,129.38 215.73,129.27 215.73,129.21 215.6,129.08 214.65,129.08 214.51,129.21 209.7,129.21 209.68,129.23 209.32,129.23 208.76,129.79 208.76,130.04 208.94,130.21 209.05,130.21 v2(209.24,130.41)
PEG_CTX_GRX_N7: length 61.6
  IN6 w0.089: v2(210.44,130.41) 210.3,130.55 210.3,131.33 209.62,132.01 202.86,132.01 202.03,131.18 202.03,130.24 200.61,128.82 200.61,125.02 199.63,124.04 199.57,124.04 197.54,122.01 195.63,122.01 194.41,120.79 193.34,120.79 192.45,119.91 192.45,117.33 190.03,114.91 190.03,114.52 188.51,113.01 187.96,113.01 184.27,109.31 179.43,109.31 177.28,107.15 176.25,107.15 176.11,107.3 176.11,107.42 v2(176.35,107.66)
  BOTTOM w0.076: v2(176.35,107.66) 176.35,106.84 175.94,106.43 173.45,106.43 173.35,106.33 172.65,106.33 172.44,106.54 172.44,106.68 UC1.B17
  BOTTOM w0.107: v2(210.44,130.41) 210.41,130.41 210.21,130.2 210.21,130.01 210.31,129.9 212.98,129.9 213.06,129.99 214.44,129.99 214.54,130.09 214.54,130.26 214.64,130.36 CC8.1
PEG_CTX_GRX_N8: length 105.8
  IN3 w0.127: v2(152.49,171.03) 152.36,170.9 152.36,170.26 157.06,165.56 157.06,163.25 159.36,160.95 161.53,160.95 163.86,158.61 163.86,156.41 165.93,154.34 165.93,154.24 168.02,152.16 172.35,152.16 172.96,152.16 173.78,151.34 183.91,151.34 184.07,151.18 186.5,151.18 190.48,147.2 190.48,138.95 188.77,137.24 188.77,126.78 180.31,118.32 180.31,114.18 178.6,112.46 178.6,110.11 177,108.51 174.89,108.51 174.44,108.07 174.44,107.92 v2(174.61,107.75)
  BOTTOM w0.076: UC1.C18 171.8,107.46 171.8,107.31 172.04,107.08 174.44,107.08 174.61,107.25 v2(174.61,107.75)
  BOTTOM w0.107: v2(152.49,171.03) 152.3,171.22 152.3,171.54 152.69,171.93 152.72,171.93 153.12,172.34 153.12,172.38 153.59,172.84 153.59,173.32 CC9.1
PEG_CTX_GRX_N9: length 108.9
  IN3 w0.127: v2(179.14,111.18) 179.14,111.65 179.5,112.01 179.5,112.65 181.3,114.45 181.3,118.59 189.28,126.57 189.28,137.03 190.99,138.74 190.99,148.09 189.37,149.7 189.37,149.98 187.66,151.69 184.28,151.69 184.12,151.85 173.99,151.85 173.17,152.67 172.01,152.67 171.56,153.12 169.91,153.12 167.9,155.13 167.9,157.41 166.47,158.84 164.38,158.84 161.76,161.46 159.57,161.46 157.57,163.46 157.57,168.41 157.71,168.56 157.71,172.04 155.95,173.8 154.9,173.8 154.78,173.68 154.78,173.39 154.96,173.21 v2(154.98,173.21)
  BOTTOM w0.076: UC1.A19 172.87,108.48 172.72,108.48 172.63,108.38 172.63,108.28 172.82,108.08 173.17,108.08 173.27,108.18 173.28,108.18 173.39,108.3 174.06,108.3 174.13,108.36 177.72,108.36
  BOTTOM w0.107: 177.72,108.36 177.88,108.36 179.58,110.06 179.58,111.3 179.44,111.43 179.25,111.43 179.14,111.33 v2(179.14,111.18) ; CC10.1 154.82,175.26 154.82,173.37 v2(154.98,173.21)
PEG_CTX_GRX_N10: length 106.5
  IN3 w0.127: v2(176.39,109.17) 176.53,109.31 176.9,109.31 177.91,110.31 177.91,110.45 177.91,112.8 179.49,114.38 179.49,118.88 181.49,120.88 181.49,122.16 188.05,128.71 188.05,137.93 188.68,138.56 188.68,145.25 188.05,145.88 188.05,148.24 185.83,150.46 183.77,150.46 183.61,150.62 173.48,150.62 172.66,151.44 167.34,151.44 163.14,155.64 163.14,157.55 160.52,160.17 159.11,160.17 158.02,161.26 156.93,161.26 155.6,162.59 155.6,162.6 155.17,163.02 155.17,165.3 154.69,165.78 154.69,166.9 151.48,170.11 151.48,171.2 152.33,172.05 155.66,172.05 155.99,172.38 155.99,172.65 v2(156.19,172.84)
  BOTTOM w0.076: v2(176.39,109.17) 176.23,109.32 175.83,109.32 175.4,108.89 174.29,108.89 173.95,108.55 173.34,108.55 173.24,108.65 172.22,108.65 172.13,108.74 172.05,108.74 171.92,108.87 171.92,108.92 UC1.C20
  BOTTOM w0.107: v2(156.19,172.84) 155.96,173.07 155.96,173.29 CC11.1
PEG_CTX_GRX_N11: length 107.9
  IN3 w0.127: v2(175.21,110.04) 175.37,110.2 175.37,112.25 177.06,113.94 177.77,113.94 178.54,114.71 178.54,119.27 180.07,120.79 180.07,122.07 187.1,129.11 187.1,147.78 185.36,149.51 183.38,149.51 183.22,149.67 173.08,149.67 172.26,150.49 166.95,150.49 162.19,155.25 162.19,157.16 160.13,159.23 158.71,159.23 157.62,160.32 156.54,160.32 154.66,162.2 154.66,162.2 154.41,162.45 154.41,162.45 154.23,162.63 154.23,164.11 151.63,166.71 151.63,168.62 150.54,169.72 150.54,171.59 153.94,174.99 156.8,174.99 157.32,174.46 157.32,173.98 157.38,173.92 157.38,173.92 v2(157.46,173.84)
  BOTTOM w0.076: v2(175.21,110.04) 175.21,109.91 175.14,109.85 175.06,109.85 174.95,109.74 174.58,109.74 173.22,109.74 173.13,109.65 172.87,109.65 172.74,109.77 172.74,109.88 172.82,109.95 172.97,109.95 UC1.A21
  BOTTOM w0.107: CC12.1 157.44,175.22 157.44,174.9 157.31,174.77 157.31,173.99 v2(157.46,173.84)
PEG_CTX_GRX_P0: length 63.4
  IN6 w0.089: v2(175.28,100.97) 175.7,100.55 175.7,100.09 176.41,99.39 178.32,99.39 182.98,104.05 186.79,104.05 187.93,105.2 188.27,105.2 191.33,108.26 194.62,108.26 195.22,108.86 196.35,109.99 198.85,109.99 200,111.14 200,112.71 200.83,113.54 200.83,114.36 205.23,118.77 205.23,122.23 208.28,125.28 211.59,125.28 212.06,124.8 212.06,124.3 212.47,123.89 212.81,123.89 213.15,123.55 213.15,123.42 v2(212.99,123.27)
  BOTTOM w0.076: UC1.C10 171.95,101.28 172.06,101.17 172.06,100.98 172.24,100.81 172.28,100.81 172.3,100.79 173.18,100.79 173.27,100.69 174.3,100.69 174.83,101.23 175.03,101.23 v2(175.28,100.97)
  BOTTOM w0.107: v2(212.99,123.27) 213.14,123.12 213.14,122.88 213.37,122.66 214.93,122.66 215.68,121.91 CC13.1
PEG_CTX_GRX_P1: length 61.9
  IN6 w0.089: v2(177.62,100.98) 177.48,100.84 177.48,100.71 177.61,100.57 178.25,100.57 183.14,105.46 187.07,105.46 187.6,106 187.94,106 189.33,107.39 189.33,107.86 190.92,109.45 194.4,109.45 198.33,113.38 199.52,113.38 200.03,113.88 200.03,114.7 204.42,119.08 204.42,123.02 207.87,126.47 208.48,126.47 208.86,126.09 211.9,126.09 212.92,125.07 212.92,124.9 213.49,124.34 214.24,124.34 214.68,123.9 214.68,123.5 v2(214.93,123.24)
  BOTTOM w0.076: UC1.A11 172.79,102.07 172.72,101.99 172.72,101.86 172.83,101.75 173.23,101.75 173.32,101.84 174.24,101.84
  BOTTOM w0.089: CC14.1 215.35,123.32 215.35,123.36 215.33,123.38 215.33,123.73 215.13,123.93 214.78,123.93 214.7,123.84 214.7,123.37 214.82,123.24 v2(214.93,123.24) ; 174.24,101.84 177.14,101.84 177.47,101.51 177.47,101.13 v2(177.62,100.98)
PEG_CTX_GRX_P2: length 62.5
  IN6 w0.089: v2(177.17,102.92) 176.98,102.74 176.98,102.48 177.07,102.39 177.8,102.39 182.15,106.73 185.28,106.73 187.76,109.22 188.89,109.22 190.39,110.72 191.74,110.72 192.56,111.53 193.14,111.53 193.57,111.97 193.72,111.97 194.78,113.03 195.07,113.03 196.27,114.24 197.09,114.24 198.68,115.83 198.68,116.29 201.11,118.71 201.11,119.36 201.96,120.22 201.96,120.58 203.15,121.76 203.15,123.55 206.09,126.49 206.09,127.13 207.13,128.17 211.93,128.17 212.32,127.78 212.52,127.78 214.77,125.53 215.44,125.53 215.63,125.34 215.63,124.82 v2(215.77,124.68)
  BOTTOM w0.076: UC1.C12 171.78,102.76 171.78,102.55 171.95,102.38 173.13,102.38 173.34,102.17 176.99,102.17 177.17,102.35 v2(177.17,102.92)
  BOTTOM w0.107: CC15.1 216.35,124.83 216,125.18 215.69,125.18 215.49,124.98 215.49,124.79 215.6,124.68 v2(215.77,124.68)
PEG_CTX_GRX_P3: length 60.1
  IN6 w0.089: v2(175.46,102.92) 175.24,102.7 175.24,102.55 176.08,101.71 178.05,101.71 182.44,106.1 185.55,106.1 188.03,108.58 189.15,108.58 190.65,110.08 194.14,110.08 197.91,113.85 197.91,114.16 199.32,115.57 199.32,116.01 203.78,120.47 203.78,123.28 208.03,127.53 211.67,127.53 212.12,127.08 212.32,127.08 214.05,125.34 214.05,125 v2(214.24,124.81)
  BOTTOM w0.076: v2(175.46,102.92) 175.19,103.2 175.19,103.31 174.97,103.53 173.33,103.53 173.13,103.33 172.84,103.33 172.77,103.41 172.77,103.56 172.84,103.64 UC1.A13
  BOTTOM w0.107: CC16.1 214.68,125.85 214.58,125.95 214.58,126.1 214.46,126.22 214.28,126.22 213.93,125.86 213.93,125.19 214.24,124.88 v2(214.24,124.81)
PEG_CTX_GRX_P4: length 62.4
  IN6 w0.089: v2(175.41,104.43) 175.19,104.21 175.19,103.9 175.28,103.81 178.13,103.81 181.68,107.37 185.02,107.37 187.5,109.85 188.47,109.85 192.5,113.88 194.76,113.88 195.82,114.94 196.57,114.94 196.96,115.33 196.96,116.09 197.38,116.51 197.38,117.12 197.86,117.59 198.84,117.59 200.18,118.93 200.18,120.62 202.51,122.95 202.51,123.81 204.27,125.57 204.27,127.33 204.61,127.66 205.68,127.66 207.33,129.31 212.19,129.31 212.58,128.93 212.58,128.67 v2(212.8,128.45)
  BOTTOM w0.076: v2(175.41,104.43) 175.33,104.35 175.33,104.1 175.07,103.84 173.2,103.84 173.09,103.96 171.97,103.96 171.79,104.14 171.79,104.33 UC1.C14
  BOTTOM w0.107: v2(212.8,128.45) 212.8,128.14 212.69,128.03 212.52,128.03 212.42,127.93 212.42,127.69 213.07,127.03 213.82,127.03 213.98,127.19 215.89,127.19 216.2,127.5 CC17.1
PEG_CTX_GRX_P5: length 60.9
  IN6 w0.089: v2(177.18,104.38) 176.99,104.58 176.92,104.58 176.76,104.73 176.76,105.1 177.13,105.46 177.72,105.46 180.09,107.84 184.82,107.84 187.3,110.32 188.27,110.32 191.86,113.9 191.86,114.62 194.14,116.91 194.86,116.91 196.01,118.06 198.62,118.06 199.71,119.15 199.71,122.09 202.77,125.15 202.77,125.61 203.36,126.2 203.36,128.28 203.98,128.9 204.73,128.9 206.22,130.38 207.78,130.38 208.37,129.78 213.33,129.78 213.97,129.14 213.97,128.85 213.56,128.45 v2(213.46,128.45)
  BOTTOM w0.076: v2(177.18,104.38) 176.99,104.57 176.99,104.78 176.8,104.98 173.21,104.98 173.16,104.93 172.82,104.93 172.74,105 172.74,105.14 172.82,105.22 UC1.A15
  BOTTOM w0.107: CC18.1 213.87,127.82 213.63,128.05 213.63,128.27 v2(213.46,128.45)
PEG_CTX_GRX_P6: length 63.1
  IN6 w0.089: v2(208.56,130.41) 208.78,130.63 208.9,130.63 209.04,130.78 209.04,131.02 208.92,131.14 205.77,131.14 204.16,129.53 203.4,129.53 202.43,128.56 202.43,126.32 201.41,125.3 201.41,124.69 199.93,123.21 199.86,123.21 197.87,121.21 195.97,121.21 195.45,120.69 195.45,120.21 194.84,119.6 193.94,119.6 193.76,119.42 193.76,117.49 190.85,114.58 190.85,114.13 188.91,112.2 188.28,112.2 184.6,108.51 179.78,108.51 177.58,106.32 175.66,106.32 175.43,106.54 174.48,106.54 174.39,106.45 174.39,106.25 174.48,106.16 174.6,106.16 v2(174.87,105.89)
  BOTTOM w0.076: UC1.C16 171.8,105.89 171.8,105.74 171.86,105.67 171.86,105.67 172.02,105.51 173.09,105.51 173.39,105.21 174.63,105.21 174.82,105.4 174.82,105.84 v2(174.87,105.89)
  BOTTOM w0.107: v2(208.56,130.41) 208.56,129.71 209.23,129.03 209.59,129.03 209.61,129.01 214.43,129.01 214.56,128.88 216.08,128.88 CC19.1
PEG_CTX_GRX_P7: length 61.6
  IN6 w0.089: v2(175.8,107.66) 175.94,107.52 175.94,107.23 176.18,106.99 177.34,106.99 179.5,109.15 184.33,109.15 188.03,112.84 188.58,112.84 190.19,114.46 190.19,114.84 192.62,117.26 192.62,119.84 193.41,120.63 194.48,120.63 195.7,121.85 197.6,121.85 199.64,123.88 199.7,123.88 200.77,124.95 200.77,128.75 202.19,130.18 202.19,131.11 202.93,131.84 209.55,131.84 210.13,131.27 210.13,130.69 v2(209.85,130.41)
  BOTTOM w0.076: UC1.A17 172.91,106.86 172.72,106.86 172.61,106.76 172.61,106.61 172.72,106.51 173.25,106.51 173.35,106.61 175.86,106.61 176.17,106.92 176.17,107.29 v2(175.8,107.66)
  BOTTOM w0.107: v2(209.85,130.41) 210,130.26 210,129.93 210.23,129.7 213.06,129.7 213.15,129.78 CC20.1
PEG_CTX_GRX_P8: length 105.7
  IN3 w0.127: v2(151.9,171.03) 152.15,170.79 152.15,170.17 156.84,165.47 156.84,163.16 159.27,160.73 161.44,160.73 163.65,158.52 163.65,156.32 165.72,154.25 165.72,154.15 167.93,151.94 172.45,151.94 172.87,151.94 173.69,151.12 183.82,151.12 183.98,150.97 186.41,150.97 190.26,147.11 190.26,139.04 188.55,137.33 188.55,126.87 180.09,118.41 180.09,114.27 178.38,112.55 178.38,110.2 176.91,108.73 174.8,108.73 174.22,108.16 174.22,107.91 v2(174.07,107.75)
  BOTTOM w0.076: v2(174.07,107.75) 174.11,107.75 174.44,107.42 174.44,107.33 174.36,107.25 172.11,107.25 171.98,107.38 171.98,107.52 172.08,107.62 172.29,107.62 UC1.B18
  BOTTOM w0.107: v2(151.9,171.03) 152.09,171.22 152.09,171.63 v4(152.76,172.3) 153.39,172.93 153.39,173.32 CC21.1
PEG_CTX_GRX_P9: length 109
  IN3 w0.127: v2(179.78,111.75) 179.72,111.81 179.72,112.55 181.52,114.36 181.52,118.5 189.5,126.48 189.5,136.94 191.21,138.65 191.21,148.18 189.59,149.79 189.59,150.07 187.75,151.91 184.37,151.91 184.21,152.07 174.08,152.07 173.26,152.89 172.1,152.89 171.65,153.34 170,153.34 168.12,155.22 168.12,157.5 166.56,159.06 164.47,159.06 161.85,161.67 159.66,161.67 157.78,163.55 157.78,168.32 157.93,168.46 157.93,172.13 156.04,174.02 154.81,174.02 154.56,173.77 154.56,173.37 v2(154.4,173.21)
  BOTTOM w0.076: UC1.B19 172.33,108.33 172.75,107.91 173.24,107.91 173.34,108.01 173.35,108.01 173.46,108.12 174.13,108.12 174.21,108.19 177.17,108.19 177.21,108.16 177.3,108.16
  BOTTOM w0.107: 177.3,108.16 177.96,108.16 179.78,109.97 v2(179.78,111.75) ; CC22.1 154.62,175.19 154.62,173.43 v2(154.4,173.21)
PEG_CTX_GRX_P10: length 106.4
  IN3 w0.127: v2(155.61,172.84) 155.77,172.68 155.77,172.47 155.57,172.27 152.24,172.27 151.27,171.29 151.27,170.02 154.48,166.81 154.48,165.69 154.96,165.21 154.96,162.93 155.38,162.5 155.38,162.5 156.84,161.04 157.93,161.04 159.01,159.95 160.43,159.95 162.92,157.46 162.92,155.55 167.25,151.22 172.57,151.22 173.38,150.4 183.52,150.4 183.68,150.24 185.73,150.24 187.83,148.15 187.83,145.79 188.46,145.16 188.46,138.65 187.83,138.02 187.83,128.81 181.27,122.25 181.27,120.97 179.27,118.97 179.27,114.47 177.69,112.89 177.69,110.4 176.81,109.53 176.65,109.53 176.54,109.64 176.54,110.09 v2(176.56,110.11)
  BOTTOM w0.076: UC1.B20 172.21,109.03 172.21,108.9 172.29,108.82 173.31,108.82 173.41,108.72 173.88,108.72 174.22,109.07 175.32,109.07 175.76,109.5 176.2,109.5 176.56,109.86 v2(176.56,110.11)
  BOTTOM w0.107: CC23.1 155.76,173.36 155.76,173 v2(155.61,172.84)
PEG_CTX_GRX_P11: length 108
  IN3 w0.127: v2(156.88,173.84) 157.11,174.06 157.11,174.37 156.71,174.77 154.03,174.77 150.76,171.5 150.76,169.81 151.85,168.71 151.85,166.8 154.45,164.2 154.45,162.72 154.5,162.67 154.5,162.67 154.88,162.29 154.88,162.29 156.63,160.54 157.71,160.54 158.8,159.45 160.22,159.45 162.41,157.25 162.41,155.34 167.04,150.71 172.35,150.71 173.17,149.89 183.31,149.89 183.47,149.73 185.45,149.73 187.32,147.87 187.32,129.02 180.29,121.98 180.29,120.7 178.76,119.18 178.76,114.62 177.86,113.72 177.15,113.72 175.59,112.16 175.59,109.88 175.55,109.84 175.21,109.5 v2(175.21,109.49)
  BOTTOM w0.076: UC1.B21 172.33,109.91 172.76,109.48 172.86,109.48 172.87,109.48 173.21,109.48 173.3,109.57 174.65,109.57 175.13,109.57 v2(175.21,109.49)
  BOTTOM w0.107: v2(156.88,173.84) 157.11,174.06 157.11,174.85 157.23,174.98 157.23,175.19 CC24.1
PEG_CTX_TRX_N12: length 82.3
  TOP w0.107: CT15.1 189.51,161.55 189.62,161.45 192.37,161.45 193.27,162.35 v2(193.27,162.81)
  IN6 w0.089: v2(193.27,162.81) 193.16,162.7 193.16,161.87 193.54,161.49 193.54,158.55 194.87,157.21 194.87,152.65 197.85,149.67 197.85,143.07 198.07,142.85 198.07,138.66 198.7,138.04 198.7,136.81 200.17,135.34 200.17,134.24 199.95,134.01 199.95,133.68 200.17,133.46 200.17,132.28 198.76,130.87 198.76,129.44 197.89,128.57 197.89,125.24 197.37,124.72 196.81,124.72 195.84,123.75 193.28,123.75 188.8,119.27 188.8,118.41 187.88,117.49 187.88,116.55 187.66,116.32 187.66,115.69 187.66,115.17 187.66,115.17 184.99,112.5 184.79,112.5 184.77,112.51 178.88,112.51 178.27,111.89 178.27,111.38 177.88,110.99 v2(177.31,110.99)
  BOTTOM w0.076: v2(177.31,110.99) 177.29,111.01 176.67,111.01 176.17,110.5 175.13,110.5 174.77,110.13 173.34,110.13 173.24,110.23 172.09,110.23 171.68,110.64 UC1.C22
PEG_CTX_TRX_N13: length 77.5
  TOP w0.107: v2(191.32,162.89) 191.02,163.19 190.7,163.19 190.53,163.35 189.89,163.35 189.36,163.88 188.39,163.88 188.35,163.84 CT13.1
  IN6 w0.089: v2(191.32,162.89) 191.28,162.93 191.28,163.08 191.34,163.14 191.4,163.14 191.63,163.36 191.78,163.36 191.89,163.25 191.89,161.93 192.73,161.09 192.73,157.45 193.18,156.99 193.18,155.33 194.06,154.44 194.06,152.32 196.94,149.44 196.94,142.84 197.27,142.51 197.27,138.33 197.9,137.71 197.9,136.27 198.46,135.71 198.46,132.08 197.96,131.59 197.96,129.96 196.6,128.6 196.6,127.91 195.92,127.23 195.92,125.72 194.76,124.55 192.92,124.55 188,119.63 188,118.75 187.08,117.83 187.08,116.88 186.86,116.66 186.86,115.5 184.7,113.34 178.72,113.34 177.45,112.07 177.03,112.07 176.74,112.36 v2(176.74,112.53)
  BOTTOM w0.076: UC1.A23 172.89,111.51 172.8,111.43 172.8,111.31 172.88,111.23 173.14,111.23 173.34,111.43 175.47,111.43 176.08,112.04 176.37,112.04 176.74,112.41 v2(176.74,112.53)
PEG_CTX_TRX_N14: length 89.3
  TOP w0.107: CT18.1 188.56,166.48 188.61,166.48 188.62,166.47 191.08,166.47 192.01,167.4 192.26,167.4 193,168.14 193,168.21 193.57,168.79 v2(193.57,169.3)
  IN6 w0.089: v2(177.3,112.79) 177.2,112.89 176.87,112.89 176.67,113.09 176.67,113.6 177.04,113.97 184.43,113.97 186.22,115.76 186.22,116.92 186.26,116.95 186.26,117.9 187.37,119.01 187.37,120.14 192.41,125.19 194.36,125.19 195.29,126.12 195.29,127.49 195.97,128.18 195.97,128.86 196.46,129.35 196.46,130.98 197.82,132.35 197.82,135.44 197.27,136 197.27,137.44 196.31,138.4 196.31,149.18 193.43,152.06 193.43,154.11 192.08,155.45 192.08,160.82 190.15,162.76 190.15,165.56 192,167.41 192.27,167.41 193.04,168.18 193.04,168.53 193.24,168.73 193.24,168.93 193.57,169.26 v2(193.57,169.3)
  BOTTOM w0.076: UC1.C24 171.84,112.15 171.84,112.03 172.06,111.81 173.23,111.81 173.32,111.72 175.17,111.72 176.35,112.89 177.2,112.89 v2(177.3,112.79)
PEG_CTX_TRX_N15: length 84.2
  TOP w0.107: v2(190.49,169.85) 190.27,169.62 189.74,169.62 189.43,169.32 189.39,169.32 188.86,168.79 188.54,168.79 CT21.1
  IN6 w0.089: v2(177.29,114.35) 177.28,114.36 177.28,114.49 177.52,114.72 177.64,114.72 177.93,114.44 182.22,114.44 185.8,118.02 185.8,118.16 186.9,119.26 186.9,120.45 195.5,129.05 195.5,129.05 195.99,129.54 195.99,131.57 196.67,132.25 196.67,137.32 195.84,138.14 195.84,148.98 192.96,151.86 192.96,153.91 191.61,155.26 191.61,160.61 189.72,162.5 189.72,162.52 189.37,162.87 189.37,166.33 189.52,166.47 190.08,166.47 192.13,168.53 192.37,168.53 192.77,168.93 192.77,169.65 192.34,170.08 191.21,170.08 190.76,169.63 190.71,169.63 v2(190.49,169.85)
  BOTTOM w0.076: UC1.A25 172.8,113.09 172.65,112.94 172.65,112.83 172.73,112.75 172.8,112.75 173.3,112.75 173.41,112.87 175.19,112.87 176.05,113.73 176.05,114.92 176.23,115.1 177.05,115.1 177.25,114.9 177.25,114.4 v2(177.29,114.35)
PEG_CTX_TRX_P12: length 82.3
  TOP w0.107: v2(192.68,162.81) 192.78,162.81 192.86,162.73 192.86,162.64 192.99,162.51 192.99,162.36 192.28,161.65 189.7,161.65 189.59,161.75 188.77,161.75 188.67,161.86 188.61,161.91 188.5,161.91 188.35,162.06 CT3.1
  IN6 w0.089: v2(192.68,162.81) 192.99,162.5 192.99,161.8 193.37,161.42 193.37,158.48 194.71,157.15 194.71,152.58 197.68,149.6 197.68,143 197.91,142.78 197.91,138.6 198.54,137.97 198.54,136.74 200.01,135.27 200.01,134.3 199.79,134.08 199.79,133.61 200.01,133.39 200.01,132.35 198.6,130.94 198.6,129.51 197.73,128.64 197.73,125.31 197.3,124.88 196.74,124.88 195.78,123.92 193.21,123.92 188.64,119.34 188.64,118.48 187.71,117.56 187.71,116.61 187.49,116.39 187.49,115.63 187.49,115.62 187.49,115.24 187.49,115.24 184.94,112.68 184.92,112.66 184.85,112.66 184.84,112.68 178.82,112.68 178.1,111.96 178.1,111.45 177.81,111.16 177.65,111.16 177.31,111.51 v2(177.31,111.54)
  BOTTOM w0.076: v2(177.31,111.54) 176.94,111.18 176.6,111.18 176.09,110.67 175.06,110.67 174.69,110.3 173.41,110.3 173.31,110.4 172.17,110.4 172.05,110.52 172.05,110.65 172.13,110.73 UC1.B22
PEG_CTX_TRX_P13: length 77.5
  TOP w0.107: v2(191.24,163.54) 191.09,163.39 190.78,163.39 190.62,163.55 189.98,163.55 189.44,164.09 188.72,164.09 188.72,164.09 188.61,164.2 188.56,164.2 188.35,164.41 CT1.1
  IN6 w0.089: v2(191.24,163.54) 191.25,163.53 191.85,163.53 192.06,163.32 192.06,162 192.9,161.16 192.9,157.51 193.35,157.06 193.35,155.39 194.23,154.51 194.23,152.39 197.11,149.51 197.11,142.91 197.44,142.58 197.44,138.4 198.07,137.77 198.07,136.33 198.62,135.78 198.62,132.02 198.13,131.52 198.13,129.89 196.77,128.53 196.77,127.84 196.09,127.16 196.09,125.65 194.83,124.39 192.99,124.39 188.17,119.56 188.17,118.68 187.24,117.76 187.24,116.81 187.02,116.59 187.02,115.43 184.77,113.17 178.79,113.17 177.52,111.9 176.75,111.9 v2(176.72,111.87)
  BOTTOM w0.076: v2(176.72,111.87) 176.51,111.87 176.51,111.87 176.15,111.87 175.54,111.26 173.42,111.26 173.21,111.06 172.8,111.06 172.35,111.51 UC1.B23
PEG_CTX_TRX_P14: length 89.3
  TOP w0.107: CT4.1 188.49,166.27 191.17,166.27 192.09,167.2 192.34,167.2 193.2,168.05 193.2,168.13 193.91,168.84 v2(194.04,168.84)
  IN6 w0.089: v2(177.3,113.34) 177.3,113.29 177.17,113.15 177.15,113.15 177.06,113.06 176.93,113.06 176.84,113.16 176.84,113.53 177.11,113.81 184.5,113.81 186.39,115.69 186.39,116.85 186.42,116.88 186.42,117.83 187.53,118.95 187.53,120.08 192.48,125.02 194.43,125.02 195.45,126.05 195.45,127.43 196.13,128.11 196.13,128.79 196.62,129.28 196.62,130.92 197.99,132.28 197.99,135.51 197.43,136.07 197.43,137.51 196.47,138.47 196.47,149.25 193.59,152.13 193.59,154.17 192.25,155.52 192.25,160.89 190.31,162.82 190.31,165.49 192.06,167.24 192.34,167.24 193.2,168.11 193.2,168.46 193.4,168.66 193.4,168.86 193.45,168.9 193.74,168.9 193.8,168.96 193.91,168.96 v2(194.04,168.84)
  BOTTOM w0.076: v2(177.3,113.34) 177.03,113.07 176.28,113.07 175.1,111.89 173.39,111.89 173.31,111.98 172.13,111.98 172.01,112.1 172.01,112.23 172.09,112.3 UC1.B24
PEG_CTX_TRX_P15: length 84.2
  TOP w0.107: v2(190.49,169.26) 190.33,169.42 189.82,169.42 v4(189.35,168.95) 188.99,168.58 188.45,168.58 188.35,168.48 CT5.1
  IN6 w0.089: v2(190.49,169.26) 190.69,169.46 190.83,169.46 191.28,169.92 192.27,169.92 192.6,169.58 192.6,169 192.3,168.69 192.06,168.69 190.01,166.64 189.45,166.64 189.21,166.4 189.21,162.8 189.56,162.45 189.56,162.43 191.45,160.54 191.45,155.19 192.79,153.84 192.79,151.79 195.67,148.92 195.67,138.08 196.5,137.25 196.5,132.31 195.82,131.63 195.82,129.61 195.33,129.12 195.33,129.12 186.73,120.51 186.73,119.33 185.63,118.23 185.63,118.09 182.16,114.61 178,114.61 177.71,114.89 177.45,114.89 177.28,114.72 177.14,114.72 176.78,114.35 v2(176.71,114.35)
  BOTTOM w0.076: v2(176.71,114.35) 176.79,114.35 177.07,114.64 177.07,114.83 176.98,114.93 176.3,114.93 176.22,114.85 176.22,113.66 175.26,112.7 173.48,112.7 173.37,112.58 173.1,112.58 172.66,112.58 172.47,112.77 172.47,112.95 UC1.B25
PEG_RCOMP: length 6.6
  BOTTOM w0.089: RC2.2 170.04,91.26 170.6,90.71 v1(170.77,90.71)
  BOTTOM w0.254: UC1.G2 169.01,96.01 169.01,95.15 169.9,94.26 170.03,94.26 170.06,94.22
  BOTTOM w0.381: 170.06,94.22 170.44,93.84 170.44,92.61 170.04,92.21 RC2.2
PEX_TERMP: length 7.9
  TOP w0.089: v1(242.24,117.69) 242.83,117.1 RG23.2 243.4,117.47 243.59,117.66 247.72,117.66 v2(248.17,118.1)
  BOTTOM w0.089: v2(248.17,118.1) 248.52,118.1 UG9.BL44
PEX_VDD_ENP: length 83.5
  TOP w0.254: v1(234.2,48.57) 233.68,48.05 233.68,43.37 235.66,41.39 238.13,41.39 v2(238.69,41.95)
  IN4 w0.254: v2(238.69,41.95) 238.17,41.42 233.59,41.42 231.82,43.2 228.45,43.2 228.25,43.4 224.39,43.4 224.37,43.42 223.15,43.42 222.08,42.36 219.02,42.36 218.98,42.32 218.91,42.32 218.86,42.28 215.62,42.28 215.22,41.87 212.92,41.87 212.66,42.13 212.66,42.65 212.92,42.92 212.92,43.4 212.92,43.4 212.92,43.49 212.66,43.74 212.3,43.74 212.29,43.75 212.29,44.17 212.04,44.42 211.16,44.42 209.5,46.08 208.95,46.08 208.26,46.77 203.61,46.77 200.85,49.52 200.85,52.77 199.53,54.09 196.86,54.09 190.57,60.38 v2(188.6,60.38)
  BOTTOM w0.203: v2(188.6,60.38) 188.86,60.38 189.62,59.62 189.62,58.8 190.78,57.64 UG31.20
  BOTTOM w0.254: PU800.11 v2(238.69,41.95) 238.39,41.65 PC801.1 ; PR801.1 PC801.1 ; PC801.1 PR802.1 PR8217.2
PGOOD_1.2V: length 2.4
  BOTTOM w0.203: PR210.2 95.58,43.59 v2(94.89,44.28) 94.89,44.79 94.69,45 PU201.10
PLTRST_CPU#: length 224.1
  TOP w0.089: CH195.1 132.33,119.19 131.78,119.75 v2(131.78,119.75)
  IN1 w0.081: v2(207.15,38.98) 206.76,39.37 206.76,39.48 207.84,40.57 207.84,40.58 208.18,40.91 208.18,43.37 208.09,43.46 208.09,44.13 205.52,46.7 203.58,46.7 201.47,48.81 201.47,50.24 v2(199.14,52.57)
  IN3 w0.127: v2(118.94,36.82) 118.82,36.94 118.82,41.07 117.94,41.95 115.08,41.95 113.51,43.53 113.51,48.91 112.55,49.88 112.55,53.41 114.52,55.38 114.52,61.03 115.16,61.67 117.31,61.67 118.17,62.53 118.17,64.42 130.57,76.82 130.57,92.13 133.36,94.92 133.36,99.98 132.79,100.55 132.79,103.47 133.94,104.63 133.94,105.36 135.17,106.58 136.18,106.58 136.42,106.82 136.42,107.15 137.23,107.96 137.23,108.66 137.86,109.29 137.86,113.22 137.74,113.34 137.74,113.72 137.86,113.85 137.86,115.67 136.77,116.75 135.97,116.75 135.75,116.98 135.75,117.3 134.66,118.39 133.14,118.39 131.78,119.75 v2(131.78,119.75)
  IN6 w0.081: v2(199.14,52.57) 198.78,52.21 195.57,52.21 194.21,53.56 189.96,53.56 189.03,52.63 189.03,50.2 188.49,49.66 188.49,43.76 178.58,33.85 175.8,33.85 175.53,33.58 132.3,33.58 131.09,34.79 120.97,34.79 v2(118.94,36.82)
  BOTTOM w0.076: UC1.BP35 133.46,119.75 133.25,119.75 133.13,119.63 132.55,119.63 132.49,119.57 131.96,119.57 131.78,119.75 v2(131.78,119.75)
  BOTTOM w0.122: UH1.AG5 206.87,39.26 v2(207.15,38.98)
PM_SLP_S3#: length 165.1
  TOP w0.102: 304.22,27.11 v2(304.22,27.1) ; 304.22,27.11 303.54,26.43 UE5.6 303.54,23.66 301.68,21.8 301.68,20.9 301.51,20.73 301.51,20.28 302.01,19.79 302.01,18.35 v2(300.98,17.33) ; 304.22,27.11 303.91,27.42 CE41.1 ; v2(322.09,38.93) 322.09,39.13 v1(323.07,40.11) 323.91,40.11 324.62,40.82 QE1.5 324.62,41.01 324.2,41.43 323.81,41.43 323.7,41.33 323.03,41.33 322.55,41.81 322.08,41.81 321.89,42 Q8.2
  IN1 w0.089: 219.18,22.18 218.64,21.64 218.51,21.64 217.46,20.59 v2(217.46,20.21) ; v2(218.39,31.61) 218.8,31.61 219.1,31.31 219.1,31 218.7,30.6 218.7,29.5 218.4,29.2 218.4,27.88 218.35,27.83 218.35,27.7 218.23,27.58 218.23,26.64 217.77,26.18 217.77,25.12 217.9,24.98 218.28,24.98 218.63,24.63 219.15,24.63 219.18,24.6
  IN1 w0.102: 219.18,24.6 219.64,24.14 219.64,22.65 219.18,22.18
  IN2 w0.089: 219.18,31.61 v2(218.39,31.61)
  IN2 w0.102: v2(304.22,27.1) 304.22,27.5 304.32,27.6 305.58,27.6 306.22,28.24 307.27,28.24 308.66,29.62 309.57,29.62 312.51,32.57 318.29,32.57 322.61,36.89 322.61,38.41 v2(322.09,38.93) ; 219.18,31.61 220.61,31.61 221.53,30.69 222.49,30.69 225.42,27.76 225.42,27.24 226.51,26.15 226.51,24.32 227.38,23.45 227.38,22.76 228.24,21.89 228.24,20.52 229.32,19.45 235.7,19.45 236.29,18.86 245.3,18.86 245.8,19.36 245.8,19.66 245.95,19.81 245.95,20.7 246.26,21.01 246.26,24.19 246.26,24.81 246.49,25.04 246.49,25.37 247.19,26.06 248.07,26.94 256.19,26.94 258.39,24.74 259.9,24.74 261.27,26.11 266.28,26.11 266.73,26.57 270.99,26.57 271.92,25.64 271.92,24.5 274.36,22.06 276.06,22.06 276.68,21.44 277.41,21.44 280.93,17.92 293.11,17.92 294,17.03 296.78,17.03 297.29,17.54 299.66,17.54 300.77,17.54 v2(300.98,17.33)
  BOTTOM w0.122: UH1.BF42 216.11,20.94 216.46,20.58 216.65,20.58 217.02,20.21 v2(217.46,20.21)
PM_SLP_S3_H: length 10.4
  TOP w0.102: 321.89,41.39 321.83,41.46 320.87,41.46 319.99,42.35 v1(319.99,43.68) 319.99,43.93 320.54,44.49 Q7.5 320.54,45.16 320.43,45.27 320.43,46.41 320.54,46.52 Q7.2 ; 321.89,41.39 Q8.5 321.89,40.14 R307.2 ; 321.89,41.39 322.08,41.58 322.4,41.58 322.54,41.44 Q8.6
PM_SLP_S4#: length 358.7
  TOP w0.107: v2(296.37,18.28) 296.19,18.1 296.19,15.26 296.08,15.15 296.08,11.04 296.34,10.77 UE5.73 ; Q9.2 327.1,42.6 325.91,41.41 325.91,36.79 v1(326.03,36.67) 326.03,35.84 323.29,33.1 323.29,28.12 v2(322.84,27.67)
  TOP w0.122: v2(219.65,21.84) 219.65,23.03 219.32,23.36 217.88,23.36 217.32,23.91 216.85,23.91 216.55,24.22 216.55,24.76 218.07,26.28 218.07,27.02 217.97,27.12 217.97,27.83 218.32,28.18 218.32,29.52 218.7,29.9 218.7,30.66 219.02,30.98 219.02,31.55 218.21,32.36 218.21,33.38 217.43,34.15 v2(217.43,34.34)
  IN1 w0.102: v2(296.37,18.28) 296.75,17.9 299.79,17.9 300.81,16.88 303.59,16.88 304.21,17.51 306.28,17.51 307.09,16.69 310.93,16.69 313.74,19.5 313.74,21.71 314.46,22.43 314.46,23.55 315.48,24.57 315.48,25.86 317.76,28.15 321.72,28.15 322.19,27.67 v2(322.84,27.67)
  IN2 w0.089: v2(217.43,34.34) 217.43,34.6 217.69,34.85 218.5,34.85 219.18,34.17
  IN2 w0.102: v2(296.37,18.28) 296.24,18.41 283.01,18.41 279.65,21.76 279.52,21.9 276.87,21.9 276.25,22.52 273.8,24.97 273.8,25.48 271.79,27.49 264.04,27.49 263.92,27.36 260.76,27.36 260.36,27.76 257.86,27.76 257.37,28.25 257.01,28.25 256.66,28.6 248.43,28.6 245.84,26.01 245.58,25.75 245.58,25.74 244.84,25.01 244.84,21.55 244.34,21.05 244.34,20.82 242.95,19.42 236.7,19.42 235.08,21.03 232.98,21.03 230.58,23.43 229.82,23.43 229.12,24.13 227.69,25.55 227.69,27.22 227.11,27.8 227.11,30.34 224.5,32.95 v2(224.04,32.95) 223.91,32.95 222.78,34.08 219.27,34.08 219.18,34.17
  IN6 w0.102: v2(204.99,60.38) 203.66,60.38 203.54,60.25 201.43,60.25 199.88,61.81 199.43,62.26 199.23,62.26 198.87,62.62 197.45,62.62 197.34,62.51 197.01,62.51 196.44,61.94 196.05,61.55 195.99,61.55 195.85,61.41 195.75,61.36 195.25,61.03 195.02,60.88 194.95,60.83 194.94,60.79 194.4,60.25 193.89,59.5 192.19,57.79 190.31,57.79 189.75,58.35 189.75,60.43 188.77,61.4 188.44,61.4 188.2,61.17 187.04,61.17 186.7,60.82 186,60.82 183.51,58.33 183.51,48.04 182.63,47.17 181.56,47.17 180.98,46.6 180.98,43.42 179.59,42.03 174.11,42.03 173.55,41.48 113.23,41.48 111.82,42.88 110.34,42.88 100.21,53.01 v2(97.74,53.01)
  BOTTOM w0.089: 218.14,43.88 218.14,43.79 218.32,43.62 219.18,43.62
  BOTTOM w0.102: v2(204.99,60.38) 205.05,60.38 208.75,56.68 208.75,55.42 211.51,52.66 211.51,52.26 213.53,50.24 213.53,50 215.19,48.35 219.05,48.35 219.54,47.86 219.54,45.62 218.14,44.22 218.14,43.88 ; 219.18,43.62 220.2,43.62 220.75,43.06 221.19,43.06 221.21,43.05 221.85,43.05 222.1,42.8 222.66,42.8 222.77,42.7 222.77,41.5 222.23,40.97 222.23,38.61 223,37.85 223,35.6 223.95,34.65 223.95,33.1 224.04,33.01 v2(224.04,32.95)
  BOTTOM w0.107: PR1301.2 98.15,53.43 v2(97.74,53.01)
  BOTTOM w0.122: v2(219.65,21.84) 219.66,21.84 219.66,21.83 219.65,21.83 219.27,21.45 218.83,21.45 218.19,20.82 218.19,19.93 217.81,19.55 217.37,19.55 216.54,20.37 216.05,20.37 215.52,20.91 UH1.BE42
PM_SLP_S4_H: length 4.6
  TOP w0.102: R325.2 326.4,40.26 327.09,40.95 Q9.5 327.1,41.33 327.2,41.43 327.65,41.43 327.75,41.33 Q9.6 328.63,40.06 v1(328.63,39.56)
PM_SLP_S5#: length 146.9
  TOP w0.089: v2(213.5,21.01) 213.55,21.01 v1(213.91,20.64)
  TOP w0.102: v2(298.84,30.85) 298.7,30.71 CE45.1 299.84,29.07 299.84,27.54 300.25,27.14 300.25,26.62 300.34,26.53 ; QE4.5 323.29,44.65 v2(322.8,44.16)
  TOP w0.107: 300.34,26.53 UE5.14 300.34,24.86 298.97,23.49 298.97,21.33 298.59,20.95 298.59,18.72 v2(298.27,18.41)
  IN2 w0.102: v2(298.84,30.85) 300.02,29.67 303.25,29.67 305.57,31.99 310.06,31.99 311.32,33.25 318,33.25 320.68,35.93 320.68,39.42 321.76,40.5 321.76,42.66 322.55,43.45 322.55,43.91 v2(322.8,44.16)
  IN6 w0.089: 219.18,21.14 218.52,21.14 218.22,20.84 218.22,20.15 217.83,19.76 217.35,19.76 216.63,20.48 215.23,20.48 214.75,20.96 213.55,20.96 v2(213.5,21.01)
  IN6 w0.102: 219.18,21.14 221.18,21.14 221.54,21.5 221.54,21.51 221.55,21.52 222.69,21.52 223.91,20.29 226.91,20.29 227.43,19.77 231.19,19.77 231.41,19.99 235.07,19.99 236.55,18.51 241.51,18.51 242.25,17.77 244.67,17.77 246.62,19.72 246.62,22.49 250.15,26.02 256.09,26.02 260.84,21.27 266.54,21.27 267.23,20.58 272.42,20.58 272.54,20.46 275.68,20.46 276.08,20.06 292.89,20.06 293.25,19.7 296.98,19.7 v2(298.27,18.41)
  BOTTOM w0.089: v2(213.5,21.01) 213.56,21.07 213.94,21.07 214.08,21.21 UH1.BC42
POK: length 244.9
  TOP w0.508: v2(85.17,19.8) 85.34,19.8 85.88,20.35 86.75,20.35 87.26,19.84 v1(87.26,18.53) 87.26,10.38 85.21,8.33 74.22,8.33 72.44,10.11 70.18,10.11 69.64,10.65 69.64,11.2 69.33,11.51 68.21,11.51 67.94,11.24 PR17.2 67.94,9.98 PR14.1
  IN2 w0.508: v2(85.17,19.8) 85.59,20.22 88.17,20.22 88.91,19.49 96.14,19.49 99.54,22.89 99.54,26.25 99.53,26.27 99.53,30.95 100.57,31.99 110.19,31.99 112.65,34.45 119.96,34.45 122.18,36.67 164.36,36.67 165.82,35.21 179.64,35.21 184.91,40.48 189.56,40.48 190.64,41.56 192.2,41.56 192.41,41.35 194.19,41.35 194.78,41.94 196.58,41.94 196.85,42.21 199.6,42.21 200.29,42.89 203.58,42.89 203.92,43.23 204.45,43.23 205.26,44.04 205.26,44.09 205.8,44.64 210.72,44.64 211.17,44.19 216.19,44.19 v2(216.25,44.12)
  IN3 w0.508: v2(216.25,44.12) 216.8,44.12 217.57,44.89 220.7,44.89 224.53,41.06 v2(224.53,37.96) ; v2(85.17,19.8) 83.49,21.49 83.49,23.92 81.38,26.03 81.38,33.1 69.38,45.09 66.48,45.09 64.72,46.85 63.92,46.85 63.71,46.64 62.96,46.64 61.41,48.19 57.94,48.19 57.22,48.9 56.69,48.9 56.31,48.52 v2(56.31,48.3)
  BOTTOM w0.203: PU100.7 55.89,47.88 v2(56.31,48.3)
POWER_LED: length 253.2
  TOP w0.102: v2(323.26,43.76) 323.94,44.44 QE4.6 ; RE28.2 205.98,160.37 QE8.2 207.49,160.58 v2(206.85,161.22)
  IN4 w0.102: v2(323.26,43.76) 322.51,43.01 319.27,43.01 319.08,43.2 310.9,43.2 310,42.29 299.4,42.29 298.13,41.02 298.13,39.91 297.59,39.37 292.07,39.37 290.16,41.28 278.72,41.28 275.84,38.4 273.76,38.4 266.73,45.43 260.39,45.43 259.78,46.04 248.31,46.04 246.8,47.55 238.09,47.55 237.29,46.76 229.24,46.76 229.09,46.92 223.43,46.92 223.27,46.76 215.98,46.76 213.97,48.76 213.82,48.76 210.5,52.09 210.5,53.73 208.54,55.69 208.54,57.3 207.39,58.45 207.39,68.94 208.57,70.13 208.57,103.39 206.42,105.54 206.42,110.7 203.27,113.85 203.27,123.27 199.9,126.64 199.9,126.78 199.9,126.78 199.9,129.51 198.91,130.5 198.91,143.73 201.05,145.87 201.05,147.83 198.7,150.18 198.19,150.18 196.24,152.13 196.24,155.47 198.19,157.42 199.9,157.42 199.96,157.41 202.45,157.41 204.93,159.88 205.51,159.88 v2(206.85,161.22)
PQ700_D: length 28
  TOP w0.508: v2(68.17,34.41) PR725.2 PC723.2 ; v2(60.46,34.22) v1(60.46,33.32) 60.46,32.9 58.85,31.3 57.64,31.3 57.13,30.79 PC701.2 57.07,30.41 PR705.1
  IN3 w0.508: v2(68.17,34.41) 67.13,35.45 v2(67.13,41.41)
  BOTTOM w0.508: v2(60.46,34.22) 60.65,34.22 61.69,35.26 66.26,35.26 66.98,35.97 PQ702.4 67.62,35.97 68.17,35.42 v2(68.17,34.41) 67.09,33.33 PQ700.1
PQ700_G: length 4.6
  TOP w0.254: v2(62.88,34.54) 63.57,34.54 ; 63.57,34.54 PR700.2 ; 63.57,34.54 PR701.1
  BOTTOM w0.254: v2(62.88,34.54) 63.36,34.07 v1(63.36,33.47) 63.36,32.91 63.59,32.68 PQ700.2
PQ701_G: length 4.9
  TOP w0.102: PR725.1 v1(67.26,33.95)
  TOP w0.508: PQ701.4 69.76,36.38 69.25,35.87 67.64,35.87 67.26,35.49 PR725.1
PQ703_S:
  vias: v1(79.47,34.01) v2(76.89,33.3) v2(76.89,32.67) v2(77.05,31.99) v2(77.53,33.3) v2(77.53,32.67) v2(77.75,31.99) v2(78.16,33.3) v2(78.16,32.67) v2(78.38,31.99) v2(78.8,33.3) v2(78.8,32.67) v2(79.5,33.3) v2(79.5,32.67) v2(80.13,33.3) v2(80.13,32.67)
PQ705_D: length 2.3
  TOP w0.102: v1(64.82,19.54) 64.73,19.62 PR710.2
  TOP w0.254: PQ705.1 63.21,20.05 PR710.2
PQ707_G: length 8.7
  TOP w0.102: v2(65.03,42.66) v1(65.03,43.49)
  TOP w0.508: PR726.1 65.34,42.36 v2(65.03,42.66)
  BOTTOM w0.508: PQ707.4 69.73,40.95 68.67,42.01 65.68,42.01 v2(65.03,42.66)
PROC_DETECT#: length 212.9
  IN1 w0.102: v2(185.68,29.01) 184.97,29.72 184.8,29.72 184.22,30.3 184.22,31.61 183.21,32.63 119.99,32.63 118.6,31.25 109.98,31.25 v2(106.94,34.28)
  IN2 w0.089: v2(206.21,20.81) 204.64,22.37 198.64,22.37 197.19,20.92 196.44,20.92 196.08,21.28 194.62,21.28 193.75,22.15 193.4,22.15
  IN2 w0.102: v2(185.68,29.01) 186.8,29.01 186.99,28.82 188.76,28.82 189.33,28.25 189.33,24.43 191.3,22.46 193.1,22.46 193.4,22.15
  IN3 w0.102: v2(106.94,34.28) 106.94,39.86 104.83,41.98 104.83,59.09 108.16,62.43 108.16,64.95 119.16,75.96 119.16,94.18 121.84,96.86 121.84,99.73 121.97,99.87 128.75,106.64 128.75,108.93 128.42,109.26 128.42,114.14 127.06,115.51 127.06,118.94 v2(126.12,119.88)
  BOTTOM w0.089: v2(206.21,20.81) 206.54,21.14 207.34,21.14 207.65,21.45 207.97,21.45 208.48,21.96 209.56,21.96 UH1.AP41
  BOTTOM w0.107: v2(126.12,119.88) 126.4,119.6 RH519.1
PROCHOT#_CHG: length 1.7
  TOP w0.203: PR724.2 54.15,24.37 54.68,24.37 54.74,24.43 PU700.10
PS_ID: length 39.1
  TOP w0.102: v2(311.91,49.47) v1(311.25,49.47)
  TOP w0.203: v2(299.61,26.87) 299.54,26.8 UE5.16
  TOP w0.254: PR3.1 PR4.2 v2(311.91,49.47)
  IN2 w0.254: v2(299.61,26.87) 301.59,26.87 302.07,27.35 302.84,27.35 304.02,26.17 304.66,26.17 304.9,26.17 305.87,27.14 306.7,27.14 308.88,29.31 309.69,29.31 311.61,31.23 v2(312.37,31.23)
  IN3 w0.254: v2(311.91,49.47) 310.57,48.14 310.57,40.81 309.9,40.14 309.9,35.42 310.14,35.18 310.14,33.46 v2(312.37,31.23)
PSID: length 8.8
  TOP w0.102: v1(65.03,47.97) 65.03,48.37 65.22,48.57 v2(65.29,48.57)
  BOTTOM w0.254: PL2.2 64.28,49.07 64.85,48.49 65.21,48.49 v2(65.29,48.57) 65.45,48.73 65.45,49.58 65.71,49.83 66.07,49.83 66.32,49.58 PJPDC1.1
PSID-1: length 1.5
  TOP w0.102: PQ2.2 v1(319.2,52.39)
PSID-2: length 1.5
  TOP w0.102: PQ2.1 316.09,53.45 v1(315.35,54.19)
PSID-3: length 1.2
  TOP w0.102: PR4.1 v1(312.56,47.35)
PSID-4: length 299.7
  TOP w0.102: PR6.2 v1(318.3,47.31)
  IN2 w0.089: 202.67,44.73 202.26,44.32 201.24,44.32 200.93,44.62 199.77,44.62 199.41,44.26 198.47,44.26 198.23,44.5 197.61,44.5 197.12,44.02 194.3,44.02 193.86,44.46 193.85,44.46
  IN2 w0.102: 202.67,44.73 202.7,44.76 203.02,44.76 204.01,45.75 211.25,45.75 211.7,45.3 217.29,45.3 217.67,44.92 223.88,44.92 225.12,43.69 229.49,43.69 229.73,43.93 235.15,43.93 235.76,44.54 237.55,44.54 238.8,43.3 239.77,43.3 241.14,41.93 244.09,41.93 245.55,43.39 265.82,43.39 276.34,32.87 279.73,32.87 283.54,29.06 289.95,29.06 294.99,24.02 295.58,24.02 296.37,24.81 296.51,24.95 302.06,24.95 302.06,24.95 304.15,24.95 305.41,24.95 306.38,25.92 307.97,25.92 308.28,26.22 308.28,27.29 309.29,28.3 310.26,28.3 311.92,29.96 312.56,29.96 v2(313.07,29.45) ; 193.85,44.46 190.83,44.46 189.29,42.92 186.24,42.92 186.11,42.79 184.92,41.6 184.45,41.6 180.64,37.79 135.32,37.79 132.4,40.71 112.85,40.71 106.99,46.57 98.85,46.57 98.69,46.74 96.43,46.74 96.25,46.56 94.17,46.56 93.43,47.3 87.6,47.3 87.41,47.11 65.33,47.11 65.14,47.3 64.76,47.3 v2(64.33,47.73)
  IN3 w0.102: v2(313.07,29.45) 313,29.52 313,32.74 312.17,33.57 312.17,33.9 310.46,35.61 310.46,39.94 311.11,40.59 311.11,47.11 312.63,48.63 v2(317.13,48.63)
  BOTTOM w0.102: v2(64.33,47.73) 63.74,48.32 PL2.1
PTP_KBBL#: length 253.5
  TOP w0.102: UE10.16 317.26,62.28 v2(317,62.54) ; v2(183.27,33.65) v3(183.89,33.65)
  IN2 w0.089: 219.18,41.57 219.16,41.57 219.13,41.6 215.16,41.6 213.89,40.33 209.04,40.33 208.98,40.39 207.14,40.39 206.93,40.18 204.32,40.18 204.07,40.43 200.35,40.43 200.34,40.42 197.73,40.42 197.42,40.11 197.1,40.11 196.72,39.74 196.72,38.74 195.7,37.72 195.14,37.72 193.86,36.43 192.82,36.43 192.77,36.48 192.1,36.48
  IN2 w0.102: v2(183.27,33.65) 183.27,34.15 184.74,35.62 191.03,35.62 191.89,36.48 192.1,36.48 ; 219.18,41.57 222.36,41.57 224.65,39.28 230.58,39.28 230.94,39.64 235.45,39.64 235.87,39.22 238.46,39.22 239.97,37.71 240.16,37.71 240.16,37.71 246.65,37.71 247.81,36.55 247.81,33.76 250.12,31.45 257.55,31.45 257.81,31.19 265.81,31.19 266.84,30.17 272.85,30.17 273.88,29.13 276.99,29.13 278.49,27.64 281.78,27.64 284.42,25 285.04,25 286.07,23.97 287.97,23.97 288.9,23.04 288.9,22.49 289.87,21.52 290.28,21.52 290.28,21.52 290.85,21.52 290.85,21.52 292.87,21.52 293.59,20.79 296.99,20.79 297.06,20.73 297.07,20.73 297.07,20.72 298.44,20.72 299.13,21.42 301.34,21.42 301.47,21.55 301.58,21.55 302.92,22.89 303.3,22.89 303.3,22.89 307.67,22.89 309.2,24.43 309.2,26.86 309.65,27.31 310.74,27.31 311.93,28.5 317.32,28.5 319.79,26.03 320.18,26.03 321.95,24.25 321.95,21.71 322.93,20.73 324.34,20.73 329.19,25.58 329.19,31.49 329.61,31.91 329.61,31.91 329.85,32.15 329.85,32.15 330.97,33.26 331.61,33.26 332.94,34.6 332.94,47.49 328.43,52 323.12,52 322.59,52.53 322.19,52.53 321.06,53.65 321.06,59.17 318.65,61.59 317.38,61.59 317,61.97 v2(317,62.54)
  BOTTOM w0.102: JTP.9 192.82,13.47 192.29,14 190.45,14 189.6,14.85 188.6,14.85 188.6,14.85 188.26,14.85 188.25,14.85 188.03,14.85 187.82,15.06 187.82,16.97 187.59,17.2 187.59,17.71 187,18.29 186.56,18.29 RE663.2 186.17,18.68 184.39,18.68 184.16,18.91 184.16,20.37 183.94,20.58 183.94,23.14 182.63,24.44 182.63,25.39 183.08,25.84 183.08,26.85 184.45,28.22 184.45,29.87 184.6,30.02 184.6,31.8 183.27,33.14 v2(183.27,33.65)
PTP_LID_CLOSE#: length 235.4
  TOP w0.102: v3(329.37,34.89) 329.13,34.65 v2(329.13,34.23) ; UE10.17 316.76,62.11 v2(316.35,62.52)
  IN2 w0.089: 192.1,36.73 193.47,36.73 197.03,40.29 197.35,40.29 197.65,40.6 200.27,40.6 200.27,40.61 204.19,40.61 204.43,40.36 206.85,40.36 207.06,40.57 209.44,40.57 209.51,40.5 213.81,40.5 215.08,41.77 219.13,41.77 219.16,41.8 219.18,41.8
  IN2 w0.102: 192.1,36.73 191.82,36.73 190.93,35.85 184.65,35.85 182.83,34.03 v2(182.83,33.2) ; v2(329.13,34.23) 330.01,35.11 331.29,35.11 332.62,36.44 332.62,41.52 331.54,42.6 330.34,42.6 329.65,43.28 329.65,45.86 330.34,46.55 330.34,49.71 328.3,51.74 323.05,51.74 322.49,52.3 322.1,52.3 320.84,53.56 320.84,59.08 318.58,61.33 317.31,61.33 316.35,62.3 v2(316.35,62.52) ; v2(279.73,28.63) 278.96,27.87 278.58,27.87 277.09,29.36 273.98,29.36 272.95,30.39 266.94,30.39 265.91,31.42 257.9,31.42 257.65,31.68 250.21,31.68 248.04,33.85 248.04,36.64 246.74,37.94 240.06,37.94 238.55,39.45 235.97,39.45 235.55,39.87 234.72,39.87 234.61,39.97 234.17,40.41 230.42,40.41 229.52,39.51 224.74,39.51 222.46,41.8 219.18,41.8
  IN4 w0.102: v2(329.13,34.23) 328.62,34.74 326.22,34.74 323.92,32.44 311.03,32.44 309.76,31.17 308.24,31.17 307.67,30.6 304.3,30.6 303.41,29.71 298.27,29.71 298.08,29.52 292.68,29.52 291.79,28.63 v2(279.73,28.63)
  BOTTOM w0.102: JTP.10 192.32,13.64 192.19,13.77 190.36,13.77 189.53,14.6 187.93,14.6 187.59,14.94 187.59,16.88 187.36,17.11 187.36,17.61 186.91,18.06 185.72,18.06 RE33.2 185.33,18.45 184.24,18.45 183.89,18.8 183.89,20.31 183.71,20.49 183.71,23.04 182.37,24.39 182.37,25.5 182.81,25.95 182.81,26.9 184.22,28.31 184.22,29.96 184.35,30.09 184.35,31.68 v2(182.83,33.2)
PWM1: length 6.2
  TOP w0.254: v2(277.31,136.64) v1(278.05,136.64) 278.89,136.64 PR6067.2
  BOTTOM w0.203: PU6000.11 277.21,136.75 v2(277.31,136.64)
  BOTTOM w0.254: PR6067.2 278.89,136.64 v2(277.31,136.64)
PWM1_1PH/ICCMAX1: length 78.7
  TOP w0.203: PU500.44 123.34,138.82 123.13,138.62 123.13,138.42 v2(123.12,138.42)
  IN6 w0.254: v2(181.06,149.13) 179.13,151.06 158.61,151.06 157.16,152.5 153.55,152.5 152.23,153.83 142.93,153.83 142.53,154.23 135.87,154.23 133.99,152.35 123.91,152.35 122.44,150.88 122.44,146.34 122.44,146.33 122.44,146.18 121.11,144.85 121.11,140.26 122.94,138.42 v2(123.12,138.42)
  BOTTOM w0.254: PR522.1 123.05,138.49 123.12,138.42 v2(123.12,138.42) ; PR5001.1 v2(181.06,149.13)
PWM1_2PH/ICCMAX2: length 34.7
  TOP w0.203: PU500.23 v2(122.94,146.58)
  IN1 w0.254: v2(139.68,151.51) 139.68,151.67 138.62,152.73 134.43,152.73 132.34,150.65 131.35,150.65 131.12,150.88 130.56,150.88 129.77,150.09 129.77,149.74 129.77,149.74 129.77,149.1 129.57,148.91 129.57,146.97 129.57,146.66 129.57,146.65 129.26,146.34 128.31,145.39 121.93,145.39 121.29,146.03 121.29,147.53 121.7,147.93 122.23,147.93 122.79,147.37 122.79,146.73 v2(122.94,146.58)
  BOTTOM w0.203: v2(122.94,146.58) 123.07,146.45 PR589.1
  BOTTOM w0.254: v2(139.68,151.51) 139.91,151.74 139.91,153.17 140.27,153.52 v1(141,153.52) 141.13,153.52 141.39,153.27 PR590.1
PWM1_4PH/ICCMAX4: length 34.4
  TOP w0.203: v2(125.15,146.84) 125.03,146.71 125.03,146.34 125.01,146.32 125.01,146.21 124.94,146.14 PU500.18
  IN1 w0.254: v2(149.97,153.06) 149.38,153.65 145.96,153.65 145.35,153.04 142.33,153.04 141.04,151.75 140.68,151.75 138.93,153.5 132.09,153.5 129,150.41 129,149.42 128.17,148.58 128.17,148.58 127.89,148.3 127.62,148.3 127.37,148.04 127.37,146.41 127.12,146.15 125.84,146.15 v2(125.15,146.84)
  BOTTOM w0.254: PR558.1 124.82,146.51 v2(125.15,146.84) ; PR552.1 v2(149.97,153.06)
PWM2: length 3
  TOP w0.102: v1(278.41,138.15) 278.55,138.29 v2(279.03,138.29)
  TOP w0.254: PR6066.2 v2(279.03,138.29)
  BOTTOM w0.203: PU6000.10 279.01,138.27 v2(279.03,138.29) PR6066.2
PWM2_2PH/ROSC1: length 2.5
  TOP w0.203: PU500.22 123.34,146.34 123.4,146.39 123.4,146.84 v1(123.28,146.96) 122.61,147.63 PR562.1
PWM2_4PH/ADDR: length 54.9
  TOP w0.203: PU500.19 124.54,146.21 124.68,146.35 124.68,146.46 124.7,146.48 v2(124.7,147.27) 124.39,147.58 124.39,147.86 PR580.1
  IN1 w0.254: v2(124.7,147.27) 124.7,148.59 125.21,149.1 125.21,150.79 126.9,152.48 128.49,152.48 130.27,154.26 139.25,154.26 139.71,153.8 140.81,153.8 141.54,154.53 141.54,160.04 142.31,160.81 146.91,160.81 151.49,156.23 151.49,154.41 151.5,154.41 153.48,152.43 156.29,152.43 157.15,151.57 157.16,151.57 157.34,151.39 v2(157.34,149.37)
  BOTTOM w0.102: v2(124.7,147.27) 124.7,148.3 v1(124.48,148.52)
  BOTTOM w0.254: PR563.1 v2(157.34,149.37)
PWM3: length 2.6
  TOP w0.254: v2(279.03,138.99) 279.22,139.18 PR6065.2
  BOTTOM w0.203: PR6065.2 279.22,139.18 v2(279.03,138.99) 278.71,138.67 PU6000.9
PWM3_4PH/VBOOT: length 60.4
  TOP w0.203: PR560.1 123.51,147.88 123.51,147.7 123.88,147.32 v2(123.88,147.27) 124.04,147.27 124.34,146.97 124.34,146.49 124.14,146.28 PU500.20
  IN1 w0.254: v2(164.94,149.33) 164.84,149.43 164.66,149.43 164.28,149.81 161.46,149.81 160.4,150.88 159.23,150.88 158.17,151.95 157.31,151.95 156.45,152.81 155.13,152.81 151.88,156.06 151.88,156.39 147.07,161.2 142.16,161.2 141.16,160.19 141.16,154.69 140.65,154.18 139.86,154.18 139.41,154.64 130.11,154.64 128.33,152.86 126.74,152.86 124.82,150.94 124.82,149.26 123.88,148.32 v2(123.88,147.27)
  BOTTOM w0.254: PR573.1 v2(164.94,149.33)
PWM4: length 3.6
  TOP w0.102: v1(278.35,139.77) 278.49,139.63 v2(279.03,139.63)
  TOP w0.254: PR6064.2 279.47,140.07 v2(279.03,139.63)
  BOTTOM w0.203: PR6064.2 279.47,140.07 v2(279.03,139.63) 278.96,139.63 278.41,139.07 PU6000.8
PWM4_4PH/ROSCM: length 68.4
  TOP w0.203: v2(123.88,146.68) 123.74,146.53 PU500.21
  IN1 w0.254: v2(123.88,146.68) 123.77,146.68 123.35,147.09 123.35,149.18 124.44,150.27 124.44,151.11 127.48,154.14 127.48,154.31 128.27,155.1 136.77,155.1 140.77,159.11 140.77,160.35 142,161.58 142.31,161.58 147.22,161.58 152.26,156.54 152.26,156.22 155.28,153.19 156.61,153.19 157.41,152.39 158.26,152.39 159.39,151.26 161.98,151.26 163.05,150.19 164.44,150.19 164.82,149.81 165.14,149.81 165.15,149.81 172.86,149.81 173.47,149.2 v2(173.61,149.2)
  BOTTOM w0.254: v2(123.88,146.68) 123.88,145.55 123.5,145.16 PR561.1 ; v2(173.61,149.2) 173.61,148.68 173.68,148.6 PR591.1
PWR_B#: length 14.9
  TOP w0.102: RE160.1 202.85,177.02 v2(202.66,176.82) RE154.2 ; JPWR.4 211.82,171.91 211.82,171.94 v2(211.64,172.12)
  TOP w0.107: RE154.2 201.91,175.66 201.94,175.64 QE13.3
  IN3 w0.102: v2(202.66,176.82) 204.29,175.19 206.44,175.19 208.22,173.41 208.83,172.8 209.28,172.8 209.96,172.11 211.31,172.11 211.32,172.12 v2(211.64,172.12)
PWR_B_7313#: length 37.4
  TOP w0.127: v2(231.53,164.49) v1(231.53,165.64)
  TOP w0.254: UE3.17 231.01,164.16 231.34,164.49 v2(231.53,164.49)
  TOP w0.508: QE13.4 201.94,173.53 202.69,174.28 v2(202.83,174.28)
  IN3 w0.508: v2(202.83,174.28) 203.7,173.41 204.15,173.41 204.64,172.92 206.04,172.92 208.32,170.64 220.85,170.64 223.25,168.25 227.17,168.25 228.97,166.45 228.97,166.14 230.61,164.49 v2(231.53,164.49)
